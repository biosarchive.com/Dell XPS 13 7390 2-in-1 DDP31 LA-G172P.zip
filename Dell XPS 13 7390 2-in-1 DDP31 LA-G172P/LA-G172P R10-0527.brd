# Allegro board LA-G172P R10-0527.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RW19  100K_0201_5%  [R_0201]  196.35 56.53 90 top
RW28  22_0201_1%  [R_0201]  193.48 58.14 0 bottom
RW29  100K_0201_1%  [R_0201]  193.48 60.74 0 bottom
RW30  4.7K_0201_5%  [R_0201]  193.48 60.17 0 bottom
RW31  22_0201_1%  [R_0201]  193.48 56.87 0 bottom
RW32  10K_0201_5%  [R_0201]  193.48 63.22 0 bottom
RW33  20K_0201_5%  [R_0201]  193.48 62.58 0 bottom
RW34  10K_0201_5%  [R_0201]  195.57 65.12 0 top
RW35  0_0201_5%  [R0201_0OHM]  193.48 58.71 0 bottom
RW36  0_0201_5%  [R_0201]  195.74 61.99 270 bottom
RW37  0_0201_5%  [R0201_0OHM]  193.48 59.6 0 bottom
RW39  100K_0201_5%  [R_0201]  195.26 57.57 0 bottom
RW40  100K_0201_5%  [R_0201]  196.88 58.69 270 bottom
RW43  100K_0201_5%  [R_0201]  195.76 60.74 0 bottom
RW45  0_0201_5%  [R_0201]  196.88 59.96 270 bottom
RW46  0_0201_5%  [R_0201]  196.84 57.81 90 top
SW1  SKSFABE010_4P  [SW_SKSFABE010_4P]  66.96 25 90 top
SW2  SKSFABE010_4P  [SW_SKSFABE010_4P]  66.96 27.65 270 bottom
TP1  PAD~D  [TPC12]  122.02 50.33 0 top
TP2  PAD~D  [TPC12]  121.95 48.74 0 top
TP3  PAD~D  [TPC12]  154.91 29.06 180 bottom
TP4  PAD~D  [TPC12]  156.69 29.06 180 bottom
TP5  PAD~D  [TPC12]  165.07 38.33 180 bottom
TP6  PAD~D  [TPC12]  163.29 38.33 180 bottom
TP6A4  PAD~D  [TPC12]  14.96 49.5 90 top
TP6A5  PAD~D  [TPC12]  283.33 41.48 0 top
TP7  PAD~D  [TPC12]  128.75 30.45 180 bottom
TP8  PAD~D  [TPC12]  129.51 30.39 180 bottom
TP9  PAD~D  [TPC12]  179.42 23.91 0 top
TP10  PAD~D  [TPC12]  181.39 21.88 0 top
TP11  PAD~D  [TPC12]  176.31 21.06 0 top
TP12  PAD~D  [TPC12]  177.64 21.06 0 top
TP13  PAD~D  [TPC12]  180.31 22.64 0 top
TP14  PAD~D  [TPC12]  178.98 21.06 0 top
TP15  PAD~D  [TPC12]  166.28 28.55 180 bottom
TP16  PAD~D  [TPC12]  161.89 38.33 180 bottom
TP17  PAD~D  [TPC12]  178.85 22.58 0 top
TP18  PAD~D  [TPC12]  133.7 20.61 0 top
TP19  PAD~D  [TPC12]  180.31 21.06 0 top
TP20  PAD~D  [TPC12]  167.99 51.79 0 top
TP22  PAD~D  [TPC12]  177.96 29.06 0 top
TP23  PAD~D  [TPC12]  181.43 50.57 0 top
TP24  PAD~D  [TPC12]  179.79 49.33 0 top
TP27  PAD~D  [TPC12]  144.3 21.18 0 top
TP28  PAD~D  [TPC12]  142.15 20.04 0 top
TP29  PAD~D  [TPC12]  142.91 21.18 0 top
TP30  PAD~D  [TPC12]  143.54 20.04 0 top
TP31  PAD~D  [TPC12]  142.4 18.71 0 top
TP32  PAD~D  [TPC12]  143.92 18.71 0 top
TP37  PAD~D  [TPC12]  122.02 45.12 0 top
TP38  PAD~D  [TPC20]  202.6 45.82 180 bottom
TP39  PAD~D  [TPC20]  203.8 44.17 180 bottom
TP40  PAD~50  [TPC20]  204.44 49.25 180 bottom
TP41  PAD~50  [TPC20]  203.04 49.25 180 bottom
TP42  PAD~50  [TPC20]  203.55 47.73 180 bottom
TP43  PAD~50  [TPC20]  202.28 47.73 180 bottom
TP44  PAD~50  [TPC20]  203.87 45.82 180 bottom
TP45  PAD~12  [TPC12]  7.85 42.71 180 bottom
TP46  PAD~12  [TPC12]  9.14 43.11 180 bottom
TP47  PAD~12  [TPC12]  8.19 41.42 180 bottom
TP48  PAD~12  [TPC12]  9.51 41.76 180 bottom
TP49  PAD~12  [TPC12]  275.28 30.73 0 top
TP50  PAD~12  [TPC12]  276.83 30.66 0 top
TP51  PAD~12  [TPC12]  273.95 31.12 0 top
TP52  PAD~12  [TPC12]  276.06 31.81 0 top
TP53  PAD~D  [TPC12]  155.16 50.01 0 top
TP55  PAD~D  [TPC12]  170.28 43.22 180 bottom
TP56  PAD~D  [TPC12]  167.42 44.23 180 bottom
TP57  PAD~D  [TPC12]  172.19 43.34 180 bottom
TP58  PAD~D  [TPC12]  211.17 69.44 0 top
TP59  PAD~D  [TPC12]  126.02 19.72 0 top
TP60  PAD~D  [TPC12]  127.35 19.72 0 top
TP61  PAD~D  [TPC12]  147.59 29.17 180 bottom
TP62  PAD~D  [TPC12]  148.55 29.07 180 bottom
TP63  PAD~D  [TPC12]  149.19 28.68 180 bottom
TP64  PAD~D  [TPC12]  148.05 28.68 180 bottom
TP65  PAD~D  [TPC12]  166.09 37.5 180 bottom
TP66  PAD~D  [TPC12]  166.15 39.03 180 bottom
TP67  PAD~D  [TPC12]  128.24 41.31 180 bottom
TP68  PAD~D  [TPC12]  134.26 41.35 180 bottom
TP69  PAD~D  [TPC12]  127.86 24.87 180 bottom
TP70  PAD~D  [TPC12]  156.65 18.78 0 top
TP71  PAD~D  [TPC12]  135.99 41.12 180 bottom
TP72  PAD~D  [TPC12]  135.1 41.12 180 bottom
TP73  PAD~D  [TPC12]  135.54 40.61 180 bottom
TP74  PAD~D  [TPC12]  212.44 60.23 180 bottom
TP76  PAD~D  [TPC20]  207.8 26.45 0 top
TP77  PAD~D  [TPC20]  209.39 26.45 0 top
TP78  PAD~D  [TPC20]  211.82 31.62 0 top
TP79  PAD~D  [TPC20]  206.03 51.47 0 top
TP80  PAD~D  [TPC20]  210.92 26.39 0 top
TP81  PAD~D  [TPC20]  211.68 33.06 0 top
TP84  PAD~D  [TPC12]  211.93 58.77 180 bottom
TP85  PAD~D  [TPC20]  202.52 39.06 180 bottom
TP86  PAD~D  [TPC20]  207.36 51.47 0 top
TP87  PAD~D  [TPC12]  132.56 28.68 180 bottom
TP88  PAD~D  [TPC12]  133.55 41.35 180 bottom
TP89  PAD~D  [TPC12]  140.69 28.68 180 bottom
TP90  PAD~D  [TPC12]  139.67 28.68 180 bottom
TP91  PAD~D  [TPC12]  147.04 28.94 180 bottom
TP92  PAD~D  [TPC12]  157.96 40.11 180 bottom
TP93  PAD~D  [TPC12]  141.57 28.68 180 bottom
TP94  PAD~D  [TPC12]  149.82 28.69 180 bottom
TP95  PAD~D  [TPC12]  129.06 41.31 180 bottom
TP96  PAD~D  [TPC12]  165.45 28.55 180 bottom
TP97  PAD~D  [TPC12]  161.51 40.61 180 bottom
TP98  PAD~D  [TPC12]  162.28 39.56 180 bottom
TP99  PAD~D  [TPC12]  130.27 25.25 180 bottom
TP100  PAD~D  [TPC12]  167.36 37.82 90 bottom
TP101  PAD~D  [TPC12]  165.01 50.77 0 top
TP110  PAD~D  [TPC12]  5.18 15.61 180 bottom
TP111  PAD~D  [TPC12]  265.27 13.85 180 top
TP112  PAD~D  [TPC12]  218.79 58.33 0 top
TP113  PAD~50  [TPC20]  134.91 79.41 180 top
TP114  PAD~50  [TPC20]  126.21 77.95 180 top
TP115  PAD~50  [TPC20]  141.01 78.73 180 top
TP116  PAD~50  [TPC20]  134.91 77.95 180 top
TP117  PAD~50  [TPC20]  133.57 77.95 180 top
TP118  PAD~50  [TPC20]  133.57 79.41 180 top
TP119  PAD~50  [TPC20]  132.24 77.95 180 top
TP120  PAD~50  [TPC20]  132.24 79.41 180 top
TP121  PAD~50  [TPC20]  130.27 77.95 180 top
TP122  PAD~50  [TPC20]  130.27 79.41 180 top
TP123  PAD~50  [TPC20]  128.94 77.95 180 top
TP124  PAD~50  [TPC20]  128.94 79.41 180 top
TP125  PAD~50  [TPC20]  127.6 77.95 180 top
TP126  PAD~50  [TPC20]  127.6 79.41 180 top
TP127  PAD~50  [TPC20]  125.19 78.74 180 top
TP128  PAD~50  [TPC20]  126.33 79.34 180 top
TP132  PAD~50  [TPC20]  159.67 79.35 180 top
TP133  PAD~50  [TPC20]  159.67 78.01 180 top
TP134  PAD~50  [TPC20]  158.34 78.01 180 top
TP135  PAD~50  [TPC20]  158.34 79.35 180 top
TP136  PAD~50  [TPC20]  156.99 78.48 180 top
TP137  PAD~50  [TPC20]  157 79.44 180 top
TP138  PAD~50  [TPC20]  157.03 77.57 180 top
TP139  PAD~50  [TPC20]  155.78 77.57 180 top
TP140  PAD~50  [TPC20]  155.77 78.48 180 top
TP141  PAD~50  [TPC20]  155.76 79.44 180 top
TP142  PAD~50  [TPC20]  167.53 79.25 180 top
TP143  PAD~50  [TPC20]  165.64 78.01 180 top
TP144  PAD~50  [TPC20]  165.64 79.35 180 top
TP145  PAD~50  [TPC20]  162.21 77.82 0 top
U7  -  [SY6288C20AAC_SOT23-5]  103.8 69.5 270 top
U15  MC74VHC1G08DFT2G_SC70-5  [TC7SH08FU_SSOP5]  178.34 18.63 90 top
U31  JW7110DFNC-TRPBF_DFN14_3X2  [EM5209VF_DFN14_3X2-S]  202.79 11.74 0 top
U34  JW7110DFNC-TRPBF_DFN14_3X2  [EM5209VF_DFN14_3X2-S]  173.78 66.92 0 top
U36  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  45.71 15.67 90 top
U51  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  18.64 27.1 225 top
U55  -  [SY6288C20AAC_SOT23-5]  169.32 69.88 180 top
U60  -  [AOZ1336DI_DFN8_2X2]  269.06 19.21 90 top
U712  ST33HTPH2032AHC1_VQFN32_5X5  [SLB9670VQ1P2-FW4P4X_VQFN32_5X5]  208.87 10.08 0 top
U733  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  204.14 25.77 90 top
U734  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  187.43 12.97 0 top
U735  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  215.5 43.2 0 top
UA1  ALC3281-CG  [ALC3281-CG_MQFN48_6X6-S]  27.74 13.18 90 top
UC1  ICL-U_BGA1526  [ICL-U_BGA_1526P-T]  126.04 24.2 270 top
UC2  MC74VHC1G08DFT2G_SC70-5  [TC7SH08FU_SSOP5]  173.96 15.95 90 top
UC4  MC74VHC1G08DFT2G_SC70-5  [TC7SH08FU_SSOP5]  187.55 47.23 270 top
UC5  MC74VHC1G08DFT2G_SC70-5  [TC7SH08FU_SSOP5]  187.56 50.88 270 top
UC6  -  [MC74VHC1G32DFT2G_SC70-5]  181.79 41.44 90 top
UC7  -  [MC74VHC1G32DFT2G_SC70-5]  187.55 30.07 270 top
UC8  SN74AUP1G97DRLR_SOT6  [SN74AUP1G97DRLR_SOT_6P]  109.66 18.46 90 bottom
UC9  -  [MC74VHC1G32DFT2G_SC70-5]  184.12 37.57 0 top
UC10  MC74VHC1G08DFT2G_SC70-5  [TC7SH08FU_SSOP5]  151.15 16.61 0 top
UC11  SN74AUP1G97DRLR_SOT6  [SN74AUP1G97DRLR_SOT_6P]  155.41 18.87 180 top
UC12  -  [AOZ1334DI-01_DFN8-7_3X3]  133.73 16.14 90 top
UC13  -  [AOZ1334DI-01_DFN8-7_3X3]  135.77 15.69 0 top
UC22  -  [AOZ1334DI-01_DFN8-7_3X3]  147.2 17.47 0 top
UC23  -  [AOZ1334DI-01_DFN8-7_3X3]  170.44 56.84 0 top
UC24  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  193.73 52.06 90 top
UC25  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  68.6 16.95 180 top
UC27  -  [AOZ1334DI-01_DFN8-7_3X3]  108.46 47.64 90 top
UC28  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  98.19 5.5 90 top
UC29  MC74VHC1G08DFT2G_SC70-5  [TC7SH08FU_SSOP5]  189.22 33.3 90 top
UC30  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  241.44 16.41 90 top
UC31  -  [SY6288C20AAC_SOT23-5]  267.89 22.06 90 top
UCR1  -  [RTS5242-GR_QFN32_4X4-S]  277.95 28.04 0 top
UD1  H9HCNNNBUUMLHR-NLM_FBGA200  [H9HCNNNBUUMLHR-NLM_FBGA_200P]  164.82 54.71 180 top
UD2  H9HCNNNBUUMLHR-NLM_FBGA200  [H9HCNNNBUUMLHR-NLM_FBGA_200P]  151.23 54.71 180 top
UD3  H9HCNNNBUUMLHR-NLM_FBGA200  [H9HCNNNBUUMLHR-NLM_FBGA_200P]  125.28 68.36 0 top
UD4  H9HCNNNBUUMLHR-NLM_FBGA200  [H9HCNNNBUUMLHR-NLM_FBGA_200P]  110.42 68.36 0 top
UE1  MEC5105_WFBGA169_11X11  [MEC5105_WFBGA_169P]  207.1 65.96 0 top
UE5  -  [74AUP1G07FZ4-7_X2-DFN1410-6]  203.15 66.53 90 top
UE6  -  [SN74LVC1G123DCUR_VSSOP8]  211.92 51.4 270 top
UE8  74AUP1G07SE-7_SOT353-5  [74AUP1G07GW_TSSOP5]  174.16 19.26 90 top
UE10  -  [74AUP1G07FZ4-7_X2-DFN1410-6]  201.38 51.64 180 top
UH1  MC74VHC1G08DFT2G_SC70-5  [TC7SH08FU_SSOP5]  176.56 53.93 90 top
UH6  MC74VHC1G08DFT2G_SC70-5  [TC7SH08FU_SSOP5]  176.59 57.03 90 top
UH8  W25Q256JVEIQ_WSON8_8X6  [W25Q256JVEIQ_WSON8_8X6-S]  225.78 16.1 270 top
UM1  TS3DS10224RUKR_WQFN20_3X3  [TS3DS10224RUKR_WQFN20_3X3-S]  14.79 53.54 90 top
UM2  TS3DS10224RUKR_WQFN20_3X3  [TS3DS10224RUKR_WQFN20_3X3-S]  274.44 56.32 180 top
UPD1  SN1806026RSHR VQFN 56P  [PTPS65988DHRSHR_VQFN56_7X7-S]  9.86 19.86 45 top
UPD2  SN1806026RSHR VQFN 56P  [PTPS65988DHRSHR_VQFN56_7X7-S]  278.33 16.15 0 top
UPD3  W25Q64JVZPIQ_WSON8_6X5  [W25Q64FVZPIG_WSON8_6X5]  17.6 21.77 225 bottom
UPD4  W25Q64JVZPIQ_WSON8_6X5  [W25Q64FVZPIG_WSON8_6X5]  241.11 12.17 270 bottom
URT1  BURNSIDE-BRIDGE_BGA105  [BURNSIDE-BRIDGE_BGA_105P-T]  9.22 43.09 180 top
URT2  BURNSIDE-BRIDGE_BGA105  [BURNSIDE-BRIDGE_BGA_105P-T]  277.09 35.16 180 top
US1  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  218.14 10.85 180 top
USSD1  S-SUN_PM971  [S-SUN_PM971_291P-T]  193.9 47.67 0 top
UT1  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  17.58 36.05 90 top
UT2  AOZ1336DI_DFN8_2X2  [AOZ1336DI_DFN8_2X2-S]  287.76 28.21 0 top
UTS1  W25Q64JVZPIQ_WSON8_6X5  [W25Q64FVZPIG_WSON8_6X5]  9.78 32.74 270 top
UTS2  W25Q64JVZPIQ_WSON8_6X5  [W25Q64FVZPIG_WSON8_6X5]  250.38 17.63 270 top
UW2  -  [74AUP1G07FZ4-7_X2-DFN1410-6]  195.49 63.84 0 bottom
UWL1  9560.D2WGE2_152P  [INTEL_9560PD2WGE2_152P]  180.42 71.37 0 top
YC1  32.768KHZ_12.5PF_9H03200042  [Y_9H03200042_2P]  171.61 53.63 180 top
YE2  32.768KHZ_9PF_X1A000141000200  [Y_X1A000141000200_2P]  205.73 70.71 0 top
YH1  38.4MHZ_10PF_8Y38420005  [Y_8Y38420005_4P]  181.63 29.7 90 top
YT1  25MHZ_20PF_FW2500025Z  [Y_FW2500025Z_4P]  16.12 48.71 0 top
YT2  25MHZ_20PF_FW2500025Z  [Y_FW2500025Z_4P]  286.44 40.93 270 top

## Library data of the parts
C1-C10 C37 C38 C46 C92 C95 C100 C112 C200 C216 C218 C220 C223 C229 C230 C233 C235 C240 C243 C246 C248 C252 C256 C276-C278 C285 C418-C420 C422 C451-C455 C622 C635 C640 C760 C761 C800 C801 C1040 C1226 C1229 C1468 C1469 C1539 C1540 C1544 C1675 C1678 C1681 C1684 C1686-C1691 C1695-C1700 C1704-C1707 C1714-C1723 C2990 C3011 C4180 C4183 C4186 C4195 C4198 C4199 C4201-C4204 C4207 C4210-C4212 C4216 C4221 C4230 C4231 CA9 CA11 CA13 CA14 CA17 CA23 CA24 CA26 CA30 CA33 CA36 CA37 CA40 CA44-CA50 CA52 CA54 CA55 CA57-CA64 CA84 CA85 CC1 CC17 CC23 CC30 CC77 CC130-CC135 CC144 CC145 CC147 CC148 CC153-CC156 CC164 CC167 CC168 CC170 CC171 CC173-CC175 CC177 CC180-CC185 CC189 CC191 CC260 CC386 CC394 CC395 CC620-CC622 CC625 CC629 CC632 CC633 CC638 CC643-CC668 CC721 CC727 CC735-CC740 CD13-CD57 CD71-CD81 CD91 CE68 CE69 CE88 CE108 CE110 CH10-CH13 CH35 CH44 CH45 CH55 CH56 CM1 CM2 CPD1-CPD3 CPD11-CPD13 CR19 CR20 CS1-CS8 CS16-CS27 CS89 CS91-CS95 CT1 CT3 CT206 CT207 CT211 CT212 CT302 CT305-CT307 CT310-CT317 CT338-CT345 CT348-CT355 CT361 CT363 CW1 CW2 CW4-CW8 CW10-CW12 PC305 PC405 PC421 PC911 PC1051-PC1055 PC1335-PC1345 PC1405 PC1506 = C_0201
C41 C47-C49 C52 C58 C87 C94 C217 C224 C227 C234 C237 C244 C245 C421 C625 C628 C750 C1131 C1132 C1224 C1387 C1467 C1676 C1683 C4181 C4182 C4189 C4197 C4205 C4209 C4213 C4217 C4222 C4227 CA15 CA19 CA20 CA22 CA25 CA29 CA31 CA32 CA38 CA39 CA51 CA53 CA78-CA83 CC129 CC136-CC140 CC188 CC511 CC707 CD3-CD12 CD83-CD90 CD303-CD309 CE39 CE76 CE89 CE105-CE107 CE109 CE312 CE410 CE413 CE429-CE432 CH1-CH4 CPD4-CPD7 CPD14 CPD16 CPD17 CPD41 CPD42 CPD49 CPD51 CR21-CR25 CS90 CT200 CT201 CT210 CT303 CT304 CT318 CT319 CT325 CT346 CT356 CT362 CV633 CV651 CW3 CW9 PC200-PC202 PC210-PC213 PC223 PC224 PC226-PC229 PC233-PC241 PC243-PC245 PC300-PC302 PC313 PC400-PC402 PC414 PC416-PC418 PC430 PC510 PC704 PC705 PC714 PC801 PC804 PC805 PC909 PC910 PC1014-PC1023 PC1031-PC1039 PC1103 PC1202 PC1322 PC1323 PC1400-PC1402 PC1511 = C_0402
C50 C1124 C1125 C1223 CA10 CA12 CA18 CA21 CC141 CC142 CC176 CC308 CC387-CC392 CPD8 CPD18 CPD19 CPD40 CPD47 CPD48 CT347 CT357 CT365 CT366 PC225 PC230-PC232 PC303 PC304 PC306-PC311 PC314 PC403 PC404 PC406-PC408 PC410-PC412 PC415 PC419 PC420 PC422 PC423 PC425-PC428 PC431 PC512 PC715 PC716 PC802 PC803 PC806-PC809 PC906-PC908 PC912 PC1004-PC1012 PC1024-PC1030 PC1220 PC1221 PC1321 PC1403 PC1404 PC1406-PC1409 PC1507-PC1510 PC1512 = C_0603
C96 C97 = C_0201: room: +3VS_AUDIO
CD58 CD60-CD63 = C_0201: room: NGFF SSD
CD59 CD64-CD70 CR6 = C_0201: room: PCH
CE42-CE45 CE48-CE51 CE54-CE58 CE60 CE63-CE65 CE67 CE104 = C_0201: room: KBC
CE46 CE52 CE53 CE61 CE66 CE75 CE79 CE86 CE93 = C_0402: room: KBC
CE47 = C_0603: room: KBC
CH40 CH46 CH47 CH49-CH54 CH57 = C_0201: room: CPU
CH48 = C_0402: room: CPU
CP10 = C_0402: room: TBT_CCG5
CR1-CR4 CR8-CR11 CR13 CR15-CR18 = C_0201: room: CARD READER
CR5 = C_0402: room: CARD READER
CR7 = C_0402: room: PCH
CT2 = C_0201: room: THUNBERBOLT
CT4-CT9 = C_0201: room: TBT
CT10 CT11 CT14 CT15 = C_0201: room: TBT_TYPEC
CT12 CT13 CT16 = C_0201: room: NONTBT_TYPEC
CT30-CT33 CT35 CT36 CT38-CT45 CT49-CT54 CT56-CT64 CT68-CT78 CT80-CT82 CT84 = C_0201: room: ETY-ROOM
CT34 CT37 CT55 CT79 = C_0603: room: ETY-ROOM
D1-D3 D23 = BAT54CW_SOT323-3
D12 D132 D481 = RB751V40_SC76-2
D13 D14 DA8 DA9 DA14 DA15 = AZ5B75-01BPR7G_CSP0603P2Y2
D16 PD100 PD101 = TVNST52302AB0_SOT523-3
D20 D21 D438 D468 D474 D475 DA10 DZ3 DZ4 = RB751S40T1G_SOD523-2
D50 D51 D75-D90 D407-D422 D444-D450 D465 D466 D471-D473 D476 D477 = ESD101-B1-02ELS_TSSLP-2-4-2
D116 DC1 DC2 DE1-DE5 DV11 DV12 PD201 PD202 PD600-PD603 RTCD3 = RB520SM-30T2R_EMD2-2
D459 D460 = AZ4520-01FPR7G_DFN1610P2E2
D461 D462 = NSR20F30NXT5G_DSN2-2
D469 D470 = BZT52C6V2LP-7_X1-DFN1006-2-2
DA1 DA3-DA5 DA13 = ESD207-B1-02EL_TSLP-2-19-2
DA11 = AZ5125-01HPR7G_SOD523-2
DT1 = 1N4148WS-L_SOD323-2: room: TBT_TYPEC
DT2 = 1N4148WS-L_SOD323-2
F1 F5 = F_T0603FF0500TM
F2 PR205 PR210 PR303 PR403 PR415 PR708 PR801 PR804 PR902 PR904 PR1401 R87 R626 R6136 = R_0603
F3 = F_F0603FA3000V032T
F4 = F_T0603FF1000TM
FD1-FD4 = FIDUCIAL_C40M80
H1-H3 H6 H7 H9-H12 = H_2P0-G
H4 = H_2P0
H5 H13 H22-H25 = H_2P4
H8 = H_2P9-G
H14 H15 = H_2P6
H16 = H_2P6-G
H17-H21 = H_1P9-G
H27 = H_1P3N
H29 = H_2P5X5P5N
H33 H35-H38 = H_0P5X2P3N
H34 = H_0P4X2P2N
JANTL1 JANTR3 = CLIP_2X2P5-NP
JANTL3 JANTR1 = BELLW_10093-1021_4P
JAPS1 = ACES_50506-01841-P01_18P: room: KB+DMIC
JCR1 = T-SOL_158-9090302600_18P-T: room: CARD READER
JDB1 JDB2 JDEBUG1 JDEBUG2 JSPI1 = ACES_50521-01041-P01_10P
JDB3 JDB4 = JXT_FP241AH-006GAAM_6P
JDEG1 = ACES_50521-01041-P01_10P: room: KBC
JEDP1 = I-PEX_20879-040E-01_40P-T
JFAN1 JFAN2 = CVILU_CF35042D0RD-NH_4P-T
JFP1 = TWVM_FPC0510-08RC-TAGHA_8P: room: FP
JHP1 = UNIMI_FCECBE015_6P-T
JIO1 = ACES_51515-0510M-P01_51P-T: room: ETY-ROOM
JMIPI60 = SAMTE_QSH-030-01-H-D-A_60P-T
JNGFF1 = BELLW_80149-2021_67P-S
JRTC1 = ACES_50278-00201-001_2P: room: RTC
JSP1-JSP3 = EMIST_SU-15AG_1P-T
JSP4-JSP10 = EMIST_CL-XXG0629_1P
JSPK1 = ACES_50208-00801-003_8P
JSSD1 = ACES_51524-0240N-001_24P
JT101 = UNIMI_LLGCBE018_6P-T
JTAG2 = SHORTPADS: User Part Number: PART#; room: KBC
JUART1 = CVILU_CI1804M1VRA-NH_4P
JUFC1 = I-PEX_20879-030E-01_30P-T
JUSBC1 JUSBC2 = FOX_UT12123-10001-7H_24P-T: room: TBT_TYPEC
L12 L15 = MURAT_BLM15PX330SN1D_2P
L24 = MURAT_LQP03TN1N8B00D_2P
L26 ML6 ML7 ML16-ML18 = INPAQ_HCM1012GH900BP_4P
L27 = MURAT_LQP03TN1N2B02D_2P
LA1 LT9 LT11-LT14 PL300 PL302 PL400 PL402 PL404 PL405 PL902 PL903 PL1205 PL1400 = TAI-T_HCB2012KF-121T50_2P
LA2 = TAI-T_HCB1608KF-121T3_L0603_2P
LA5-LA8 = MURAT_BLM18SG260TN1D_2P
LA18 LA19 = MURAT_BLM15AX700SN1D_2P
LC1 = TAI-T_UHP252012NF-R68M_2P
LC2 LS2 PL501 PL1500 = MURAT_BLM18EG221SN1D_2P
LED1 = LED_HT-F196BP5_2P
LED2 = LED_HT-F196BP5_2P: room: BATTERY LED
LT1 LT2 = TAI-T_HCB2012KF-121T50_2P: room: ETY-ROOM
LT3 LT15 = MURAT_BLM18KG331SN1D_2P
LT5 = MAG_MLV-YT10NR68N-M1L_2P
LT8 = MAG_MLV-YT10NR68N-M1L_2P: room: TBT_TYPEC
LT10 = TAI-T_HCB2012KF-121T50_2P: room: TBT_TYPEC
LV1 = MURAT_BLM15PX221SN1D_2P
ML1 = INPAQ_HCM1012GH900BP_4P: room: FP
PC100 = C_0402: room: CCG5_5V_PATH_12
PC101 PC102 = C_0402: room: CCG5_PATH_12
PC203-PC209 PC214-PC217 PC221 PC222 PC1222 PC1223 = C_0603-H1_2
PC218 PC219 PC432 PC433 PC1212 = C_B3
PC500 PC503 PC504 = C_0402: room: PWR_CHARGER
PC501 PC502 PC506-PC509 = C_0603: room: PWR_CHARGER
PC505 = C_0201: room: PWR_CHARGER
PC600 = C_0402: room: PWR_3V1
PC700-PC703 = C_0805
PC706 PC711 PC713 = C_0402: room: +1VALWP
PC708-PC710 PC712 = C_0603: room: +1VALWP
PC810 PC811 = C_0402: room: PWR_1.2VDDR
PC900 PC901 = C_0402: room: PWM_+1.05_VMM
PC902 PC904 PC905 = C_0603: room: PWM_+1.05_VMM
PC903 = C_B3: room: PWM_+1.05_VMM
PC1000-PC1002 PC1050 PC1300 PC1334 = C_TEPSLB30J157M-35-8R
PC1013 = C_0603: room: VCCIO
PC1100-PC1102 PC1104 PC1105 PC1107 = C_0402: room: ISL95859
PC1106 = C_0201: room: ISL95859
PC1108 = C_0402: room: ETY-ROOM
PC1200 PC1201 PC1206 PC1213-PC1215 PC1219 = C_0402: room: PWR_CPU_VCCCORE
PC1203 PC1204 PC1216 PC1217 = C_0603-H1_2: room: PWR_CPU_VCCCORE
PC1207 PC1208 = C_0603: room: PWR_CPU_VCCCORE
PC1209-PC1211 = C_B3: room: PWR_CPU_VCCCORE
PC1301 PC1302 = C_TEPSLB30J157M-35-8R: room: PWR_CPU_VCCGT
PC1304-PC1311 = C_0603: room: PWR_CPU_VCCGT
PC1312-PC1317 = C_0402: room: PWR_CPU_VCCGT
PC1318 PC1319 = C_0402: room: PWR_CPU_VCCSA
PC1320 = C_0603: room: PWR_CPU_VCCSA
PC1411 = C_0402: room: CPU_OUTPUT_MLCC
PC1412 = C_0603: room: CPU_OUTPUT_MLCC
PC1501 = C_0402: room: PWR_1.8VALW
PC1502 PC1505 = C_0402: room: PWR_1.8VU
PC1503 PC1504 = C_0603: room: PWR_1.8VU
PD200 = SMF4L22A_SOD123FL2
PD604 RTCD2 RTCD4 RTCD5 = LBAT54HT1G_SOD323-2
PJP300 PJP400 PJP401 PJP500 PJP700 PJP1400 PJP1500 = JUMP_43X118
PJP800 = JUMP_43X79: room: PWR_1.2VDDR
PL100-PL102 = TAI-T_HCB2012KF-121T50_2P: room: CCG5_PATH_12
PL200 = TOKO_1277AS-H-1R0N-P2_2P
PL201 = MAG_MMD-10BZN2R2M-M1L_2P
PL301 = CHILI_MHCB06015-1R5M-C1_2P
PL401 PL403 = MAG_MMD-05AHN1R5M-M1L_2P
PL500 PL1501 = TOKO_FDSD0412-H-1R0M-P3_2P
PL700 = TAI-T_HCB2012KF-121T50_2P: room: +1VALWP
PL701 = MAG_MMD-04AE-R47M-M1L_2P: room: +1VALWP
PL800 = MURAT_BLM18EG221SN1D_2P: room: PWR_1.2VDDR
PL801 = CHILI_HEI322512A-1R0M-Q8_2P: room: PWR_1.2VDDR
PL900 = CHILI_MHCB06024-R15M-C1R885_2P
PL1200 PL1201 = CHILI_MHCB06024-R15M-C1R885_2P: room: PWR_CPU_VCCCORE
PL1202-PL1204 = TAI-T_HCB2012KF-121T50_2P: room: PWR_CPU_VCCCORE
PL1401 = CHILI_MHCI04015-R68M-R8_2P
PQ100 QE18 QM1 = 2N7002KDW_SOT363-6
PQ201 PQ203 = AON6962_DFN5X6D-8-7: room: CCG5_LPS_12
PQ202 = AON7405_DFN8-5: room: CCG5_LPS_12
PQ205 = L2N7002WT1G_SC70-3: room: CCG5_LPS_12
PQ600 = L2N7002WT1G_SC70-3
PR100 PR102 PR104 PR213 PR214 PR220 PR223 PR300 PR400 PR412 PR607 PR608 PR803 PR915 PR916 PR1116 PR1118 PR1121 PR1122 PR1408 R620 R638 R720 R1095 R1096 R5779 R6089 R6090 RA18 RA22 RA23 RA25 RA29 RC168 RC505 RC583 RC696 RC736 RC745 RC747 RD400 RE305 RE402 RE405 RE411 RE417 RE489 RE490 RH565 RPD84 RPD93 RT79 RT88 RT180 RT181 RT184 RT185 = R0402_0OHM
PR101 PR103 PR232 PR301 PR308 PR401 PR408 PR420 PR509 PR802 PR901 PR903 PR906-PR908 PR1111-PR1113 PR1119 PR1406 PR1507 R25 R29 R31 R32 R36-R41 R54 R111-R114 R137 R140-R155 R157 R160-R163 R167-R176 R178 R188 R193-R195 R210 R220 R230 R232 R236 R238 R239 R245 R246 R249 R257 R260 R261 R267 R270-R272 R274 R283 R288 R311 R322 R335 R374 R375 R410 R444 R445 R466 R471 R529-R532 R534 R544 R545 R600 R609 R610 R614 R616-R618 R621-R624 R627-R629 R644 R648 R649 R656 R658 R660 R666 R667 R677-R681 R700 R701 R703 R704 R709 R710 R724-R726 R789 R801 R1000 R1133-R1136 R1141-R1143 R2745 R6128 R6129 R6137 R6143 R6155 R6157 R6162 R6168 R6171-R6175 R6183-R6185 R6194 R6204-R6208 RA1-RA3 RA6 RA8-RA10 RA13 RA14 RA17 RA21 RA30 RA57 RA62-RA66 RC1-RC3 RC8 RC12 RC14 RC15 RC17 RC20 RC145-RC147 RC150 RC151 RC180 RC181 RC201-RC203 RC222 RC223 RC244 RC247 RC254 RC336 RC338 RC339 RC344 RC351 RC367-RC369 RC432-RC434 RC503 RC504 RC508 RC569 RC595 RC602 RC604 RC606 RC609-RC612 RC614-RC617 RC623 RC626 RC627 RC631 RC634 RC644 RC647 RC648 RC655 RC656 RC663-RC668 RC671-RC673 RC679 RC680 RC682 RC687 RC691-RC694 RC698 RC700 RC701 RC711 RC712 RC717 RC723 RC724 RC727 RC730 RC734 RC735 RC737-RC744 RC746 RC748-RC752 RD1-RD4 RD21-RD24 RD26 RD28 RD30 RD32 RD34 RD36 RD38 RD40 RD41 RD43 RD44 RD300 RE48 RE87 RE93 RE95-RE102 RE122 RE123 RE152 RE186 RE208 RE210-RE213 RE237 RE312 RE321 RE322 RE412 RE426 RE445 RE446 RE449 RE451 RE457-RE460 RE469 RE470 RE472 RE473 RE475 RE478 RE480 RE481 RE483-RE488 RE491 RE493 RE494 RE520-RE524 RE526 RH1 RH4-RH10 RH12 RH14-RH17 RH23-RH27 RH39-RH41 RH114 RH143-RH145 RH185 RH200-RH203 RH217 RH297 RH298 RH300 RH301 RH460 RH475 RH572 RH573 RH575 RH587 RH588 RH591 RH592 RH595 RH601 RH603-RH607 RH610 RH612-RH618 RH621 RH629-RH637 RH640 RH641 RH643 RH646 RH647 RH653-RH655 RH658 RH660 RH661 RH665-RH667 RH671 RH672 RH675 RH682-RH692 RH705 RH706 RH709 RH713 RH715-RH725 RH727 RH728 RH730-RH734 RH738-RH743 RH745-RH749 RPD11-RPD14 RPD59-RPD62 RPD89-RPD92 RPD99-RPD102 RPD114 RPD115 RPD128 RPD129 RPD131 RPD136 RPD137 RPD139 RPD141 RPD142 RPD144 RPD146 RPD147 RPD155 RPD167-RPD170 RPD173 RPD174 RPD177 RPD181-RPD184 RPD189-RPD194 RPD196-RPD199 RPD201-RPD205 RR11 RS207 RS208 RS377 RS378 RT1 RT2 RT8 RT12 RT15 RT22 RT53-RT56 RT63-RT65 RT73 RT95 RT97 RT98 RT101 RT102 RT109 RT118-RT123 RT150 RT151 RT158-RT160 RT162 RT163 RT169 RT170 RT172-RT179 RT186 RT187 RT189 RT190 RT193-RT196 RT200-RT203 RT212-RT219 RT222-RT225 RTCR2-RTCR4 RW1 RW15 RW19 RW28-RW34 RW36 RW39 RW40 RW43 RW45 RW46 = R_0201
PR105 PR110 PR134 PR201 PR204 PR207 PR221 PR222 PR224-PR227 PR231 PR236 PR304 PR306 PR307 PR309 PR310 PR404 PR406 PR407 PR409 PR411 PR416 PR418 PR419 PR421 PR423 PR510 PR603 PR712 PR900 PR1114 PR1117 PR1120 PR1123 PR1300 PR1403 PR1409 R30 R123 R138 R200 R231 R360 R390 R612 R634 R655 R687 R688 R694 R931 R932 R2751 R5768 R5769 RA36 RA41 RC165 RC582 RC589 RE479 RE525 RTCR1 RW4-RW7 = R_0402
PR106 PR108 = R_0402: room: CCG5_PATH_12
PR200 PR211 = R_1206_4P-D
PR202 PR203 = R_0402: room: AC_DISCONNECT
PR206 PR208 PR215 RD45 RD46 = R_1206
PR212 = R0201_0OHM: room: AC_DISCONNECT
PR216 = R_1206: room: BATT_CONNECTOR
PR217 PR219 PR230 = R_0402: room: BATT_CONNECTOR
PR218 = R0402_0OHM: room: BATT_CONNECTOR
PR229 PR413 PR912 PR1115 PR1204 PR1205 PR1400 R156 R190-R192 R201 R208 R213 R244 R247 R273 R300 R312 R452 R456 R470 R533 R633 R636 R651 R652 R672 R702 R747 R787 R800 R808 R1015 R1016 R1150 R6114-R6118 R6141 R6142 R6152 R6163 R6164 R6166 R6169 R6170 R6181 R6193 R6199 RA27 RA28 RA58 RC226 RC255 RC430 RC601 RC603 RC605 RC619 RC624 RC636 RC640 RC651 RC657 RC683-RC686 RC688-RC690 RC695 RC697 RC699 RC702-RC704 RC731 RD25 RD27 RD29 RD31 RD33 RD35 RD37 RD39 RD42 RE428 RE431 RE448 RE461-RE464 RE467 RE468 RE471 RE476 RE477 RE482 RE492 RH11 RH13 RH207 RH280 RH312 RH584 RH586 RH594 RH600 RH622 RH625 RH638 RH639 RH645 RH659 RH729 RH735-RH737 RH744 RM1 RM2 RM9-RM22 RPD17 RPD21 RPD22 RPD88 RPD97 RPD105 RPD106 RPD109 RPD112 RPD113 RPD123 RPD124 RPD126 RPD127 RPD130 RPD132 RPD134 RPD135 RPD138 RPD149-RPD154 RPD157 RPD163-RPD166 RPD171 RPD172 RPD185-RPD188 RR12 RT59 RT62 RT112 RT113 RT116 RT117 RT124 RT125 RT152 RT164-RT168 RT171 RT197-RT199 RW8 RW13 RW17 RW35 RW37 = R0201_0OHM
PR233 PR234 = R0402_0OHM: room: CCG5_LPS_12
PR311 PR410 PR422 PR910 PR1411 PR1509 RS200 = R_0805
PR501 PR502 PR504 = R_0402: room: PWR_CHARGER
PR503 = R_0201: room: PWR_CHARGER
PR506 = R_0805: room: PWR_CHARGER
PR507 = R_0603: room: PWR_CHARGER
PR600-PR602 PR604-PR606 = R_0402: room: PWR_3V1
PR702-PR704 PR706 = R_0201: room: +1VALWP
PR705 = R_0402: room: +1VALWP
PR707 = R_0805: room: +1VALWP
PR1100-PR1102 PR1104 PR1106-PR1108 PR1127-PR1129 PR1133 PR1134 = R_0402: room: ISL95859
PR1103 PR1125 = R0201_0OHM: room: ISL95859
PR1109 PR1126 = R_0201: room: ISL95859
PR1110 = R0402_0OHM: room: PWR_CPU_CONTROLLER
PR1124 PR1130-PR1132 = R0402_0OHM: room: ISL95859
PR1200 PR1202 = R0402_0OHM: room: PWR_CPU_VCCCORE
PR1201 PR1203 = R_1206: room: PWR_CPU_VCCCORE
PR1502 = R_0603: room: PWR_1.8VALW
PR1503 = R_0402: room: PWR_1.8VALW
PT200 TP1-TP6 TP6A4 TP6A5 TP7-TP20 TP22-TP24 TP27-TP32 TP37 TP45-TP53 TP55-TP74 TP84 TP87-TP101 TP110-TP112 = TPC12
PU200 = ISL88738HRTZ-T_TQFN32_4X4
PU300 = NB502GQ-Z_QFN16_3X3: room: 3V_LDO
PU400 PU401 = NB502GQ-Z_QFN16_3X3
PU500 PU1500 = NB691GG-Z_QFN11_2X2
PU600 UE6 = SN74LVC1G123DCUR_VSSOP8
PU700 = RT6243BGQVF_VQFN18_3P5X3P5: room: +1VALWP
PU800 = NB691GG-Z_QFN11_2X2: room: PWR_1.2VDDR
PU900 = MP2941GL-Z_QFN19_3X4: room: PWM_+1.05_VMM
PU1100 = MP2940AGRT-0010-Z_TQFN28_4X4
PU1200 PU1201 = MP86902-BGLT-Z_TQFN21-15_3X4: room: ETY-ROOM
PU1400 = NB693GQ-Z_QFN16_3X3
Q3 Q348 QE15 QE19 QE23 QRTC1 = L2N7002WT1G_SC-70-3
Q15 = SI3457BDV-T1-E3_TSOP6
Q16 = L2N7002DW1T1G_SC88-6
Q30 QC2 QW2 = PMDXB600UNE_DFN1010B-6
Q124 Q350 QC1 QE3 QE4 QE8 QE10 QE17 QE22 QF1 QF2 QT1 QT2 QW1 = PMBT3904MB_SOT883B
Q349 = LP2301ALT1G_SOT23-3
QE14 = PMBT3904MB_SOT883B: room: KBC
QE16 QE25 = LMBT3904WT1G_SC70-3
QR1 = PMBT3904MB_SOT883B: room: CARD READER
QV18 QV20 = MMBT3906LP-7B_X1-DFN1006-3
QV19 QV21 = MMBT3904LP-7B_X1-DFN1006-3
QZ20 = LMUN5111T1G_SC70-3
R24 R204 R211 R216 R227 R441 R669 R670 R5717 R6048 R6133 R6135 R6161 R6182 RC120 RC139 RC587 RC592 RC630 RC639 RC643 RC659 RC718 RE49 = R0603_0OHM
R164 = R_0201: room: DP_MUX1
R165 R166 RT10 RT11 RT13 RT14 RT20 RT30 RT33-RT45 RT71 RT84 = R_0201: room: ETY-ROOM
R222 = R0402_0OHM: room: FP
R716 = R0805_0OHM
RC13 RC16 = R_0201: room: CMC
RE1 = R_0201: room: FAN1
RE10 RE14 RE15 RE21 RE22 RE29 = R_0201: room: TPM
RE106 = R0402_0OHM: room: KBC
RE108 RE109 RE111-RE113 RE124 RE130 RE133 RE137 RE142 RE154 RE156 RE157 RE159 RE160 RE164 RE172 RE183 RE184 RE193 RE201-RE206 RE215 RE219 RE244 RE245 RE247 = R_0201: room: KBC
RE115 RE125 RE126 RE153 RE158 RE178 RE194 RE199 = R_0402: room: KBC
RE147 RE185 RE209 RE248 = R0201_0OHM: room: KBC
RE187 RT72 = R_0201: room: AUDIO_CODEC
RE200 = R_0201: room: TOUCH
RH42 RH57 RH218 = R0201_0OHM: room: CPU
RH46 RH64 RH80 = R_0201: room: CPU
RH95 RH96 RH98 RH111-RH113 RH129 RH139 RH141 RH142 = R_0201: room: PCH
RPD96 RPD121 = R1206_0OHM
RR1 = R_0402: room: CARD READER
RR2-RR4 RR6 RR8 RR9 = R0201_0OHM: room: CARD READER
RR10 = R_0201: room: CARD READER
RT3 RT4 RT6 RT7 RT9 RT16 = R_0201: room: TBT
RT17 RT93 = R_0201: room: AR
RT18 RT21 RT23 = R_0201: room: GRAPHICS
RT19 RT50 = R_0402: room: ETY-ROOM
RT83 = R0201_0OHM: room: ETY-ROOM
RT94 = R0201_0OHM: room: AR
RTCD6 = BAT54HT1G_SOD323-2
SW1 = SW_SKSFABE010_4P: room: PCH
SW2 = SW_SKSFABE010_4P
TP38-TP44 TP76-TP81 TP85 TP86 TP113-TP128 TP132-TP145 = TPC20
U7 U55 UC31 = SY6288C20AAC_SOT23-5
U15 = TC7SH08FU_SSOP5: room: ETY-ROOM
U31 U34 = EM5209VF_DFN14_3X2-S
U36 U51 U733-U735 UC24 UC25 UC28 UC30 US1 UT1 = AOZ1336DI_DFN8_2X2-S
U60 = AOZ1336DI_DFN8_2X2
U712 = SLB9670VQ1P2-FW4P4X_VQFN32_5X5
UA1 = ALC3281-CG_MQFN48_6X6-S
UC1 = ICL-U_BGA_1526P-T: room: CPU
UC2 UC4 UC5 UC10 UC29 UH1 = TC7SH08FU_SSOP5
UC6 = MC74VHC1G32DFT2G_SC70-5: room: CPU
UC7 UC9 = MC74VHC1G32DFT2G_SC70-5
UC8 UC11 = SN74AUP1G97DRLR_SOT_6P
UC12 UC13 UC22 UC23 UC27 = AOZ1334DI-01_DFN8-7_3X3
UCR1 = RTS5242-GR_QFN32_4X4-S
UD1-UD4 = H9HCNNNBUUMLHR-NLM_FBGA_200P
UE1 = MEC5105_WFBGA_169P
UE5 UE10 UW2 = 74AUP1G07FZ4-7_X2-DFN1410-6
UE8 = 74AUP1G07GW_TSSOP5
UH6 = TC7SH08FU_SSOP5: room: PCH
UH8 = W25Q256JVEIQ_WSON8_8X6-S
UM1 UM2 = TS3DS10224RUKR_WQFN20_3X3-S
UPD1 = PTPS65988DHRSHR_VQFN56_7X7-S: room: TBT_CCG5
UPD2 = PTPS65988DHRSHR_VQFN56_7X7-S
UPD3 UPD4 UTS1 UTS2 = W25Q64FVZPIG_WSON8_6X5
URT1 URT2 = BURNSIDE-BRIDGE_BGA_105P-T
USSD1 = S-SUN_PM971_291P-T
UT2 = AOZ1336DI_DFN8_2X2-S: room: AR
UWL1 = INTEL_9560PD2WGE2_152P
YC1 = Y_9H03200042_2P
YE2 = Y_X1A000141000200_2P: room: KBC
YH1 = Y_8Y38420005_4P: room: PCH
YT1 = Y_FW2500025Z_4P: room: ETY-ROOM
YT2 = Y_FW2500025Z_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1N4148WS-L_SOD323-2
  rect 0.559x0.813 smd: 1(0,0) 2(2.3,0)
2N7002KDW_SOT363-6
  oval 0.356x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.6) 5(0.65,1.6) 6(0,1.6)
74AUP1G07FZ4-7_X2-DFN1410-6
  oval 0.254x0.533 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,0.725) 5(0.5,0.725) 6(0,0.725)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50208-00801-003_8P
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0) 5(-3.2,0) 6(-4,0) 7(-4.8,0) 8(-5.6,0)
  rect 1.194x1.702 smd: 9(1.3,-1.95) 10(-6.9,-1.95)
ACES_50278-00201-001_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.925) 4(4.1,-4.925)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50521-01041-P01_10P
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.5) 12(5.5,-2.5)
ACES_51515-0510M-P01_51P-T
  oval 0.305x1.245 smd: 1(0,0) 3(0.6,0) 5(1.2,0) 7(1.8,0) 9(2.4,0) 11(3,0) 13(3.6,0) 15(4.2,0) 17(4.8,0) 19(5.4,0) 21(6,0) 23(6.6,0) 25(7.2,0) 27(7.8,0) 29(8.4,0) 31(9,0) 33(9.6,0) 35(10.2,0) 37(10.8,0) 39(11.4,0) 41(12,0) 43(12.6,0) 45(13.2,0) 47(13.8,0) 49(14.4,0) 51(15,0)
  oval 0.305x1.041 smd: 2(0.3,3.3) 4(0.9,3.3) 6(1.5,3.3) 8(2.1,3.3) 10(2.7,3.3) 12(3.3,3.3) 14(3.9,3.3) 16(4.5,3.3) 18(5.1,3.3) 20(5.7,3.3) 22(6.3,3.3) 24(6.9,3.3) 26(7.5,3.3) 28(8.1,3.3) 30(8.7,3.3) 32(9.3,3.3) 34(9.9,3.3) 36(10.5,3.3) 38(11.1,3.3) 40(11.7,3.3) 42(12.3,3.3) 44(12.9,3.3) 46(13.5,3.3) 48(14.1,3.3) 50(14.7,3.3)
  rect 0.406x0.94 smd: 52(15.7,0.5) 53(-0.7,0.5)
ACES_51524-0240N-001_24P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0) 11(10,0) 12(11,0) 13(12,0) 14(13,0) 15(14,0) 16(15,0) 17(16,0) 18(17,0) 19(18,0) 20(19,0) 21(20,0) 22(21,0) 23(22,0) 24(23,0)
  rect 2.489x2.21 smd: 25(-3,-3.05) 26(26,-3.05)
ALC3281-CG_MQFN48_6X6-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
AON6962_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.63)
AON7405_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AOZ1334DI-01_DFN8-7_3X3
  oval 0.305x0.406 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.6)
  oval 1.6x0.406 smd: 6(0.65,2.6)
  rect 2.388x1.6 smd: 7(0.975,1.3)
AOZ1336DI_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AOZ1336DI_DFN8_2X2-S
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AZ5B75-01BPR7G_CSP0603P2Y2
  rect 0.279x0.381 smd: 1(0,0) 2(0.4,0)
AZ4520-01FPR7G_DFN1610P2E2
  rect 0.635x0.991 smd: 1(0,0) 2(1.225,0)
AZ5125-01HPR7G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.5,0)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BAT54HT1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.225,0)
BELLW_10093-1021_4P
  rect 0.61x0.559 smd: 1(0,0)
  custom 0.145x0.145 smd: 2(0.96,0.975) 4(-0.96,0.975)
  rect 0.508x0.508 smd: 3(0,1.975)
BELLW_80149-2021_67P-S
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(4.75,-7.55) 13(5,0) 14(5.25,-7.55) 15(5.5,0) 16(5.75,-7.55) 17(6,0) 18(6.25,-7.55) 19(6.5,0) 20(6.75,-7.55) 21(7,0) 22(7.25,-7.55) 23(7.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
BURNSIDE-BRIDGE_BGA_105P-T
  oval 0.229x0.381 smd: A1(0,0) A12(0,-5.06) B1(-0.46,0) B12(-0.46,-5.06) C1(-0.92,0) C12(-0.92,-5.06) D1(-1.38,0) D12(-1.38,-5.06) E1(-1.84,0) E12(-1.84,-5.06) F1(-2.3,0) F12(-2.3,-5.06) G1(-2.76,0) G12(-2.76,-5.06) H1(-3.22,0) H12(-3.22,-5.06) J1(-3.68,0) J12(-3.68,-5.06) K1(-4.14,0) K12(-4.14,-5.06) L1(-4.6,0) L12(-4.6,-5.06) M1(-5.06,0) M12(-5.06,-5.06)
  oval 0.381x0.229 smd: A2(0,-0.46) A3(0,-0.92) A4(0,-1.38) A5(0,-1.84) A6(0,-2.3) A7(0,-2.76) A8(0,-3.22) A9(0,-3.68) A10(0,-4.14) A11(0,-4.6) M2(-5.06,-0.46) M3(-5.06,-0.92) M4(-5.06,-1.38) M5(-5.06,-1.84) M6(-5.06,-2.3) M7(-5.06,-2.76) M8(-5.06,-3.22) M9(-5.06,-3.68) M10(-5.06,-4.14) M11(-5.06,-4.6)
  round 0.305 smd: B2(-0.46,-0.46) B3(-0.46,-0.92) B4(-0.46,-1.38) B5(-0.46,-1.84) B6(-0.46,-2.3) B7(-0.46,-2.76) B8(-0.46,-3.22) B9(-0.46,-3.68) B10(-0.46,-4.14) B11(-0.46,-4.6) C2(-0.92,-0.46) C11(-0.92,-4.6) D2(-1.38,-0.46) D11(-1.38,-4.6) E2(-1.84,-0.46) E11(-1.84,-4.6) F2(-2.3,-0.46) F11(-2.3,-4.6) G2(-2.76,-0.46) G11(-2.76,-4.6) H2(-3.22,-0.46) H11(-3.22,-4.6) J2(-3.68,-0.46) J11(-3.68,-4.6) K2(-4.14,-0.46) K11(-4.14,-4.6) L2(-4.6,-0.46) L3(-4.6,-0.92) L4(-4.6,-1.38) L5(-4.6,-1.84) L6(-4.6,-2.3) L7(-4.6,-2.76) L8(-4.6,-3.22) L9(-4.6,-3.68) L10(-4.6,-4.14) L11(-4.6,-4.6)
  round 0.254 smd: C3(-1.23,-1.23) C5(-1.23,-1.88) C6(-1.23,-2.53) C7(-1.23,-3.18) C9(-1.23,-3.83) E3(-1.88,-1.23) E5(-1.88,-1.88) E6(-1.88,-2.53) E7(-1.88,-3.18) E9(-1.88,-3.83) F3(-2.53,-1.23) F5(-2.53,-1.88) F6(-2.53,-2.53) F7(-2.53,-3.18) F9(-2.53,-3.83) G3(-3.18,-1.23) G5(-3.18,-1.88) G6(-3.18,-2.53) G7(-3.18,-3.18) G9(-3.18,-3.83) J3(-3.83,-1.23) J5(-3.83,-1.88) J6(-3.83,-2.53) J7(-3.83,-3.18) J9(-3.83,-3.83)
BZT52C6V2LP-7_X1-DFN1006-2-2
  rect 0.406x0.711 smd: 1(0,0) 2(0.7,0)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0603-H1_2
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_B3
  rect 1.346x2.692 smd: 1(0,0) 2(2.75,0)
C_TEPSLB30J157M-35-8R
  rect 1.346x2.692 smd: 1(0,0) 2(2.75,0)
CHILI_HEI322512A-1R0M-Q8_2P
  rect 0.889x2.794 smd: 1(0,0) 2(2.6,0)
CHILI_MHCB06015-1R5M-C1_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CHILI_MHCB06024-R15M-C1R885_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CHILI_MHCI04015-R68M-R8_2P
  rect 1.499x2.489 smd: 1(0,0) 2(3.7,0)
CLIP_2X2P5-NP
  rect 2.007x2.489 smd: 1(0,0)
CVILU_CF35042D0RD-NH_4P-T
  oval 0.305x0.991 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0)
  rect 0.406x0.787 smd: 5(-2.725,-2.6) 6(1.225,-2.6)
CVILU_CI1804M1VRA-NH_4P
  oval 0.508x0.991 smd: 1(0,-0.05) 2(-0.8,-0.05) 3(-1.6,-0.05) 4(-2.4,-0.05)
  rect 1.194x1.702 smd: 5(-3.7,1.4) 6(1.3,1.4)
EM5209VF_DFN14_3X2-S
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
EMIST_CL-XXG0629_1P
  rect 5.588x4.394 smd: 1(0,0)
EMIST_SU-15AG_1P-T
  rect 3.2x2.997 smd: 1(0,0)
ESD101-B1-02ELS_TSSLP-2-4-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD207-B1-02EL_TSLP-2-19-2
  rect 0.356x0.61 smd: 1(0,0) 2(0.65,0)
F_F0603FA3000V032T
  rect 0.711x0.991 smd: 1(0,0) 2(1.5,0)
F_T0603FF0500TM
  rect 0.711x0.991 smd: 1(0,0) 2(1.5,0)
F_T0603FF1000TM
  rect 0.711x0.991 smd: 1(0,0) 2(1.5,0)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
FOX_UT12123-10001-7H_24P-T
  round 0.66 hole 0.66 unplated: (-1.05,-0.33) (6.3,-0.33)
  oval 1.6x1.016 hole 1.295x0.711: 1(-1.075,0.98) 5(6.325,0.98)
  oval 1.194x2.489 hole 0.711x2.007: 2(-2.3,-0.78) 6(7.55,-0.78)
  oval 2.261x1.092 hole 1.905x0.711: 3(-1.7,-1.43) 7(6.95,-1.43)
  oval 1.194x2.159 hole 0.711x1.6: 4(-3.225,-6.43) 8(8.475,-6.43)
  oval 0.279x0.94 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  oval 0.279x0.838 smd: B1(5.25,-1.66) B2(4.75,-1.66) B3(4.25,-1.66) B4(3.75,-1.66) B5(3.25,-1.66) B6(2.75,-1.66) B7(2.25,-1.66) B8(1.75,-1.66) B9(1.25,-1.66) B10(0.75,-1.66) B11(0.25,-1.66) B12(-0.25,-1.66)
H9HCNNNBUUMLHR-NLM_FBGA_200P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) AA1(0,-13) AA2(0.8,-13) AA3(1.6,-13) AA4(2.4,-13) AA5(3.2,-13) AA8(5.601,-13) AA9(6.401,-13) AA10(7.201,-13) AA11(8.001,-13) AA12(8.801,-13) AB1(0,-13.65) AB2(0.8,-13.65) AB3(1.6,-13.65) AB4(2.4,-13.65) AB5(3.2,-13.65) AB8(5.601,-13.65) AB9(6.401,-13.65) AB10(7.201,-13.65) AB11(8.001,-13.65) AB12(8.801,-13.65) B1(0,-0.65) B2(0.8,-0.65) B3(1.6,-0.65) B4(2.4,-0.65) B5(3.2,-0.65) B8(5.601,-0.65) B9(6.401,-0.65) B10(7.201,-0.65) B11(8.001,-0.65) B12(8.801,-0.65) C1(0,-1.3) C2(0.8,-1.3) C3(1.6,-1.3) C4(2.4,-1.3) C5(3.2,-1.3) C8(5.601,-1.3) C9(6.401,-1.3) C10(7.201,-1.3) C11(8.001,-1.3) C12(8.801,-1.3) D1(0,-1.95) D2(0.8,-1.95) D3(1.6,-1.95) D4(2.4,-1.95) D5(3.2,-1.95) D8(5.601,-1.95) D9(6.401,-1.95) D10(7.201,-1.95) D11(8.001,-1.95) D12(8.801,-1.95) E1(0,-2.6) E2(0.8,-2.6) E3(1.6,-2.6) E4(2.4,-2.6) E5(3.2,-2.6) E8(5.601,-2.6) E9(6.401,-2.6) E10(7.201,-2.6) E11(8.001,-2.6) E12(8.801,-2.6) F1(0,-3.25) F2(0.8,-3.25) F3(1.6,-3.25) F4(2.4,-3.25) F5(3.2,-3.25) F8(5.601,-3.25) F9(6.401,-3.25) F10(7.201,-3.25) F11(8.001,-3.25) F12(8.801,-3.25) G1(0,-3.9) G2(0.8,-3.9) G3(1.6,-3.9) G4(2.4,-3.9) G5(3.2,-3.9) G8(5.601,-3.9) G9(6.401,-3.9) G10(7.201,-3.9) G11(8.001,-3.9) G12(8.801,-3.9) H1(0,-4.55) H2(0.8,-4.55) H3(1.6,-4.55) H4(2.4,-4.55) H5(3.2,-4.55) H8(5.601,-4.55) H9(6.401,-4.55) H10(7.201,-4.55) H11(8.001,-4.55) H12(8.801,-4.55) J1(0,-5.2) J2(0.8,-5.2) J3(1.6,-5.2) J4(2.4,-5.2) J5(3.2,-5.2) J8(5.601,-5.2) J9(6.401,-5.2) J10(7.201,-5.2) J11(8.001,-5.2) J12(8.801,-5.2) K1(0,-5.85) K2(0.8,-5.85) K3(1.6,-5.85) K4(2.4,-5.85) K5(3.2,-5.85) K8(5.601,-5.85) K9(6.401,-5.85) K10(7.201,-5.85) K11(8.001,-5.85) K12(8.801,-5.85) N1(0,-7.8) N2(0.8,-7.8) N3(1.6,-7.8) N4(2.4,-7.8) N5(3.2,-7.8) N8(5.601,-7.8) N9(6.401,-7.8) N10(7.201,-7.8) N11(8.001,-7.8) N12(8.801,-7.8) P1(0,-8.45) P2(0.8,-8.45) P3(1.6,-8.45) P4(2.4,-8.45) P5(3.2,-8.45) P8(5.601,-8.45) P9(6.401,-8.45) P10(7.201,-8.45) P11(8.001,-8.45) P12(8.801,-8.45) R1(0,-9.1) R2(0.8,-9.1) R3(1.6,-9.1) R4(2.4,-9.1) R5(3.2,-9.1) R8(5.601,-9.1) R9(6.401,-9.1) R10(7.201,-9.1) R11(8.001,-9.1) R12(8.801,-9.1) T1(0,-9.75) T2(0.8,-9.75) T3(1.6,-9.75) T4(2.4,-9.75) T5(3.2,-9.75) T8(5.601,-9.75) T9(6.401,-9.75) T10(7.201,-9.75) T11(8.001,-9.75) T12(8.801,-9.75) U1(0,-10.4) U2(0.8,-10.4) U3(1.6,-10.4) U4(2.4,-10.4) U5(3.2,-10.4) U8(5.601,-10.4) U9(6.401,-10.4) U10(7.201,-10.4) U11(8.001,-10.4) U12(8.801,-10.4) V1(0,-11.05) V2(0.8,-11.05) V3(1.6,-11.05) V4(2.4,-11.05) V5(3.2,-11.05) V8(5.601,-11.05) V9(6.401,-11.05) V10(7.201,-11.05) V11(8.001,-11.05) V12(8.801,-11.05) W1(0,-11.7) W2(0.8,-11.7) W3(1.6,-11.7) W4(2.4,-11.7) W5(3.2,-11.7) W8(5.601,-11.7) W9(6.401,-11.7) W10(7.201,-11.7) W11(8.001,-11.7) W12(8.801,-11.7) Y1(0,-12.35) Y2(0.8,-12.35) Y3(1.6,-12.35) Y4(2.4,-12.35) Y5(3.2,-12.35) Y8(5.601,-12.35) Y9(6.401,-12.35) Y10(7.201,-12.35) Y11(8.001,-12.35) Y12(8.801,-12.35)
H_0P4X2P2N
  oval 0.406x2.21 hole 0.406x2.21 unplated: (0,0)
H_0P5X2P3N
  oval 0.508x2.311 hole 0.508x2.311 unplated: (0,0)
H_1P3N
  round 1.295 hole 1.295 unplated: (0,0)
H_1P9-G
  round 2.413 hole 1.905: 1(0,0)
H_2P0
  round 2.515 hole 2.007: 1(0,0)
H_2P0-G
  round 2.515 hole 2.007: 1(0,0)
H_2P4
  round 2.896 hole 2.388: 1(0,0)
H_2P5X5P5N
  oval 2.489x5.512 hole 2.489x5.512 unplated: (0,0)
H_2P6
  round 3.099 hole 2.591: 1(0,0)
H_2P6-G
  round 3.099 hole 2.591: 1(0,0)
H_2P9-G
  round 3.404 hole 2.896: 1(0,0)
I-PEX_20879-030E-01_30P-T
  oval 0.203x0.635 smd: 1(0,0) 2(-0.4,0) 3(-0.8,0) 4(-1.2,0) 5(-1.6,0) 6(-2,0) 7(-2.4,0) 8(-2.8,0) 9(-3.2,0) 10(-3.6,0) 11(-4,0) 12(-4.4,0) 13(-4.8,0) 14(-5.2,0) 15(-5.6,0) 16(-6,0) 17(-6.4,0) 18(-6.8,0) 19(-7.2,0) 20(-7.6,0) 21(-8,0) 22(-8.4,0) 23(-8.8,0) 24(-9.2,0) 25(-9.6,0) 26(-10,0) 27(-10.4,0) 28(-10.8,0) 29(-11.2,0) 30(-11.6,0)
  rect 0.305x0.813 smd: 31(-13.385,0.085) 43(1.785,0.085)
  rect 1.448x0.356 smd: 32(-12.305,0.75) 42(0.705,0.75)
  rect 0.457x0.356 smd: 33(-10.6,0.75) 34(-9.4,0.75) 35(-8.2,0.75) 36(-7,0.75) 37(-5.8,0.75) 38(-4.6,0.75) 39(-3.4,0.75) 40(-2.2,0.75) 41(-1,0.75)
  rect 0.406x0.889 smd: 44(1.735,-2.28) 56(-13.335,-2.28)
  rect 1.397x0.508 smd: 45(0.64,-2.915) 55(-12.24,-2.915)
  rect 0.457x0.508 smd: 46(-1,-2.915) 47(-2.2,-2.915) 48(-3.4,-2.915) 49(-4.6,-2.915) 50(-5.8,-2.915) 51(-7,-2.915) 52(-8.2,-2.915) 53(-9.4,-2.915) 54(-10.6,-2.915)
I-PEX_20879-040E-01_40P-T
  oval 0.203x0.635 smd: 1(0,0) 2(-0.4,0) 3(-0.8,0) 4(-1.2,0) 5(-1.6,0) 6(-2,0) 7(-2.4,0) 8(-2.8,0) 9(-3.2,0) 10(-3.6,0) 11(-4,0) 12(-4.4,0) 13(-4.8,0) 14(-5.2,0) 15(-5.6,0) 16(-6,0) 17(-6.4,0) 18(-6.8,0) 19(-7.2,0) 20(-7.6,0) 21(-8,0) 22(-8.4,0) 23(-8.8,0) 24(-9.2,0) 25(-9.6,0) 26(-10,0) 27(-10.4,0) 28(-10.8,0) 29(-11.2,0) 30(-11.6,0) 31(-12,0) 32(-12.4,0) 33(-12.8,0) 34(-13.2,0) 35(-13.6,0) 36(-14,0) 37(-14.4,0) 38(-14.8,0) 39(-15.2,0) 40(-15.6,0)
  rect 0.305x0.813 smd: 41(-17.385,0.085) 57(1.785,0.085)
  rect 1.448x0.356 smd: 42(-16.305,0.75) 56(0.705,0.75)
  rect 0.457x0.356 smd: 43(-15,0.75) 44(-13.8,0.75) 45(-12.6,0.75) 46(-11.4,0.75) 47(-10.2,0.75) 48(-9,0.75) 49(-7.8,0.75) 50(-6.6,0.75) 51(-5.4,0.75) 52(-4.2,0.75) 53(-3,0.75) 54(-1.8,0.75) 55(-0.6,0.75)
  rect 0.406x0.889 smd: 58(1.735,-2.28) 74(-17.335,-2.28)
  rect 1.397x0.508 smd: 59(0.64,-2.915) 73(-16.24,-2.915)
  rect 0.457x0.508 smd: 60(-0.6,-2.915) 61(-1.8,-2.915) 62(-3,-2.915) 63(-4.2,-2.915) 64(-5.4,-2.915) 65(-6.6,-2.915) 66(-7.8,-2.915) 67(-9,-2.915) 68(-10.2,-2.915) 69(-11.4,-2.915) 70(-12.6,-2.915) 71(-13.8,-2.915) 72(-15,-2.915)
ICL-U_BGA_1526P-T
  round 0.356 smd: A3(-1.098,0) A48(-23.27,0) A49(-23.73,0.46) B2(-0.556,0.549) C1(0,1.11) DW1(0,48.27) DW2(-0.46,48.73) DW48(-23.27,48.73) DW49(-23.73,48.27)
  round 0.33 smd: A4(-1.748,0) A47(-22.62,0) B3(-1.199,0.642) B48(-23.102,0.628) C2(-0.645,1.193) C49(-23.73,1.11) D1(0,1.76) DE12(-5.555,41.397) DE13(-6.385,41.397) DE15(-7.215,41.397) DE17(-8.045,41.397) DE18(-8.875,41.397) DE20(-9.705,41.397) DE22(-10.535,41.397) DE23(-11.365,41.397) DE26(-12.195,41.397) DE28(-13.025,41.397) DE29(-13.855,41.397) DE31(-14.685,41.397) DE33(-15.515,41.397) DF12(-5.555,42.047) DF13(-6.385,42.047) DF15(-7.215,42.047) DF17(-8.045,42.047) DF18(-8.875,42.047) DF20(-9.705,42.047) DF22(-10.535,42.047) DF23(-11.365,42.047) DF26(-12.195,42.047) DF28(-13.025,42.047) DF29(-13.855,42.047) DF31(-14.685,42.047) DF33(-15.515,42.047) DG12(-5.555,42.697) DG13(-6.385,42.697) DG15(-7.215,42.697) DG17(-8.045,42.697) DG18(-8.875,42.697) DG20(-9.705,42.697) DG22(-10.535,42.697) DG23(-11.365,42.697) DG26(-12.195,42.697) DG28(-13.025,42.697) DG29(-13.855,42.697) DG31(-14.685,42.697) DG33(-15.515,42.697) DU1(0,47.62) DU49(-23.73,47.62) DV2(-0.628,48.102) DV48(-23.102,48.102) DW3(-1.11,48.73) DW47(-22.62,48.73)
  round 0.305 smd: A5(-2.398,0) A7(-3.207,0) A33(-15.458,0) A43(-20.572,0) A44(-21.32,0) A46(-21.97,0) AA12(-5.738,10.053) AA35(-16.72,10.054) AA37(-17.643,10.054) AA45(-21.455,10.119) AA47(-22.726,10.119) AB3(-0.972,10.442) AB5(-1.96,10.442) AB6(-2.676,10.51) AB7(-3.326,10.51) AB9(-3.976,10.51) AB10(-4.626,10.51) AB11(-5.276,10.51) AB13(-6.2,10.51) AB34(-16.258,10.512) AB36(-17.181,10.512) AB38(-18.105,10.512) AB39(-18.755,10.512) AB41(-19.405,10.512) AB42(-20.055,10.512) AB43(-20.705,10.512) AB45(-21.78,10.739) AB47(-22.43,10.739) AC3(-1.3,11.116) AC5(-1.95,11.116) AC12(-5.738,10.968) AC35(-16.72,10.969) AC37(-17.643,10.969) AC45(-21.455,11.37) AC46(-22.106,11.37) AD3(-0.975,11.679) AD4(-1.625,11.679) AD6(-2.676,11.425) AD7(-3.326,11.425) AD9(-3.976,11.425) AD10(-4.626,11.425) AD11(-5.276,11.425) AD34(-16.258,11.427) AD35(-16.72,11.884) AD36(-17.181,11.427) AD37(-17.643,11.884) AD38(-18.105,11.427) AD39(-18.755,11.427) AD41(-19.405,11.427) AD42(-20.055,11.427) AD43(-20.705,11.427) AE3(-1.3,12.242) AE5(-1.95,12.242) AE6(-2.676,12.34) AE7(-3.326,12.34) AE9(-3.976,12.34) AE11(-4.9,12.34) AE36(-17.181,12.342) AE38(-18.105,12.342) AE39(-18.755,12.342) AE41(-19.405,12.342) AE42(-20.055,12.342) AE43(-20.705,12.342) AE45(-21.78,12.001) AE47(-22.43,12.001) AF10(-4.438,12.798) AF37(-17.643,12.799) AF45(-21.455,12.621) AF47(-22.726,12.621) AG3(-0.972,12.916) AG5(-1.96,12.916) AG6(-2.676,13.255) AG7(-3.326,13.255) AG9(-3.976,13.255) AG11(-4.9,13.255) AG36(-17.181,13.257) AG38(-18.105,13.257) AG39(-18.755,13.257) AG41(-19.405,13.257) AG42(-20.055,13.257) AG43(-20.705,13.257) AG45(-21.78,13.241) AG47(-22.43,13.241) AH10(-4.438,13.713) AH37(-17.643,13.714) AH45(-21.455,13.872) AH46(-22.106,13.872) AJ3(-1.376,14.17) AJ5(-2.026,14.17) AJ6(-2.676,14.17) AJ7(-3.326,14.17) AJ9(-3.976,14.17) AJ11(-4.9,14.17) AJ36(-17.181,14.172) AJ38(-18.105,14.172) AJ39(-18.755,14.172) AJ41(-19.405,14.172) AJ42(-20.055,14.172) AJ43(-20.705,14.172) AK10(-4.438,14.628) AK37(-17.643,14.629) AK45(-21.78,14.503) AK47(-22.43,14.503) AL3(-1.376,15.085) AL5(-2.026,15.085) AL6(-2.676,15.085) AL7(-3.326,15.085) AL9(-3.976,15.085) AL11(-4.9,15.085) AL36(-17.181,15.087) AL38(-18.105,15.087) AL39(-18.755,15.087) AL41(-19.405,15.087) AL42(-20.055,15.087) AL43(-20.705,15.087) AL45(-21.455,15.123) AL47(-22.726,15.123) AM10(-4.438,15.543) AM37(-17.643,15.544) AM45(-21.78,15.743) AM47(-22.43,15.743) AN3(-1.376,16) AN5(-2.026,16) AN6(-2.676,16) AN7(-3.326,16) AN9(-3.976,16) AN11(-4.9,16) AN36(-17.181,16.002) AN38(-18.105,16.002) AN39(-18.755,16.002) AN41(-19.405,16.002) AN42(-20.055,16.002) AN43(-20.705,16.002) AN45(-21.455,16.374) AN46(-22.106,16.374) AP10(-4.438,16.458) AP37(-17.643,16.459) AR3(-1.376,16.915) AR5(-2.026,16.915) AR6(-2.676,16.915) AR7(-3.326,16.915) AR9(-3.976,16.915) AR10(-4.438,17.373) AR11(-4.9,16.915) AR36(-17.181,16.917) AR37(-17.643,17.374) AR38(-18.105,16.917) AR39(-18.755,16.917) AR41(-19.405,16.917) AR42(-20.055,16.917) AR43(-20.705,16.917) AR45(-21.78,17.005) AR47(-22.43,17.005) AT3(-1.376,17.83) AT5(-2.026,17.83) AT6(-2.676,17.83) AT7(-3.326,17.83) AT9(-3.976,17.83) AT11(-4.9,17.83) AT36(-17.181,17.832) AT38(-18.105,17.832) AT39(-18.755,17.832) AT41(-19.405,17.832) AT42(-20.055,17.832) AT43(-20.705,17.832) AT45(-21.455,17.625) AT47(-22.726,17.625) AU10(-4.438,18.288) AU37(-17.643,18.289) AU45(-21.78,18.245) AU47(-22.43,18.245) AV3(-1.376,18.745) AV5(-2.026,18.745) AV6(-2.676,18.745) AV7(-3.326,18.745) AV9(-3.976,18.745) AV11(-4.9,18.745) AV36(-17.181,18.747) AV38(-18.105,18.747) AV39(-18.755,18.747) AV41(-19.405,18.747) AV42(-20.055,18.747) AV43(-20.705,18.747) AV45(-21.455,18.876) AV46(-22.106,18.876) AW10(-4.438,19.203) AW37(-17.643,19.204) AY3(-1.376,19.66) AY5(-2.026,19.66) AY6(-2.676,19.66) AY7(-3.326,19.66) AY9(-3.976,19.66) AY11(-4.9,19.66) AY36(-17.181,19.662) AY38(-18.105,19.662) AY39(-18.755,19.662) AY41(-19.405,19.662) AY42(-20.055,19.662) AY43(-20.705,19.662) AY45(-21.78,19.507) AY47(-22.43,19.507) B4(-1.849,0.642) B7(-3.207,0.65) B33(-15.458,0.65) B43(-20.572,0.65) B45(-21.821,0.788) B47(-22.452,0.628) BA10(-4.438,20.118) BA37(-17.643,20.119) BA45(-21.455,20.127) BA47(-22.726,20.127) BB3(-1.376,20.575) BB5(-2.026,20.575) BB6(-2.676,20.575) BB7(-3.326,20.575) BB9(-3.976,20.575) BB11(-4.9,20.575) BB36(-17.181,20.577) BB38(-18.105,20.577) BB39(-18.755,20.577) BB41(-19.405,20.577) BB42(-20.055,20.577) BB43(-20.705,20.577) BB45(-21.78,20.747) BB47(-22.43,20.747) BC10(-4.438,21.033) BC37(-17.643,21.034) BD3(-1.376,21.49) BD5(-2.026,21.49) BD6(-2.676,21.49) BD7(-3.326,21.49) BD9(-3.976,21.49) BD11(-4.9,21.49) BD36(-17.181,21.492) BD38(-18.105,21.492) BD39(-18.755,21.492) BD41(-19.405,21.492) BD42(-20.055,21.492) BD43(-20.705,21.492) BD45(-21.455,21.378) BD46(-22.106,21.378) BE10(-4.438,21.948) BE37(-17.643,21.949) BE45(-21.78,22.009) BE47(-22.43,22.009) BF3(-1.376,22.405) BF5(-2.026,22.405) BF6(-2.676,22.405) BF7(-3.326,22.405) BF9(-3.976,22.405) BF10(-4.438,22.863) BF11(-4.9,22.405) BF36(-17.181,22.407) BF37(-17.643,22.864) BF38(-18.105,22.407) BF39(-18.755,22.407) BF41(-19.405,22.407) BF42(-20.055,22.407) BF43(-20.705,22.407) BF45(-21.455,22.629) BF47(-22.726,22.629) BG3(-1.376,23.32) BG5(-2.026,23.32) BG6(-2.676,23.32) BG7(-3.326,23.32) BG9(-3.976,23.32) BG11(-4.9,23.32) BG36(-17.181,23.322) BG38(-18.105,23.322) BG39(-18.755,23.322) BG41(-19.405,23.322) BG42(-20.055,23.322) BG43(-20.705,23.322) BG45(-21.78,23.249) BG47(-22.43,23.249) BH10(-4.438,23.778) BH37(-17.643,23.779) BJ3(-1.376,24.235) BJ5(-2.026,24.235) BJ6(-2.676,24.235) BJ7(-3.326,24.235) BJ9(-3.976,24.235) BJ11(-4.9,24.235) BJ36(-17.181,24.237) BJ38(-18.105,24.237) BJ39(-18.755,24.237) BJ41(-19.405,24.237) BJ42(-20.055,24.237) BJ43(-20.705,24.237) BJ45(-21.455,23.88) BJ46(-22.106,23.88) BL10(-4.438,24.693) BL37(-17.643,24.695) BL45(-21.78,24.511) BL47(-22.43,24.511) BM3(-1.376,25.151) BM5(-2.026,25.151) BM6(-2.676,25.151) BM7(-3.326,25.151) BM9(-3.976,25.151) BM11(-4.9,25.151) BM36(-17.181,25.152) BM38(-18.105,25.152) BM39(-18.755,25.152) BM41(-19.405,25.152) BM42(-20.055,25.152) BM43(-20.705,25.152) BM45(-21.455,25.131) BM47(-22.726,25.131) BN10(-4.438,25.608) BN37(-17.643,25.61) BN45(-21.78,25.751) BN47(-22.43,25.751) BP3(-1.376,26.066) BP5(-2.026,26.066) BP6(-2.676,26.066) BP7(-3.326,26.066) BP9(-3.976,26.066) BP11(-4.9,26.066) BP36(-17.181,26.067) BP38(-18.105,26.067) BP39(-18.755,26.067) BP41(-19.405,26.067) BP42(-20.055,26.067) BP43(-20.705,26.067) BR10(-4.438,26.523) BR37(-17.643,26.525) BR45(-21.455,26.382) BR46(-22.106,26.382) BT3(-1.376,26.981) BT5(-2.026,26.981) BT6(-2.676,26.981) BT7(-3.326,26.981) BT9(-3.976,26.981) BT11(-4.9,26.981) BT36(-17.181,26.982) BT38(-18.105,26.982) BT39(-18.755,26.982) BT41(-19.405,26.982) BT42(-20.055,26.982) BT43(-20.705,26.982) BT45(-21.78,27.013) BT47(-22.43,27.013) BU10(-4.438,27.438) BU37(-17.643,27.44) BU45(-21.455,27.633) BU47(-22.726,27.633) BV3(-1.376,27.896) BV5(-2.026,27.896) BV6(-2.676,27.896) BV7(-3.326,27.896) BV9(-3.976,27.896) BV11(-4.9,27.896) BV36(-17.181,27.897) BV38(-18.105,27.897) BV39(-18.755,27.897) BV41(-19.405,27.897) BV42(-20.055,27.897) BV43(-20.705,27.897) BV45(-21.78,28.253) BV47(-22.43,28.253) BW3(-1.376,28.811) BW5(-2.026,28.811) BW6(-2.676,28.811) BW7(-3.326,28.811) BW9(-3.976,28.811) BW10(-4.438,28.353) BW11(-4.9,28.811) BW36(-17.181,28.812) BW37(-17.643,28.355) BW38(-18.105,28.812) BW39(-18.755,28.812) BW41(-19.405,28.812) BW42(-20.055,28.812) BW43(-20.705,28.812) BY10(-4.438,29.268) BY37(-17.643,29.27) BY45(-21.455,28.884) BY46(-22.106,28.884) C3(-1.288,1.286) C5(-1.938,1.286) C6(-2.533,0.972) C7(-3.207,1.3) C8(-3.77,0.975) C9(-4.333,1.3) C11(-5.007,0.972) C12(-5.681,1.3) C13(-6.244,0.975) C14(-6.807,1.3) C16(-7.481,0.972) C33(-15.458,1.3) C34(-16.041,1.004) C35(-16.66,1.3) C38(-17.942,1.3) C39(-18.595,1.004) C40(-19.248,1.3) C43(-20.572,1.3) C44(-21.201,1.006) C47(-22.344,1.278) C48(-23.099,1.278) CA3(-1.376,29.726) CA5(-2.026,29.726) CA6(-2.676,29.726) CA7(-3.326,29.726) CA9(-3.976,29.726) CA11(-4.9,29.726) CA36(-17.181,29.727) CA38(-18.105,29.727) CA39(-18.755,29.727) CA41(-19.405,29.727) CA42(-20.055,29.727) CA43(-20.705,29.727) CA45(-21.78,29.515) CA47(-22.43,29.515) CB10(-4.438,30.183) CB37(-17.643,30.185) CB45(-21.455,30.135) CB47(-22.726,30.135) CC3(-0.972,30.514) CC5(-1.96,30.514) CC6(-2.676,30.641) CC7(-3.326,30.641) CC9(-3.976,30.641) CC11(-4.9,30.641) CC36(-17.181,30.642) CC38(-18.105,30.642) CC39(-18.755,30.642) CC41(-19.405,30.642) CC42(-20.055,30.642) CC43(-20.705,30.642) CC45(-21.78,30.755) CC47(-22.43,30.755) CD3(-1.3,31.188) CD5(-1.95,31.188) CD10(-4.438,31.098) CE3(-0.975,31.751) CE4(-1.625,31.751) CE6(-2.676,31.556) CE7(-3.326,31.556) CE9(-3.976,31.556) CE11(-4.9,31.556) CE34(-16.155,31.557) CE35(-16.805,31.557) CE37(-17.455,31.557) CE38(-18.105,31.557) CE39(-18.755,31.557) CE41(-19.405,31.557) CE42(-20.055,31.557) CE43(-20.705,31.557) CE45(-21.455,31.386) CE46(-22.106,31.386) CF3(-1.3,32.314) CF5(-1.95,32.314) CF10(-4.438,32.013) CF33(-15.693,32.015) CF45(-21.78,32.017) CF47(-22.43,32.017) CG6(-2.676,32.471) CG7(-3.326,32.471) CG9(-3.976,32.471) CG11(-4.9,32.471) CG32(-15.231,32.472) CG34(-16.155,32.472) CG35(-16.805,32.472) CG37(-17.455,32.472) CG38(-18.105,32.472) CG39(-18.755,32.472) CG41(-19.405,32.472) CG42(-20.055,32.472) CG43(-20.705,32.472) CG45(-21.455,32.637) CG47(-22.726,32.637) CH3(-0.972,32.988) CH5(-1.96,32.988) CH10(-4.438,32.928) CH33(-15.693,33.054) CH45(-21.78,33.257) CH47(-22.43,33.257) CJ3(-1.3,33.662) CJ5(-1.95,33.662) CJ6(-2.676,33.386) CJ7(-3.326,33.386) CJ9(-3.976,33.386) CJ11(-4.9,33.386) CJ32(-15.231,33.637) CJ34(-16.155,33.637) CJ35(-16.805,33.637) CJ37(-17.455,33.637) CJ38(-18.105,33.637) CJ39(-18.755,33.637) CJ41(-19.405,33.637) CJ42(-20.055,33.637) CJ43(-20.705,33.637) CK3(-0.975,34.225) CK4(-1.625,34.225) CK6(-2.676,34.301) CK7(-3.326,34.301) CK9(-3.976,34.301) CK10(-4.438,33.843) CK11(-4.9,34.301) CK33(-15.693,34.095) CK45(-21.455,33.888) CK46(-22.106,33.888) CL3(-1.3,34.788) CL5(-1.95,34.788) CL10(-4.438,34.758) CL32(-15.231,34.552) CL34(-16.155,34.552) CL35(-16.805,34.552) CL37(-17.455,34.552) CL38(-18.105,34.552) CL39(-18.755,34.552) CL41(-19.405,34.552) CL42(-20.055,34.552) CL43(-20.705,34.552) CL45(-21.78,34.519) CL47(-22.43,34.519) CM6(-2.676,35.216) CM7(-3.326,35.216) CM9(-3.976,35.216) CM11(-4.9,35.216) CM33(-15.693,35.01) CM45(-21.455,35.139) CM47(-22.726,35.139) CN3(-0.972,35.462) CN5(-1.96,35.462) CN10(-4.438,35.673) CN32(-15.231,35.467) CN34(-16.155,35.467) CN35(-16.805,35.467) CN37(-17.455,35.467) CN38(-18.105,35.467) CN39(-18.755,35.467) CN41(-19.405,35.467) CN42(-20.055,35.467) CN43(-20.705,35.467) CN45(-21.78,35.759) CN47(-22.43,35.759) CP3(-1.3,36.136) CP5(-1.95,36.136) CP6(-2.676,36.131) CP7(-3.326,36.131) CP9(-3.976,36.131) CP11(-4.9,36.131) CP33(-15.693,35.925) CR3(-0.975,36.699) CR4(-1.625,36.699) CR10(-4.438,36.588) CR32(-15.231,36.382) CR34(-16.155,36.382) CR35(-16.805,36.382) CR37(-17.455,36.382) CR38(-18.105,36.382) CR39(-18.755,36.382) CR41(-19.405,36.382) CR42(-20.055,36.382) CR43(-20.705,36.382) CR45(-21.455,36.39) CR46(-22.106,36.39) CT3(-1.3,37.262) CT5(-1.95,37.262) CT6(-2.676,37.046) CT7(-3.326,37.046) CT9(-3.976,37.046) CT11(-4.9,37.046) CT32(-15.231,37.297) CT33(-15.693,36.84) CT34(-16.155,37.297) CT35(-16.805,37.297) CT37(-17.455,37.297) CT38(-18.105,37.297) CT39(-18.755,37.297) CT41(-19.405,37.297) CT42(-20.055,37.297) CT43(-20.705,37.297) CT45(-21.78,37.021) CT47(-22.43,37.021) CU10(-4.438,37.503) CU33(-15.693,37.755) CU45(-21.455,37.641) CU47(-22.726,37.641) CV3(-0.972,37.936) CV5(-1.96,37.936) CV6(-2.676,37.961) CV7(-3.326,37.961) CV9(-3.976,37.961) CV11(-4.9,37.961) CV32(-15.231,38.212) CV34(-16.155,38.212) CV35(-16.805,38.212) CV37(-17.455,38.212) CV38(-18.105,38.212) CV39(-18.755,38.212) CV41(-19.405,38.212) CV42(-20.055,38.212) CV43(-20.705,38.212) CV45(-21.78,38.261) CV47(-22.43,38.261) CW3(-1.3,38.61) CW5(-1.95,38.61) CW10(-4.438,38.418) CW33(-15.693,38.67) CY3(-0.975,39.173) CY4(-1.625,39.173) CY6(-2.676,38.876) CY7(-3.326,38.876) CY9(-3.976,38.876) CY11(-4.9,38.876) CY32(-15.231,39.127) CY34(-16.155,39.127) CY35(-16.805,39.127) CY37(-17.455,39.127) CY38(-18.105,39.127) CY39(-18.755,39.127) CY41(-19.405,39.127) CY42(-20.055,39.127) CY43(-20.705,39.127) CY45(-21.455,38.892) CY46(-22.106,38.892) D2(-0.645,1.843) D4(-1.484,1.906) D7(-3.207,1.95) D8(-3.77,1.625) D9(-4.333,1.95) D12(-5.681,1.95) D13(-6.244,1.625) D14(-6.807,1.95) D33(-15.458,1.95) D35(-16.66,1.95) D36(-17.289,1.624) D38(-17.942,1.95) D40(-19.248,1.95) D42(-19.901,1.624) D43(-20.572,1.95) D44(-21.219,1.873) D47(-22.731,1.82) D49(-23.73,1.76) DA3(-1.3,39.736) DA5(-1.95,39.736) DA6(-2.676,39.791) DA7(-3.326,39.791) DA9(-3.976,39.791) DA10(-4.438,39.333) DA11(-4.9,39.791) DA33(-15.693,39.585) DA45(-21.78,39.523) DA47(-22.43,39.523) DB10(-4.438,40.248) DB32(-15.231,40.042) DB34(-16.155,40.042) DB35(-16.805,40.042) DB37(-17.455,40.042) DB38(-18.105,40.042) DB39(-18.755,40.042) DB41(-19.405,40.042) DB42(-20.055,40.042) DB43(-20.705,40.042) DB45(-21.455,40.143) DB47(-22.726,40.143) DC3(-0.972,40.41) DC5(-1.96,40.41) DC6(-2.676,40.706) DC7(-3.326,40.706) DC9(-3.976,40.706) DC11(-4.9,40.706) DC33(-15.693,40.5) DC45(-21.78,40.763) DC47(-22.43,40.763) DD3(-1.3,41.084) DD5(-1.95,41.084) DD34(-16.155,40.957) DD35(-16.805,40.957) DD37(-17.455,40.957) DD38(-18.105,40.957) DD39(-18.755,40.957) DD41(-19.405,40.957) DD42(-20.055,40.957) DD43(-20.705,40.957) DE3(-0.975,41.647) DE4(-1.625,41.647) DE6(-2.676,41.621) DE7(-3.326,41.621) DE9(-3.976,41.621) DE10(-4.626,41.621) DE45(-21.455,41.394) DE46(-22.106,41.394) DF3(-1.3,42.21) DF5(-1.95,42.21) DF34(-16.155,41.872) DF35(-16.805,41.872) DF37(-17.455,41.872) DF38(-18.105,41.872) DF39(-18.755,41.872) DF41(-19.405,41.872) DF42(-20.055,41.872) DF43(-20.705,41.872) DF45(-21.78,42.025) DF47(-22.43,42.025) DG6(-2.676,42.536) DG7(-3.326,42.536) DG9(-3.976,42.536) DG10(-4.626,42.536) DG34(-16.341,42.697) DG36(-17.256,42.697) DG38(-18.171,42.697) DG40(-19.086,42.697) DG42(-20.001,42.697) DG44(-20.916,42.697) DG47(-22.726,42.653) DH3(-0.972,42.884) DH5(-1.96,42.884) DH45(-21.78,43.236) DH47(-22.43,43.236) DJ3(-1.3,43.558) DJ5(-1.95,43.558) DJ6(-2.616,43.347) DJ8(-3.531,43.347) DJ10(-4.446,43.347) DJ11(-5.361,43.347) DJ13(-6.276,43.347) DJ15(-7.191,43.347) DJ17(-8.106,43.347) DJ19(-9.021,43.347) DJ21(-9.936,43.347) DJ22(-10.851,43.347) DJ24(-11.766,43.347) DJ27(-12.681,43.347) DJ29(-13.596,43.347) DJ31(-14.511,43.347) DJ33(-15.426,43.347) DJ34(-16.341,43.347) DJ36(-17.256,43.347) DJ38(-18.171,43.347) DJ40(-19.086,43.347) DJ42(-20.001,43.347) DJ44(-20.916,43.347) DK3(-0.975,44.121) DK4(-1.625,44.121) DK6(-2.616,43.997) DK8(-3.531,43.997) DK10(-4.446,43.997) DK11(-5.361,43.997) DK13(-6.276,43.997) DK15(-7.191,43.997) DK17(-8.106,43.997) DK19(-9.021,43.997) DK21(-9.936,43.997) DK22(-10.851,43.997) DK24(-11.766,43.997) DK27(-12.681,43.997) DK29(-13.596,43.997) DK31(-14.511,43.997) DK33(-15.426,43.997) DK34(-16.341,43.997) DK36(-17.256,43.997) DK38(-18.171,43.997) DK40(-19.086,43.997) DK42(-20.001,43.997) DK44(-20.916,43.997) DK46(-22.105,43.889) DL3(-1.3,44.684) DL5(-1.95,44.684) DL6(-2.616,44.647) DL8(-3.531,44.647) DL10(-4.446,44.647) DL11(-5.361,44.647) DL13(-6.276,44.647) DL15(-7.191,44.647) DL17(-8.106,44.647) DL19(-9.021,44.647) DL21(-9.936,44.647) DL22(-10.851,44.647) DL24(-11.766,44.647) DL27(-12.681,44.647) DL29(-13.596,44.647) DL31(-14.511,44.647) DL33(-15.426,44.647) DL34(-16.341,44.647) DL36(-17.256,44.647) DL38(-18.171,44.647) DL40(-19.086,44.647) DL42(-20.001,44.647) DL44(-20.916,44.647) DL45(-21.78,44.542) DL47(-22.43,44.542) DN3(-0.972,45.358) DN5(-1.96,45.358) DN6(-2.616,45.297) DN8(-3.531,45.297) DN10(-4.446,45.297) DN11(-5.361,45.297) DN13(-6.276,45.297) DN15(-7.191,45.297) DN17(-8.106,45.297) DN19(-9.021,45.297) DN21(-9.936,45.297) DN22(-10.851,45.297) DN24(-11.766,45.297) DN27(-12.681,45.297) DN29(-13.596,45.297) DN31(-14.511,45.297) DN33(-15.426,45.297) DN34(-16.341,45.297) DN36(-17.256,45.297) DN38(-18.171,45.297) DN40(-19.086,45.297) DN42(-20.001,45.297) DN44(-20.916,45.297) DN47(-22.43,45.67) DP1(0,46.032) DP3(-1.3,46.032) DP5(-1.95,46.032) DP6(-2.616,45.947) DP8(-3.531,45.947) DP10(-4.446,45.947) DP11(-5.361,45.947) DP13(-6.276,45.947) DP15(-7.191,45.947) DP17(-8.106,45.947) DP19(-9.021,45.947) DP21(-9.936,45.947) DP22(-10.851,45.947) DP24(-11.766,45.947) DP27(-12.681,45.947) DP29(-13.596,45.947) DP31(-14.511,45.947) DP33(-15.426,45.947) DP34(-16.341,45.947) DP36(-17.256,45.947) DP38(-18.171,45.947) DP40(-19.086,45.947) DP42(-20.001,45.947) DP44(-20.916,45.947) DP45(-21.78,45.994) DR5(-1.917,46.681) DR47(-22.43,46.32) DR48(-23.08,46.32) DR49(-23.73,46.32) DT1(0,46.97) DT2(-0.628,46.802) DT3(-1.278,46.802) DT6(-2.559,46.78) DT7(-3.195,47.105) DT8(-3.848,46.78) DT10(-4.505,46.78) DT11(-5.162,46.78) DT12(-5.815,47.105) DT14(-6.468,46.78) DT15(-7.125,46.78) DT16(-7.782,46.78) DT18(-8.435,47.105) DT19(-9.088,46.78) DT20(-9.745,46.78) DT22(-10.402,46.78) DT23(-11.055,47.105) DT24(-11.708,46.78) DT27(-12.365,46.78) DT28(-13.022,46.78) DT29(-13.675,47.105) DT30(-14.328,46.78) DT32(-14.985,46.78) DT33(-15.642,46.78) DT34(-16.295,47.105) DT36(-16.948,46.78) DT37(-17.605,46.78) DT38(-18.262,46.78) DT40(-18.915,47.105) DT41(-19.568,46.78) DT42(-20.225,46.78) DT44(-20.891,46.781) DT45(-21.541,46.845) DT47(-22.771,46.892) DT49(-23.73,46.97) DU2(-0.628,47.452) DU3(-1.278,47.452) DU6(-2.542,47.43) DU10(-4.505,47.755) DU15(-7.125,47.755) DU20(-9.745,47.755) DU27(-12.365,47.755) DU32(-14.985,47.755) DU37(-17.605,47.755) DU42(-20.225,47.755) DU44(-20.891,47.431) DU45(-21.541,47.495) DU47(-22.431,47.449) DU48(-23.101,47.452) DV3(-1.278,48.102) DV4(-1.842,47.775) DV6(-2.439,48.08) DV44(-20.891,48.081) DV45(-21.801,48.098) DV47(-22.451,48.099) DW4(-1.76,48.73) DW6(-2.439,48.73) DW44(-20.891,48.731) DW46(-21.97,48.73) E1(0,2.41) E3(-1.029,2.371) E5(-1.995,2.363) E6(-2.533,1.965) E11(-5.007,1.965) E16(-7.481,1.965) E34(-16.041,2.274) E36(-17.289,2.274) E39(-18.595,2.274) E42(-19.901,2.274) E46(-22.091,1.971) E48(-23.295,2.264) F6(-2.583,2.668) F8(-3.498,2.668) F10(-4.413,2.668) F11(-5.328,2.668) F13(-6.243,2.668) F15(-7.158,2.668) F17(-8.137,2.6) F33(-15.458,2.6) F45(-21.455,2.491) F47(-22.674,2.475) G1(-0.323,2.986) G3(-0.972,3.019) G5(-1.96,3.019) G6(-2.583,3.318) G8(-3.498,3.318) G10(-4.413,3.318) G11(-5.328,3.318) G13(-6.243,3.318) G15(-7.158,3.318) G17(-8.137,3.25) G33(-15.458,3.25) G34(-16.269,3.021) G36(-17.184,3.021) G38(-18.105,3.192) G39(-18.755,3.192) G41(-19.405,3.192) G42(-20.055,3.192) G43(-20.705,3.192) G45(-21.78,3.106) G47(-22.43,3.106) G48(-23.08,3.051) G49(-23.73,3.051) H1(0,3.694) H3(-1.3,3.694) H5(-1.95,3.694) H17(-8.137,3.9) H33(-15.458,3.9) H34(-16.269,3.671) H36(-17.184,3.671) H45(-21.455,3.724) H46(-22.105,3.724) J3(-0.975,4.257) J4(-1.625,4.257) J6(-2.583,3.968) J8(-3.498,3.968) J10(-4.413,3.968) J11(-5.328,3.968) J13(-6.243,3.968) J15(-7.158,3.968) J16(-7.68,4.362) J18(-8.595,4.362) J20(-9.51,4.362) J22(-10.425,4.362) J23(-11.34,4.362) J26(-12.255,4.362) J28(-13.17,4.362) J30(-14.085,4.362) J32(-15,4.362) J34(-16.269,4.321) J36(-17.184,4.321) J38(-18.105,4.107) J39(-18.755,4.107) J41(-19.405,4.107) J42(-20.055,4.107) J43(-20.705,4.107) J45(-21.78,4.377) J47(-22.43,4.377) K3(-1.3,4.82) K5(-1.95,4.82) K6(-2.583,4.618) K8(-3.498,4.618) K10(-4.413,4.618) K11(-5.328,4.618) K13(-6.243,4.618) K15(-7.222,4.824) K17(-8.137,4.824) K19(-9.052,4.824) K21(-9.967,4.824) K23(-10.882,4.824) K24(-11.797,4.824) K27(-12.713,4.824) K29(-13.628,4.824) K31(-14.543,4.824) K33(-15.458,4.824) L6(-2.583,5.268) L8(-3.498,5.268) L10(-4.413,5.268) L11(-5.328,5.268) L13(-6.243,5.268) L34(-16.269,4.971) L36(-17.184,4.971) L38(-18.105,5.022) L39(-18.755,5.022) L41(-19.405,5.022) L42(-20.055,5.022) L43(-20.705,5.022) L45(-21.455,5.03) L47(-22.726,5.03) M3(-0.972,5.494) M5(-1.96,5.494) M6(-2.583,5.918) M8(-3.498,5.918) M10(-4.413,5.918) M11(-5.328,5.918) M13(-6.243,5.918) M34(-16.269,5.621) M36(-17.184,5.621) M38(-18.105,5.937) M39(-18.755,5.937) M41(-19.405,5.937) M42(-20.055,5.937) M43(-20.705,5.937) M45(-21.78,5.683) M47(-22.43,5.683) N3(-1.3,6.168) N5(-1.95,6.168) N34(-16.269,6.271) N36(-17.184,6.271) N45(-21.455,6.336) N46(-22.105,6.336) P3(-0.975,6.731) P4(-1.625,6.731) P6(-2.583,6.568) P8(-3.498,6.568) P10(-4.413,6.568) P11(-5.328,6.568) P13(-6.243,6.568) P38(-18.105,6.852) P39(-18.755,6.852) P41(-19.405,6.852) P42(-20.055,6.852) P43(-20.705,6.852) R3(-1.3,7.294) R5(-1.95,7.294) R12(-5.738,7.308) R35(-16.72,7.309) R37(-17.643,7.309) R45(-21.78,6.989) R47(-22.43,6.989) T6(-2.676,7.765) T7(-3.326,7.765) T9(-3.976,7.765) T10(-4.626,7.765) T11(-5.276,7.765) T13(-6.2,7.765) T34(-16.258,7.767) T36(-17.181,7.767) T38(-18.105,7.767) T39(-18.755,7.767) T41(-19.405,7.767) T42(-20.055,7.767) T43(-20.705,7.767) T45(-21.455,7.617) T47(-22.726,7.617) U3(-0.972,7.968) U5(-1.96,7.968) U12(-5.738,8.223) U35(-16.72,8.224) U37(-17.643,8.224) U45(-21.78,8.237) U47(-22.43,8.237) V3(-1.3,8.642) V5(-1.95,8.642) V6(-2.676,8.68) V7(-3.326,8.68) V9(-3.976,8.68) V10(-4.626,8.68) V11(-5.276,8.68) V13(-6.2,8.68) V34(-16.258,8.682) V36(-17.181,8.682) V38(-18.105,8.682) V39(-18.755,8.682) V41(-19.405,8.682) V42(-20.055,8.682) V43(-20.705,8.682) V45(-21.455,8.868) V46(-22.106,8.868) W3(-0.975,9.205) W4(-1.625,9.205) W12(-5.738,9.138) W35(-16.72,9.139) W37(-17.643,9.139) Y3(-1.3,9.768) Y5(-1.95,9.768) Y6(-2.676,9.595) Y7(-3.326,9.595) Y9(-3.976,9.595) Y10(-4.626,9.595) Y11(-5.276,9.595) Y13(-6.2,9.595) Y34(-16.258,9.597) Y36(-17.181,9.597) Y38(-18.105,9.597) Y39(-18.755,9.597) Y41(-19.405,9.597) Y42(-20.055,9.597) Y43(-20.705,9.597) Y45(-21.78,9.499) Y47(-22.43,9.499)
  oval 0.254x0.33 smd: A9(-4.333,0) A11(-5.007,0.322) A12(-5.681,0) A14(-6.807,0) A16(-7.481,0.322) A36(-17.289,0.324) A38(-17.942,0) A39(-18.595,0.324) A40(-19.248,0) A42(-19.901,0.324) B9(-4.333,0.65) B12(-5.681,0.65) B14(-6.807,0.65) B38(-17.942,0.65) B40(-19.248,0.65) C36(-17.289,0.974) C42(-19.901,0.974) DU7(-3.195,47.755) DU8(-3.848,47.43) DU11(-5.162,47.43) DU12(-5.815,47.755) DU14(-6.468,47.43) DU16(-7.782,47.43) DU18(-8.435,47.755) DU19(-9.088,47.43) DU22(-10.402,47.43) DU23(-11.055,47.755) DU24(-11.708,47.43) DU28(-13.022,47.43) DU29(-13.675,47.755) DU30(-14.328,47.43) DU33(-15.642,47.43) DU34(-16.295,47.755) DU36(-16.948,47.43) DU38(-18.262,47.43) DU40(-18.915,47.755) DU41(-19.568,47.43) DV8(-3.848,48.08) DV11(-5.162,48.08) DV14(-6.468,48.08) DV16(-7.782,48.08) DV19(-9.088,48.08) DV22(-10.402,48.08) DV24(-11.708,48.08) DV28(-13.022,48.08) DV30(-14.328,48.08) DV33(-15.642,48.08) DV36(-16.948,48.08) DV38(-18.262,48.08) DV41(-19.568,48.08) DW7(-3.195,48.405) DW8(-3.848,48.73) DW10(-4.505,48.405) DW11(-5.162,48.73) DW12(-5.815,48.405) DW14(-6.468,48.73) DW15(-7.125,48.405) DW16(-7.782,48.73) DW18(-8.435,48.405) DW19(-9.088,48.73) DW20(-9.745,48.405) DW22(-10.402,48.73) DW23(-11.055,48.405) DW24(-11.708,48.73) DW27(-12.365,48.405) DW28(-13.022,48.73) DW29(-13.675,48.405) DW30(-14.328,48.73) DW32(-14.985,48.405) DW33(-15.642,48.73) DW34(-16.295,48.405) DW36(-16.948,48.73) DW37(-17.605,48.405) DW38(-18.262,48.73) DW40(-18.915,48.405) DW41(-19.568,48.73) DW42(-20.225,48.405)
  round 0.406 smd: A17(-8.137,0) A19(-9.052,0) A21(-9.967,0) A23(-10.882,0) A24(-11.797,0) A27(-12.713,0) A29(-13.628,0) A31(-14.543,0) B17(-8.137,0.65) B19(-9.052,0.65) B21(-9.967,0.65) B23(-10.882,0.65) B24(-11.797,0.65) B27(-12.713,0.65) B29(-13.628,0.65) B31(-14.543,0.65) C17(-8.137,1.3) C19(-9.052,1.3) C21(-9.967,1.3) C23(-10.882,1.3) C24(-11.797,1.3) C27(-12.713,1.3) C29(-13.628,1.3) C31(-14.543,1.3) D17(-8.137,1.95) D19(-9.052,1.95) D21(-9.967,1.95) D23(-10.882,1.95) D24(-11.797,1.95) D27(-12.713,1.95) D29(-13.628,1.95) D31(-14.543,1.95) F19(-9.052,2.6) F21(-9.967,2.6) F23(-10.882,2.6) F24(-11.797,2.6) F27(-12.713,2.6) F29(-13.628,2.6) F31(-14.543,2.6) G19(-9.052,3.25) G21(-9.967,3.25) G23(-10.882,3.25) G24(-11.797,3.25) G27(-12.713,3.25) G29(-13.628,3.25) G31(-14.543,3.25) H19(-9.052,3.9) H21(-9.967,3.9) H23(-10.882,3.9) H24(-11.797,3.9) H27(-12.713,3.9) H29(-13.628,3.9) H31(-14.543,3.9)
  oval 0.203x0.305 smd: A34(-16.041,0.354) A35(-16.66,0) B35(-16.66,0.65)
  oval 0.305x0.203 smd: AA49(-23.376,10.119) AB48(-23.08,10.739) AB49(-23.73,10.739) AC47(-22.756,11.37) AC49(-23.406,11.37) AE48(-23.08,12.001) AE49(-23.73,12.001) AF49(-23.376,12.621) AG48(-23.08,13.241) AG49(-23.73,13.241) AH1(0,13.659) AH2(-0.65,13.659) AH47(-22.756,13.872) AH49(-23.406,13.872) AJ1(0,14.309) AJ2(-0.65,14.309) AK48(-23.08,14.503) AK49(-23.73,14.503) AL1(0,14.959) AL2(-0.65,14.959) AL49(-23.376,15.123) AM1(0,15.609) AM2(-0.65,15.609) AM48(-23.08,15.743) AM49(-23.73,15.743) AN1(0,16.259) AN2(-0.65,16.259) AN47(-22.756,16.374) AN49(-23.406,16.374) AR1(0,16.909) AR2(-0.65,16.909) AR48(-23.08,17.005) AR49(-23.73,17.005) AT1(0,17.559) AT2(-0.65,17.559) AT49(-23.376,17.625) AU1(0,18.209) AU2(-0.65,18.209) AU48(-23.08,18.245) AU49(-23.73,18.245) AV1(0,18.859) AV2(-0.65,18.859) AV47(-22.756,18.876) AV49(-23.406,18.876) AY1(0,19.509) AY2(-0.65,19.509) AY48(-23.08,19.507) AY49(-23.73,19.507) BA1(0,20.159) BA2(-0.65,20.159) BA49(-23.376,20.127) BB1(0,20.809) BB2(-0.65,20.809) BB48(-23.08,20.747) BB49(-23.73,20.747) BD1(0,21.459) BD2(-0.65,21.459) BD47(-22.756,21.378) BD49(-23.406,21.378) BE1(0,22.109) BE2(-0.65,22.109) BE48(-23.08,22.009) BE49(-23.73,22.009) BF1(0,22.759) BF2(-0.65,22.759) BF49(-23.376,22.629) BG48(-23.08,23.249) BG49(-23.73,23.249) BH1(0,23.409) BH2(-0.65,23.409) BJ1(0,24.059) BJ2(-0.65,24.059) BJ47(-22.756,23.88) BJ49(-23.406,23.88) BL1(0,24.709) BL2(-0.65,24.709) BL48(-23.08,24.511) BL49(-23.73,24.511) BM1(0,25.359) BM2(-0.65,25.359) BM49(-23.376,25.131) BN48(-23.08,25.751) BN49(-23.73,25.751) BP1(0,26.009) BP2(-0.65,26.009) BR1(0,26.659) BR2(-0.65,26.659) BR47(-22.756,26.382) BR49(-23.406,26.382) BT1(0,27.309) BT2(-0.65,27.309) BT48(-23.08,27.013) BT49(-23.73,27.013) BU49(-23.376,27.633) BV1(0,27.959) BV2(-0.65,27.959) BV48(-23.08,28.253) BV49(-23.73,28.253) BW1(0,28.609) BW2(-0.65,28.609) BY1(0,29.259) BY2(-0.65,29.259) BY47(-22.756,28.884) BY49(-23.406,28.884) CA48(-23.08,29.515) CA49(-23.73,29.515) CB1(0,29.909) CB2(-0.65,29.909) CB49(-23.376,30.135) CC48(-23.08,30.755) CC49(-23.73,30.755) CE47(-22.756,31.386) CE49(-23.406,31.386) CF48(-23.08,32.017) CF49(-23.73,32.017) CG49(-23.376,32.637) CH48(-23.08,33.257) CH49(-23.73,33.257) CK47(-22.756,33.888) CK49(-23.406,33.888) CL48(-23.08,34.519) CL49(-23.73,34.519) CM49(-23.376,35.139) CN48(-23.08,35.759) CN49(-23.73,35.759) CR47(-22.756,36.39) CR49(-23.406,36.39) CT48(-23.08,37.021) CT49(-23.73,37.021) CU49(-23.376,37.641) CV48(-23.08,38.261) CV49(-23.73,38.261) CY47(-22.756,38.892) CY49(-23.406,38.892) DA48(-23.08,39.523) DA49(-23.73,39.523) DB49(-23.376,40.143) DC48(-23.08,40.763) DC49(-23.73,40.763) DE47(-22.756,41.394) DE49(-23.406,41.394) DF48(-23.08,42.025) DF49(-23.73,42.025) T49(-23.376,7.617) U48(-23.08,8.237) U49(-23.73,8.237) V47(-22.756,8.868) V49(-23.406,8.868) Y48(-23.08,9.499) Y49(-23.73,9.499)
  oval 0.33x0.254 smd: AB1(-0.322,10.442) AC1(0,11.116) AC2(-0.65,11.116) AE1(0,12.242) AE2(-0.65,12.242) AG1(-0.322,12.916) CC1(-0.322,30.514) CD1(0,31.188) CD2(-0.65,31.188) CF1(0,32.314) CF2(-0.65,32.314) CH1(-0.322,32.988) CJ1(0,33.662) CJ2(-0.65,33.662) CL1(0,34.788) CL2(-0.65,34.788) CN1(-0.322,35.462) CP1(0,36.136) CP2(-0.65,36.136) CT1(0,37.262) CT2(-0.65,37.262) CV1(-0.322,37.936) CW1(0,38.61) CW2(-0.65,38.61) DA1(0,39.736) DA2(-0.65,39.736) DC1(-0.322,40.41) DD1(0,41.084) DD2(-0.65,41.084) DF1(0,42.21) DF2(-0.65,42.21) DG49(-23.376,42.653) DH1(-0.322,42.884) DH48(-23.08,43.236) DH49(-23.73,43.236) DJ1(0,43.558) DJ2(-0.65,43.558) DK47(-22.755,43.889) DK49(-23.405,43.889) DL1(0,44.684) DL2(-0.65,44.684) DL48(-23.08,44.542) DL49(-23.73,44.542) DM47(-22.755,45.106) DM49(-23.405,45.106) DN1(-0.322,45.358) DN48(-23.08,45.67) DN49(-23.73,45.67) DP2(-0.65,46.032) H2(-0.65,3.694) H47(-22.755,3.724) H49(-23.405,3.724) J48(-23.08,4.377) J49(-23.73,4.377) K1(0,4.82) K2(-0.65,4.82) L49(-23.405,5.03) M1(-0.322,5.494) M48(-23.08,5.683) M49(-23.73,5.683) N1(0,6.168) N2(-0.65,6.168) N47(-22.755,6.336) N49(-23.405,6.336) R1(0,7.294) R2(-0.65,7.294) R48(-23.08,6.989) R49(-23.73,6.989) U1(-0.322,7.968) V1(0,8.642) V2(-0.65,8.642) Y1(0,9.768) Y2(-0.65,9.768)

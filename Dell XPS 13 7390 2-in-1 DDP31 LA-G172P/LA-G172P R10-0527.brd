# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.05V_VCCSTG: length 120.6
  TOP w0.762: v5(107.03,7.63) 108.11,8.71 v6(108.11,15.09) v1(108.11,17)
  IN1 w0.254: v2(90.77,23.34) 89.8,24.31 89.8,47.17 95.05,52.41 v1(99.69,52.41)
  IN1 w0.508: v1(129.76,21.52) 130.58,21.52 v2(130.69,21.64)
  IN1 w0.762: v1(108.11,17) 107.16,17 107,17.16 101.63,17.16 100.87,17.92 v2(100.87,20.36)
  IN2 w0.762: v2(130.69,21.64) 131.67,21.64 133.23,20.07 133.23,17.87 129.64,14.28 112.98,14.28 107.03,8.32 v5(107.03,7.63)
  IN3 w0.254: v4(132.81,27.32) 132.47,27.66 131.25,27.66 v4(130.91,27.32) 130.88,27.29 130.88,25.98 130.63,25.73 130.63,24.71 130.4,24.48 130.4,21.93 v2(130.69,21.64)
  IN3 w0.508: v4(112.68,3.11) 112.68,3.4 111.03,5.05 110.26,5.05 107.68,7.63 v5(107.03,7.63)
  IN3 w0.762: v2(90.77,23.34) 93.76,20.36 v2(100.87,20.36)
+1.8V_1.2V_SSD:
  vias: v6(190.34,18.07)
+1.8V_1.2V_SSD_R:
  vias: v6(186.31,15.05)
+1.8V_1.2VDX_SSD:
  vias: v5(194.2,29.5) v5(194.2,28.93) v5(194.76,29.5) v5(194.76,28.93) v5(199.11,36.04) v5(199.11,35.28) v5(202.29,36.05) v5(202.31,35.32) v6(196.25,29.63)
+1.8V_3.3V_ALW_VTR3: length 16.2
  TOP w0.254: v5(210.3,55.86) UE1.N5
  BOTTOM w0.508: v5(199.05,66.55) 199.93,66.55 200.44,66.03 200.44,62.84 v6(203.62,59.66) 204,59.28 205.32,59.28 206.51,58.09 207.12,58.09 208.7,56.5
+1.8V_MEM: length 58.3
  TOP w0.2: v5(158.81,64.14) 158.49,64.46 UD1.T9 ; v5(128.07,64.13) 127.74,64.46 UD3.G4 ; v5(113.21,64.14) 112.9,64.46 UD4.G4 ; 112.89,58.61 v5(113.23,58.94)
  TOP w0.203: UD4.T4 112.89,58.61 ; UD3.T9 131.67,58.61 131.19,58.86 v1(131.19,58.87) ; UD4.T9 116.75,58.61 v5(116.43,58.93)
  TOP w0.25: v5(124.37,65.31) 124.43,65.31 124.63,65.11 UD3.F1 ; v5(154.71,57.96) UD1.F12 ; v5(166.11,65.11) UD1.U1 ; v5(109.7,65.11) UD4.F1 ; 120.32,65.11 v5(120.49,64.93) ; v5(120.33,58.02) 120.27,57.96 UD4.U12 ; v5(109,57.96) UD4.U1
  TOP w0.254: v5(109,57.96) 108.96,57.92 108.94,57.92 CD14.1 ; CD31.1 135.8,64.87 135.49,64.57 v5(135.22,64.57) 134.68,65.11 UD3.F12 ; v5(148.44,58.93) 148.75,58.61 UD2.G4 ; v5(140.34,57.38) 140.34,57.42 140.22,57.54 CD52.1 140.29,57.96 UD2.F12 ; v5(151.75,57.87) 151.66,57.96 UD2.F1 ; UD2.G9 144.9,58.61 v5(145.23,58.94) ; UD1.G4 162.34,58.61 v5(162.02,58.93) ; v5(155.59,57) 155.16,57 154.76,57.4 153.6,57.4 153.35,57.15 CD51.1 ; UD1.F1 165.61,57.96 166.06,57.5 v5(166.28,57.5) ; CD8.1 CD16.1 120.54,64.88 v5(120.49,64.93) ; v5(158.82,58.94) 158.82,58.94 158.49,58.61 UD1.G9 ; v5(109.7,65.11) 109.65,65.06 CD13.1 ; v5(140.42,64.44) 140.22,64.64 CD53.1 140.99,65 141.1,65.11 UD2.U12 ; CD32.1 123.54,66.14 v5(124.37,65.31) ; CD67.1 154.01,66.19 154.55,65.64 154.55,65.36 154.81,65.11 v5(154.91,65.11) UD1.U12 ; CD30.1 135.33,57.97 134.91,58.39 v5(134.82,58.39) 134.51,58.39 UD3.U12 ; v5(120.33,58.02) 120.86,58.02 121,57.89 CD15.1 ; UD4.F12 120.32,65.11 ; UD3.U1 v5(124.37,57.96)
  TOP w0.356: 151.99,65.11 UD2.U1 ; CD305.1 167.09,65.2 167,65.29 CD70.1 ; CD303.1 153.35,55.84 CD69.1 CD51.1 ; v5(166.28,57.5) 166.47,57.5 166.85,57.12 CD68.1
  TOP w0.381: CD67.1 153.93,66.53 153.68,66.79 CD12.1 ; CD10.1 136.82,64.87 CD31.1 ; CD54.1 153,65.58 v5(152.52,65.11) 151.99,65.11 ; v5(124.37,57.96) 123.62,57.96 123.54,57.89 CD29.1 CD15.1 ; CD13.1 107.14,65.06 CD9.1 ; CD70.1 166.64,65.63 v5(166.11,65.11) ; CD11.1 136.86,57.97 CD30.1
  IN1 w0.254: v2(162.08,64.16) 162.11,64.16 v1(162.41,64.46) ; v1(131.19,58.87) 131.24,58.93 131.34,58.93 131.49,58.77 v2(131.54,58.77) ; v1(116.82,64.46) 116.9,64.46 v2(117.19,64.17) ; v2(145.08,64.21) 144.83,64.46 v1(144.83,64.46) ; v2(149.11,64.74) 149.1,64.73 149.09,64.73 v1(148.83,64.46) ; v2(128.02,58.53) 128.02,58.55 127.96,58.61 v1(127.68,58.61) ; v1(131.68,64.46) v2(131.43,64.21)
  IN3 w0.254: v2(131.54,58.77) 131.42,58.65 v4(131.42,58.4) ; v2(145.08,64.21) 145.36,64.21 v4(145.41,64.16) ; v4(149.49,64.87) 149.22,64.87 149.13,64.77 149.13,64.76 149.11,64.75 v2(149.11,64.74) ; v4(116.81,64.17) v2(117.19,64.17) ; v4(162.32,63.93) 162.1,64.16 v2(162.08,64.16) ; v2(131.43,64.21) v4(130.99,64.21) ; v2(128.02,58.53) 128.02,58.55 127.96,58.61 v4(127.67,58.61)
  vias: v5(168.68,61.61) v5(168.68,61.03) v5(168.68,60.46) v6(137.07,60.87)
+1.8V_MEM_R:
  vias: v3(171.86,62.14)
+1.8V_PRIM: length 226.2
  TOP w0.254: UE10.6 v5(201.38,50.32)
  TOP w0.356: RC351.1 147.04,20.74 146.72,20.42 146.72,19.29 146.93,19.07 ; RH615.1 v1(177.43,36.99)
  TOP w0.508: 137.64,2.86 104.26,2.86 103.51,3.61 v5(103.24,3.61) ; v1(140.56,4.18) 140.56,3.4 140.02,2.86 138.62,2.86
  IN1 w0.254: v2(177.01,36.99) v1(177.43,36.99) 177.43,36.69 178.7,35.41 180.44,35.41 v1(180.75,35.72) ; v1(171.61,56.36) 171.8,56.17 v2(171.93,56.17) ; v1(171.19,55.79) v2(171.19,56.13)
  IN1 w0.508: v2(181.72,38.02) 181.58,38.02 v1(181.27,38.33) ; v1(211.69,52.27) v2(211.69,51.81) ; v2(193.32,62.46) 193.32,60.36 192.01,59.04 192.01,54.92 191.49,54.4 191.49,51.14 v1(191.95,50.67) 191.95,50.35 191.36,49.76 191.36,49.04 190.27,47.95 190.27,46.8 v2(189.83,46.37) ; v2(140.88,4.49) v1(140.56,4.18)
  IN2 w0.508: v2(211.69,51.81) 210.67,51.81 209.22,50.36 206.65,50.36 205.9,49.6 203.54,49.6 202.5,50.65 201.71,50.65 v5(201.38,50.32) 201.38,49.81 200.71,49.14 196.9,49.14 v5(196.2,49.85)
  IN3 w0.254: v4(182.47,38.39) 182.47,38.39 182.1,38.02 v2(181.72,38.02)
  IN3 w0.508: v2(146.36,16.61) 142.09,12.34 142.09,8.93 139.97,6.81 139.97,5.4 v2(140.88,4.49) ; v4(172.18,26.17) v2(172.51,26.17) ; v5(199.83,65.73) 199.83,64.85 198.79,63.81 197.23,63.81 v4(196.92,63.5) 196.75,63.33 194.18,63.33 v4(194.06,63.22) 193.64,63.22 193.32,62.9 v2(193.32,62.46) 192.15,62.46 191.43,63.18 190.71,63.18 189.86,62.33 v4(189.45,62.33) ; v4(177.77,37.25) 177.26,37.25 v2(177.01,36.99)
  IN3 w0.762: v4(149.78,19.04) 148.79,19.04 v2(146.36,16.61)
  BOTTOM w0.254: v4(189.45,62.33) 189.45,57.82 190.47,56.81 192.46,56.81 ; RH725.2 192.63,56.23 192.46,56.41 192.46,56.81 ; 192.46,56.81 192.46,57.33 192.71,57.58 193.23,57.58 193.31,57.5 RH724.2
  BOTTOM w0.356: RW43.2 196.35,61.31 RW1.2 196.62,61.4 196.94,61.73 196.94,63.49 v4(196.92,63.5) ; RW29.2 194.36,60.74 194.57,60.95 194.57,62.84 194.19,63.22 v4(194.06,63.22) ; RH612.1 RH614.1 RH616.1 182.15,38.71 v4(182.47,38.39)
  BOTTOM w0.508: v5(103.24,3.61) 103.4,3.76 103.4,7.75 103.28,7.87 103.28,18.45 104.43,19.59 104.43,23.3 102.96,24.77 94.74,24.77 94.14,24.17 94.14,22.77 93.7,22.33 89.63,22.33 84.74,17.44 71.03,17.44 70.14,18.32 v5(68.82,18.32)
  BOTTOM w0.762: v4(149.78,19.04) 149.78,19.76 150.4,20.38 168.71,20.38 v6(172.18,23.85) v4(172.18,26.17)
  vias: v1(147.12,16.61) v1(147.8,16.18) v1(170.78,56.3) v1(170.78,55.92) v5(195.27,23.3) v5(195.27,22.73) v5(195.27,22.16) v5(195.9,23.3) v5(195.9,22.73) v5(195.9,22.16) v5(196.47,23.3) v5(196.47,22.73) v5(196.47,22.16)
+1.8V_PRIMP: length 14.5
  TOP w0.254: PR502.1 211.82,18.2 v1(212.34,18.2)
  IN1 w0.254: v1(200.03,21.61) 202.19,19.45 211.09,19.45 v1(212.34,18.2)
  vias: v6(203.8,19.15)
+1.8VS: length 108
  TOP w0.356: v1(199.49,50.29) 199.49,49.86 200.04,49.31 201.77,49.31 v5(201.96,49.51) ; C248.1 188.56,52.93 188.75,52.74 v1(188.75,52.17) ; R724.2 R445.1 R444.1 210.83,36.13 v5(210.86,36.13)
  IN1 w0.508: v2(199.79,52.13) 199.8,52.13 200.58,52.13 200.87,51.84 200.87,51.1 200.41,50.65 199.84,50.65 v1(199.49,50.29) ; v2(189.58,51.69) 189.24,51.69 v1(188.75,52.17)
  IN2 w0.508: v2(160.56,79.18) 160.97,79.18 162.34,80.55 166.78,80.55 167.79,79.55 167.79,76.8 171.97,72.62 174.25,72.62 175.09,71.78 176.88,71.78 179.83,68.83 190.25,68.83 190.61,69.19 191.29,69.19 191.96,68.52 v5(194.03,68.52) ; v2(189.58,51.69) 191.55,51.69 192.11,52.24 193.19,52.24 193.48,51.95 194.23,51.95 194.52,52.25 199.68,52.25 v2(199.79,52.13)
  IN3 w0.508: v4(196.51,51.03) 197.81,52.32 199.6,52.32 v2(199.79,52.13) ; v5(201.96,49.51) 205.2,46.27 205.2,42.34 210.86,36.68 v5(210.86,36.13) ; v4(161.07,79.18) v2(160.56,79.18) v4(160.05,79.18)
  BOTTOM w0.508: v4(196.51,51.03) 196.51,52.43 196.25,52.69 196.25,55.53 197.74,57.01 197.74,58.86 198.58,59.7 198.58,63.65 197.98,64.25 197.98,64.47 195.49,66.97 193.37,66.97 192.67,67.66 192.67,68.14 v6(193.18,68.64) 193.9,68.64 v5(194.03,68.52)
+1.8VS_AUDIO: length 61.8
  TOP w0.203: UA1.20 33.53,16.83
  TOP w0.254: v1(35.91,16.66) 35.49,17.08 CA24.1 34.97,16.9 33.6,16.9 33.53,16.83 ; v1(48.53,12.9) 48.53,13.6 48.86,13.94 48.86,16.08 47.7,17.25 47.36,17.25 v1(47.01,17.6) ; RA41.1 36.93,13.77 36.51,13.36 36.03,13.36 35.47,12.8 v1(35.47,12.04) 35.47,11.7 35.18,11.41 35.18,10.8 v6(35.15,10.77) 34.7,10.32 RA36.1
  IN1 w0.254: v1(35.47,12.04) 35.51,12.08 41.17,12.08 41.99,12.9 v1(48.53,12.9) 48.74,12.9 49.09,13.24 58.97,13.24 61.16,11.06 66.05,11.06 66.39,11.4 v1(67.71,11.4) ; v1(35.91,16.66) 35.97,16.66 37.22,15.41 39.89,15.41 40.64,16.16 43.85,16.16 44.44,16.75 44.44,17.11 45.11,17.78 46.37,17.78 46.55,17.6 v1(47.01,17.6)
+3.3V_ALW2: length 155
  TOP w0.254: v5(202.36,65.24) 202.62,65.51 RE152.1
  IN1 w0.254: v2(165.81,71.86) 165.05,71.86 164.16,72.76 154.34,72.76 153.73,72.14 143.37,72.14 143.12,71.9 136.34,71.9 135.98,71.54 125.19,71.54 124.97,71.32 107.47,71.32 106.4,72.39 99.61,72.39 98.89,71.66 97.27,71.66 93.23,67.63 89.43,67.63 88.01,69.05 v2(88.01,69.44) ; v1(78.71,58.6) 78.82,58.48 81.24,58.48 81.83,57.89 86.81,57.89 86.97,57.73 86.97,57.1 86.79,56.92 86.13,56.92 85.95,56.74 85.95,55.57 v2(85.57,55.2) v1(85.16,55.2)
  IN2 w0.254: v2(165.81,71.86) 170.02,67.65 170.02,67.57 172.68,64.91 174.84,64.91 175.28,65.35 177.75,65.35 178.44,64.66 188.94,64.66 189.1,64.82 194,64.82 194.01,64.81 195.16,63.65 198.15,63.65 198.51,63.3 200.9,63.3 201.9,64.3 201.9,64.78 v5(202.36,65.24) ; v2(85.57,55.2) 85.68,55.31 85.68,57.14 84.37,58.44 84.37,66.14 87.68,69.44 v2(88.01,69.44)
  BOTTOM w0.081: v3(201.82,66.22) 201.82,66.2 202.36,65.67 v5(202.36,65.24)
+3.3V_ALW_UE1: length 26.9
  TOP w0.254: v5(213.12,60.77) 212.73,61.16 UE1.G8 ; UE1.K2 207.5,59.16 207.5,59.96 UE1.H1
  IN1 w0.254: v1(213.5,57.16) v2(213.5,57.49) 213.5,57.88 213.09,58.29 213.09,59.67 213.18,59.77 213.18,60.13 213.12,60.19 v5(213.12,60.77) ; v1(211.9,65.16) 212.28,65.54 v2(212.37,65.54)
  IN2 w0.254: v5(206.12,60.19) 206.25,60.06 207.7,60.06 207.88,60.23 208.37,60.23 208.91,60.77 210.65,60.77 211.15,61.28 212.62,61.28 v5(213.12,60.77) 213.13,60.77 213.71,61.35 213.71,61.62 215.62,63.52 215.62,65.19 215.26,65.54 v2(212.37,65.54)
  IN3 w0.254: v4(211.62,65.09) 212.07,65.54 v2(212.37,65.54) ; v2(213.5,57.49) v4(213.5,57.82)
  BOTTOM w0.254: v4(211.62,65.09) 211.63,65.11 CE44.1 ; v4(213.5,57.82) 213.58,57.73 CE50.1 CE51.1
+3.3V_BAT_LDO: length 437.2
  TOP w0.254: v5(180.94,5.31) 180.94,6.77 v3(180.28,7.44) 179.62,8.1 RTCD2.2 ; v1(36.55,8.38) 36.88,8.72 38.09,8.72 38.74,9.37 PR110.2 39.31,10.44 PD101.2 ; v1(93.82,7.91) 93.82,8.6 92.9,9.52 PD604.2 ; QE23.2 215.22,70.25 215.56,70.59 216.12,70.59 216.82,71.28 216.82,71.55 217.58,72.31 RE520.1 220.24,72.43 220.76,71.92 220.76,68.93 221.75,67.94 221.75,62.33 221.5,62.08 v5(220.89,62.08)
  IN1 w0.254: v2(259.68,15.47) 260.07,15.85 261.35,15.85 262.22,16.72 263.77,16.72 264.33,16.17 264.33,14.3 266.04,12.58 272.45,12.58 273.29,13.42 v1(273.29,13.93) 275,13.93 v2(275.05,13.88) ; v1(93.82,7.91) 94.51,7.22 v2(94.51,2.79) ; v2(36.1,8.38) v1(36.55,8.38) ; v2(12.8,11.52) 10.9,11.52 9.24,13.18 9.24,14.18 v1(7.68,15.74)
  IN2 w0.254: v2(275.05,13.88) 274.92,13.75 274.92,10.77 273.97,9.82 273.97,8.8 267.61,2.43 238.21,2.43 237.48,1.71 226.73,1.71 223.48,4.96 221.67,4.96 221.31,4.6 218.63,4.6 216.52,2.49 187.45,2.49 184.41,5.54 181.17,5.54 v5(180.94,5.31) 177.43,1.8 153.21,1.8 152.56,2.45 133.71,2.45 132.99,1.73 96.07,1.73 95.01,2.79 v2(94.51,2.79) 93.85,2.79 92.86,1.8 81.01,1.8 76.69,6.12 76.69,7.63 75.67,8.65 58.9,8.65 58.81,8.74 45.37,8.74 45.05,9.05 37.18,9.05 36.51,8.38 v2(36.1,8.38) 35.1,9.38 27.29,9.38 26.51,8.61 26.51,7.28 25.97,6.74 23.11,6.74 19.97,3.59 15.27,3.59 12.8,6.06 v2(12.8,11.52) ; v2(259.68,15.47) 257.66,13.45 249.22,13.45 249.08,13.31 230.17,13.31 223.26,20.21 223.26,23.26 222.82,23.7 222.82,24.88 221.99,25.71 221.99,27.3 222.12,27.43 222.12,38.87 221.36,39.63 221.36,54.72 220.38,55.7 220.38,61.82 220.63,62.08 v5(220.89,62.08)
+3.3V_EC_PLL: length 4.4
  TOP w0.254: RE113.2 203.45,62.9 CE47.1 204.67,62.9 CE48.1 205.42,62.62 206.08,61.96 UE1.F1
+3.3V_TBT_L: length 48.8
  TOP w0.305: RT16.2 v1(4.05,46.12) RT13.2 RT172.2
  IN1 w0.305: v2(3.96,45.64) 4.05,45.73 v1(4.05,46.12)
  IN1 w0.381: v2(8.64,37.13) 8.66,37.15 9.34,37.15 9.36,37.13 9.37,37.13 9.53,36.97 9.57,36.97 9.59,36.95 10.05,36.95 10.17,36.83 11.35,36.83 12.26,35.91 v1(12.65,35.91) ; v1(18.68,45.57) 18.68,46.63 18.12,47.19 v2(17.72,47.19)
  IN2 w0.381: v2(17.72,47.19) 17.5,46.96 15.71,46.96 15.33,47.34 15.33,49.62 14.42,50.53 5.7,50.53 v2(5.68,50.54) ; v2(3.96,45.64) 5.79,43.81 5.79,40.25 7.64,38.41 7.64,37.32 7.98,36.98 8.49,36.98 v2(8.64,37.13)
  IN3 w0.381: v2(5.68,50.54) 5.46,50.54 4.64,49.73 4.64,47.94 3.96,47.25 v2(3.96,45.64) 5.81,43.79 7.21,43.79 7.78,44.36 v4(7.78,44.61)
  BOTTOM w0.127: v6(7.59,44.16) 7.59,44.23 7.78,44.42 v4(7.78,44.61)
  BOTTOM w0.381: RT218.2 8.53,44.23 RT181.2 8.03,44.87 v4(7.78,44.61)
  BOTTOM w0.508: RT180.2 RT181.2
+3.3V_TBT_L_ANA: length 2.6
  IN1 w0.254: v1(13.82,43.55) 13.82,43.09 v2(13.75,43.01)
  IN3 w0.254: v2(13.75,43.01) 13.88,43.14 v4(13.88,43.32)
  BOTTOM w0.102: v3(14.27,41.84) 14.27,42.92 v4(13.88,43.32)
+3.3V_TBT_L_DB: length 7.8
  TOP w0.081: v1(17.69,45.3) 17.83,45.3 RT203.1
  IN1 w0.064: v2(17.3,45.19) 17.42,45.3 v1(17.69,45.3) ; v2(13.37,43.92) 13.37,44.65 v1(13.05,44.97)
  IN3 w0.064: v2(17.3,45.19) 17.24,45.12 17.24,43.92 16.61,43.28 14.45,43.28 14.07,43.66 13.62,43.66 v2(13.37,43.92)
+3.3V_TBT_L_FLASH: length 47.3
  TOP w0.254: UTS1.8 v5(17.9,32.74) 18.08,32.74 18.17,32.65 RT23.2
  IN1 w0.254: v2(8.17,25.2) 9.42,25.2 v1(9.66,25.44)
  IN2 w0.254: v2(5.3,45.19) 5.3,45.14 6.21,44.23 6.21,40.43 8.06,38.58 8.06,37.77 8.25,37.57 v5(8.25,37.54) ; v2(8.17,25.2) 7.88,25.2 7.61,25.46 7.61,27.99 8.39,28.76 8.39,29.54 7.86,30.07 v2(7.86,30.97)
  GND3 w0.254: v9(8.44,30.71) 8.12,30.71 v2(7.86,30.97)
  IN3 w0.254: v4(5.26,45.59) 5.26,45.35 5.3,45.31 v2(5.3,45.19)
  BOTTOM w0.254: v9(8.44,30.71) 8.02,30.71 7.81,30.92 7.81,37.1 v5(8.25,37.54) 8.4,37.7 11.78,37.7 11.94,37.85 15.94,37.85 v3(16.42,37.37) 18,35.79 18,32.84 v5(17.9,32.74) ; v9(8.44,30.71) 8.44,30.9 8.69,31.15 9.56,31.15 9.96,30.75 RT22.2 ; v9(8.44,30.71) RT21.2 ; JDB3.1 v4(5.26,45.59)
+3.3V_TBT_L_FLASH_R: length 40
  TOP w0.254: v5(7.89,28.97) 7.89,27.2 DT1.2
  IN1 w0.254: v2(7.36,48.54) 7.36,49.76 7.72,50.11 8.03,50.11 v1(8.29,50.37) ; v5(8.11,39.19) 8.11,39.03 9.77,37.37 10.22,37.37 10.34,37.25 v1(10.66,37.25)
  IN2 w0.254: v5(8.11,39.19) 8.21,39.29 8.21,42.2 7.48,42.93 7.04,42.93 6.57,43.4 6.57,44.38 5.73,45.21 5.73,47.14 7.13,48.54 v2(7.36,48.54)
  BOTTOM w0.254: RT176.1 10.45,39.24 8.16,39.24 v5(8.11,39.19) 7.45,38.53 v6(7.45,29.5) 7.45,29.21 7.69,28.97 v5(7.89,28.97) 8.15,28.97 8.79,29.61 10.59,29.61 12.83,31.86 RT169.1
+3.3V_TBT_L_LC: length 9.2
  IN1 w0.254: v1(11.1,44.97) 11.38,44.97 v2(11.43,44.92) 11.71,44.64 11.71,43.66 11.89,43.48 11.89,42.19 11.69,42 v2(10.66,42)
  IN3 w0.254: v4(11.06,44.93) 11.42,44.93 v2(11.43,44.92) ; v2(10.66,42) 10.71,42.05 v4(11.02,42.05)
  BOTTOM w0.102: RT64.2 v3(12.12,43.09)
  BOTTOM w0.254: RT176.2 10.88,40.73 RT65.2 RT63.2 v4(11.02,42.05) 11.2,42.23 RT64.2
+3.3V_TBT_L_SVR: length 6.9
  IN3 w0.305: v5(14.78,44.34) 14.56,44.56 13.47,44.56 13.36,44.68 12.03,44.68 11.75,44.4 11.75,43.87 11.45,43.56 11.02,43.56 10.07,44.51 v4(10.07,44.61)
  BOTTOM w0.305: v4(10.07,44.61) 9.81,44.87 RT181.1
+3.3V_TBT_L_SX: length 2.7
  IN1 w0.254: v2(11.34,45.85) 11.11,45.62 v1(11.1,45.62)
  IN3 w0.254: v4(11.06,45.57) v2(11.34,45.85)
  BOTTOM w0.254: RT180.1 9.75,45.69 10.03,45.97 10.76,45.97 11.06,45.67 v4(11.06,45.57)
+3.3V_TBT_R: length 55
  TOP w0.356: RT173.2 274.43,39.84 v5(273.98,39.84)
  TOP w0.381: RT41.2 274.18,35.32 v5(274.11,35.24) 273.97,35.1 273.97,34.05 274.42,33.6 RT38.2 RT37.2 274.42,33.03 274.11,32.72 274.11,32.2 274.43,31.88 RT219.2
  IN1 w0.381: v2(290.1,32.21) 290.7,31.62 290.7,26.63 288.32,24.26 v1(288.32,23.96) ; v1(286.23,34.82) v2(286.56,34.82)
  IN2 w0.381: v5(273.98,39.84) 274.45,39.84 274.95,40.33 274.95,42.2 275.95,43.2 282.95,43.2 283.38,42.77 288.69,42.77 290.63,40.83 290.63,32.75 v2(290.1,32.21) 289.17,32.21 v2(286.56,34.82)
  IN3 w0.381: v5(273.98,39.84) 274.22,39.84 274.73,39.32 274.73,35.6 274.38,35.24 v5(274.11,35.24)
  BOTTOM w0.102: v5(274.11,35.24) v6(274.11,34.69)
+3.3V_TBT_R_ANA: length 1.8
  IN1 w0.254: v1(281.69,35.62) v2(282.04,35.62)
  IN3 w0.254: v2(282.04,35.62) 281.99,35.57 v4(281.66,35.57)
  BOTTOM w0.102: v3(282.54,35.12) 282.08,35.57 v4(281.66,35.57)
+3.3V_TBT_R_B:
  vias: v3(286.35,30.96)
+3.3V_TBT_R_DB: length 8.3
  TOP w0.356: RT202.1 v1(288.28,37.2)
  IN1 w0.254: v1(288.28,37.2) 288.06,37.2 287.93,37.07 286.6,37.07 286.12,36.6 285.34,36.6 285.13,36.8 281.16,36.8 v1(280.92,37.04)
+3.3V_TBT_R_FLASH: length 50.9
  TOP w0.254: v1(256.28,17.63) RT45.2 259.18,17.92 258.7,18.39 DT2.1 258.7,19.57 260.47,21.33 261.92,21.33 262.48,20.77 262.48,20.55 262.85,20.17 v1(263.75,20.17) ; RT44.2 RT43.2 v1(246.82,17.63)
  IN1 w0.254: v1(256.28,17.63) 255.93,17.98 247.17,17.98 v1(246.82,17.63) ; v1(263.75,20.17) v2(264.08,20.17)
  IN3 w0.254: v2(264.08,20.17) v4(264.44,20.17)
  BOTTOM w0.254: JDB4.1 286.59,27.07 285.24,25.72 285.24,24.07 284.12,22.94 273.8,22.94 273.4,23.34 v3(269.65,23.34) 269.04,23.34 267.19,21.5 265.77,21.5 v4(264.44,20.17)
+3.3V_TBT_R_FLASH_R: length 100
  TOP w0.254: RT177.1 274.16,27.87 273.84,28.19 273.84,30.14 v5(274.1,30.39) ; v1(257.76,18.48) 257.33,18.48 DT2.2 257.18,20.18 258.81,20.18 260.32,21.69 262.06,21.69 263.02,20.74 v5(263.11,20.74) ; RT171.1 289.84,34.14 v5(290.1,33.88)
  IN1 w0.254: v2(237.65,18.45) 237.7,18.4 238.91,18.4 239.79,17.52 240.22,17.52 241.21,16.53 245.31,16.53 245.65,16.86 246.41,16.86 246.9,16.38 247.55,16.38 248.43,17.26 255.04,17.26 255.35,16.94 256.86,16.94 257.49,17.57 257.49,18.21 v1(257.76,18.48) ; v5(275.62,40.8) 275.81,40.8 276.18,40.42 277.02,40.42 277.21,40.23 277.78,40.23 277.97,40.04 277.97,39.15 277.53,38.71 277.53,38.23 276.84,37.55 276.84,36.02 275.01,34.19 275.01,32.64 274.1,31.73 v5(274.1,30.39)
  IN2 w0.254: v5(290.1,33.88) 290.1,40.64 288.39,42.35 283.21,42.35 282.92,42.65 281.11,42.65 280.35,41.88 278.26,41.88 277.81,41.43 276.54,41.43 275.91,40.8 v5(275.62,40.8)
  IN3 w0.254: v5(274.1,30.39) 274.1,29.25 272,27.15 272,25.58 270.7,24.27 269.58,24.27 268.93,23.62 268.93,23.24 267.25,21.56 264,21.56 263.18,20.74 v5(263.11,20.74) ; v2(237.65,18.45) 237.6,18.4 v4(237.28,18.4)
  BOTTOM w0.102: v5(274.1,30.39) 274.1,30.4 v6(274.78,30.4)
  BOTTOM w0.254: RT187.1 275.34,40.73 275.41,40.8 v5(275.62,40.8) ; RT170.1 232.76,13.88 v4(237.28,18.4)
+3.3V_TBT_R_LC: length 10.4
  IN1 w0.254: v2(278.67,36.74) 278.67,36.79 278.92,37.04 v1(278.97,37.04)
  IN1 w0.381: v2(278.67,36.74) 278.54,36.61 278.54,35.98 277.85,35.28 277.36,35.28 276.68,34.6 276.68,33.9 276.89,33.69 276.89,32.68 276.5,32.28 276.5,31.39 275.05,29.95 v1(275.05,29.21)
  IN3 w0.254: v4(279.09,36.93) 278.93,36.93 278.8,36.8 278.73,36.8 v2(278.67,36.74)
+3.3V_TBT_R_SX: length 11.4
  TOP w0.203: v5(278.66,38) URT2.E6
  IN1 w0.254: v1(287.75,35.74) 287.75,36.1 v2(287.55,36.31)
  IN2 w0.254: v2(287.55,36.31) 287.26,36.6 280.07,36.6 v5(278.66,38)
  BOTTOM w0.356: v5(278.66,38) 278.73,38 279.09,37.65 CT70.1
+3.3V_VPS_TPM:
  vias: v1(210.46,3.97) v1(210.8,3.96) v1(215.22,9.04) v1(215.31,9.91) v1(215.53,9.68) v1(215.7,13.24) v1(216.14,13.26) v2(210.54,4.42) v2(211.03,4.42) v2(216.21,5.42) v2(216.75,5.42) v3(216,15.59)
+3.3VA_TBT_L: length 16.7
  TOP w0.254: v1(14.02,37.79) RT79.2
  IN1 w0.254: v1(14.02,37.79) 15.11,37.79 v2(15.78,37.12) ; v1(13.05,46.27) 13.05,46.35 v2(12.83,46.57)
  IN3 w0.254: v2(12.83,46.57) 13.05,46.35 v4(13.05,46.29) ; v4(16.48,37.95) 16.48,37.67 15.93,37.12 v2(15.78,37.12)
  BOTTOM w0.254: v4(16.48,37.95) 16.48,39.85 v6(17.24,40.61) 17.24,42.96 15.84,44.36 15.84,46.01 15.56,46.29 CT302.1 v4(13.05,46.29)
+3.3VA_TBT_R: length 10.1
  TOP w0.254: v1(286.91,36.68) 286.99,36.6 RT88.2
  IN1 w0.254: v2(281.27,38.2) 281.13,38.34 v1(280.92,38.34) ; v1(286.91,36.68) 286.37,36.13 v2(285.3,36.13)
  IN3 w0.254: v2(285.3,36.13) 285.3,36.21 283.09,38.42 v4(281.66,38.42) 281.49,38.42 v2(281.27,38.2)
  BOTTOM w0.076: v3(282.54,38.74) 282.22,38.42 v4(281.66,38.42)
  BOTTOM w0.356: v4(281.66,38.42) CT305.1
+3.3VDX_SSD: length 9.4
  TOP w0.102: v6(194.49,20.05) v6(194.49,21.8) 194.49,21.92 194.49,21.92 v6(194.49,23.55) 194.75,23.81 194.98,23.81 195.95,24.77 195.95,25.4 196.82,26.27 CC388.1
  TOP w0.254: USSD1.E10 v5(201.46,44.12) ; USSD1.E9 200.65,44.12 v5(200.65,44.11) ; USSD1.D9 v5(200.66,44.92) ; USSD1.D10 v5(201.46,44.92)
  vias: v5(200.69,32.87) v5(200.69,32.1) v5(200.82,29.46) v5(200.82,28.83) v5(201.39,29.46) v5(201.39,28.83) v5(201.52,32.87) v5(201.52,32.1)
+3V_1.8V_HDA: length 11.8
  TOP w0.381: LC2.2 177.92,38.31 CC168.2 CC23.1 v5(176.25,38.31)
  IN1 w0.381: v1(168.08,36.4) v2(168.08,36.77)
  IN3 w0.381: v5(176.25,38.31) 173.25,38.31 172.65,37.71 169.87,37.71 169.58,38.01 168.83,38.01 168.08,37.26 v2(168.08,36.77)
+3V_5V_CAM_PWR:
  vias: v3(170.59,64.93)
+3V_NB_LID: length 288
  TOP w0.254: PR606.1 87.56,9.32 v1(88,9.32) 88.38,9.32 88.43,9.37 89.06,9.37 89.58,8.85 PR601.1 ; RE478.1 212.94,52.86 RE411.1 213.43,50.21 v5(213.41,50.19) 213.25,50.04 RE479.1
  TOP w0.508: PR602.1 92.37,8.24 92.89,7.72 v5(92.89,6.72) ; R390.2 58.53,20.62 v1(58.39,20.48)
  IN1 w0.254: v2(249.84,5.35) 249.84,6.26 249.95,6.37 v1(249.95,8.93) ; v1(88,9.32) 88.01,9.31 88.01,8.95 87.26,8.2 86.34,8.2 85.12,6.98 79.04,6.98 76.49,9.53 73.86,9.53 72.69,10.69 70.67,10.69 68.41,12.95 65.73,12.95 65.39,12.61 63.13,12.61 59.33,16.41 59.33,17.06 v5(58.79,17.6)
  IN1 w0.508: v1(58.39,20.48) v2(58.01,20.1)
  IN2 w0.508: v2(181.85,7.42) 185.54,7.42 187.55,5.41 195.46,5.41 196.17,6.12 200.38,6.12 201.57,4.93 204.66,4.93 205.23,5.5 207.29,5.5 v2(208.5,6.7) 209.09,6.12 217.6,6.12 217.8,5.92 221.41,5.92 222.28,6.79 222.99,6.79 227.12,2.67 237.08,2.67 237.81,3.39 247.89,3.39 v2(249.84,5.35)
  IN3 w0.254: v4(225.84,10.13) 225.39,9.69 221.28,9.69 220.63,10.34 217.11,10.34 214.46,9.87 213.65,9.05 210.85,9.05 v2(208.5,6.7)
  IN3 w0.508: v2(58.01,20.1) 58.01,18.58 58.79,17.8 v5(58.79,17.6) ; v2(181.85,7.42) 177.88,7.42 176.13,5.66 175.11,5.66 172.52,3.07 138.6,3.07 137.83,2.3 98.32,2.3 93.89,6.72 v5(92.89,6.72)
  BOTTOM w0.254: v4(225.84,10.13) 225.84,19.66 v3(225.71,19.79) 225.71,25.2 221.08,29.83 221.08,35.52 220.82,35.77 220.82,36.69 220.24,37.27 220.24,46.33 217.26,49.31 216.32,49.31 215.44,50.19 v5(213.41,50.19) ; v5(58.79,17.6) 58.73,17.55 QF1.2
+3V_PRIM: length 625.2
  TOP w0.254: v1(174.09,62.5) 174.09,62.62 174.62,63.16 R616.1 ; RT109.2 v1(8.29,49.78)
  TOP w0.305: v5(273.98,40.49) RT189.2 ; UC11.5 154.91,18.13 155.41,18.63 UC11.1 155.41,19.23 155.48,19.3 CC633.1
  TOP w0.356: RC744.2 182.19,43.43 181.9,43.72 181.52,43.72 181.39,43.85 181.01,43.85 180.79,44.07 v5(179.39,44.07) ; CC632.1 151.15,19.27 UC10.5 ; CC632.1 150.64,19.54 150.64,19.33 150.42,19.11 v5(150.42,18.51) ; CC632.1 151.01,19.91 152.45,19.91 152.75,20.22 155.12,20.22 155.48,19.86 CC633.1 ; v5(66.33,17.85) 66.33,17.82 66.29,17.85 R6205.1 ; v1(173.71,53.66) 173.92,53.66 174.2,53.93 UH1.5 ; RH604.2 RH629.2 v5(179.09,27.53)
  TOP w0.381: v5(179.39,44.07) 179.19,43.87 RH745.1 RH746.1
  TOP w0.508: RC745.1 235.67,17.78 D20.2 234.82,17.78 234.62,17.58 230.78,17.58 228,20.36 228,22.96 224.25,26.71 v5(224.25,30.01)
  IN1 w0.254: v1(174.09,62.5) 174.08,62.49 174.08,60.16 173.79,59.88 173.79,59.17 174.1,58.87 174.1,58.54 173.79,58.23 173.79,56.67 173.67,56.54 v2(173.67,56.19) ; v2(79.19,10.33) 77.53,11.98 74.84,11.98 73.25,13.56 71.49,13.56 69.49,15.57 69.49,17.01 68.16,18.33 66.81,18.33 v5(66.33,17.85) ; v2(173.32,54.73) 173.71,54.34 v1(173.71,53.66) 173.71,52.72 172.57,51.58 171.4,51.58 170.09,50.28 168.8,50.28 168.46,50.62 v1(168.43,50.62) ; v2(7.87,49.6) 8.11,49.6 v1(8.29,49.78) ; v1(4.05,48.46) v2(3.6,48.46) ; v1(168.73,37.23) v2(168.97,37.46) ; v2(177.07,25.28) 178.29,25.28 v1(178.57,24.99) ; v1(214.62,12.67) 214.62,6.37 v1(215.44,5.56) ; v1(168.08,35.57) v2(168.32,35.8) ; v1(168.73,36.4) v2(168.97,36.63)
  IN1 w0.508: v2(212.47,37.25) 212.47,37.64 215.43,40.61 215.43,42.48 219.18,46.23 219.18,50.26 v2(218.72,50.72)
  IN2 w0.254: v2(3.6,48.46) 4.74,49.6 v2(7.87,49.6) 8.2,49.93 14.21,49.93 14.76,49.38 14.76,46.5 15.39,45.87 15.39,45.13 17.24,43.28 17.24,39.67 16.48,38.91 16.48,37.21 16.85,36.84 16.85,34.61 15.15,32.9 15.15,23.17 19.33,18.99 19.33,18.78 19.46,18.64
  IN2 w0.508: v2(164.9,49.74) 166.39,51.23 171.23,51.23 172.49,52.49 172.49,53.9 v2(173.32,54.73) 173.67,55.08 v2(173.67,56.19) ; v2(212.47,37.25) 212.47,32 217.52,26.95 217.52,24.29 217.89,23.93 217.89,22.25 217.52,21.88 217.09,21.88 216.75,21.54 216.75,20.55 217.22,20.07 217.22,18.85 218.36,17.71 v5(218.36,16.44) 218.97,17.05 220.56,17.05 229.9,7.72 230.92,7.72 231.24,8.04 231.9,8.04 234.37,10.51 243.78,10.51 244.77,9.52 247.12,9.52 248.1,10.5 248.1,10.88 249.73,12.51 261.72,12.51 264.37,15.16 264.37,16.98 266.96,19.57 266.96,21 269.01,23.05 269.01,24.07 273.16,28.23 273.16,37.89 273.4,38.13 273.4,40.08 273.74,40.42 273.83,40.42 273.89,40.49 v5(273.98,40.49) ; v5(123.73,3.91) 126.72,3.91 128.5,5.69 129.45,5.69 138.13,14.37 149.62,14.37 150.97,15.73 150.97,16.45 150.42,17 v5(150.42,18.51) ; v2(177.07,25.28) 178.36,25.28 178.9,25.82 178.9,27.14 179.09,27.33 v5(179.09,27.53) ; 19.46,18.64 19.46,17.82 24.08,13.2 31.2,13.2 31.54,12.85 31.88,12.51 76.97,12.51 79.15,10.33 v2(79.19,10.33) 79.19,9.86 80.43,8.61 80.43,8.15 80.43,7.84 81.76,6.51 81.97,6.51 82.59,5.9 95.54,5.9 96.7,7.06 98.18,7.06 98.93,7.81 103.92,7.81 105.26,9.15 v2(105.26,9.79) 105.26,18.73 106.47,19.94 109.13,19.94 110.23,18.84 v5(110.36,18.84)
  IN3 w0.254: v4(171.67,36.71) 171.97,37.01 172.86,37.01 ; 171.17,40.86 v4(171.17,41.5) ; v2(164.9,49.74) 164.81,49.84 164.48,49.84 164.45,49.87 163.39,49.87 162.4,48.88 162.4,48.3 162.81,47.89 162.81,46.21 162.86,46.16 162.86,46.04 162.91,45.99 162.91,45.57 163.42,45.06 v4(163.42,45.05)
  IN3 w0.508: v5(179.39,44.07) 177.21,41.89 177.21,40.83 177.03,40.65 177.03,38.51 177.29,38.25 ; v5(181.86,39.24) 181.45,38.83 178.63,38.83 178.04,38.25 177.29,38.25 ; 177.29,38.25 176.67,37.63 v4(174.43,37.63) 173.47,37.63 172.86,37.01 ; 165.12,39.15 166.83,39.15 167.4,39.72 168.37,39.72 168.68,39.41 169.71,39.41 171.17,40.86 ; 165.12,39.15 165.12,36.75 165.77,36.1 v4(167.86,36.1) 168.16,35.8 v2(168.32,35.8) ; 165.12,39.15 164.42,39.85 162.9,39.85 162.33,40.42 162.33,42.06 163.25,42.99 v4(163.42,42.99) ; v2(177.07,25.28) 175.94,24.14 v4(175.94,23.83) ; v4(218.72,51.28) v2(218.72,50.72) ; v2(105.26,9.79) 108.54,9.79 111.23,7.1 112.69,7.1 113.46,6.32 119.2,6.32 119.95,7.07 122.31,7.07 123.73,5.64 v5(123.73,3.91)
  BOTTOM w0.305: JAPS1.1 217.91,62.77 219.11,61.57 219.11,60.07 218.8,59.77 JAPS1.7
  BOTTOM w0.356: v5(273.98,40.49) 274.05,40.42 274.23,40.42 274.76,39.89 RT187.2 ; v4(171.17,41.5) 170.95,41.72 RH618.2 ; R6174.1 R6175.1 184.02,40.74 184.44,40.32 ; RH672.2 v4(163.42,42.99)
  BOTTOM w0.381: RC751.1 191.99,31.47 ; RC682.1 RH647.2 158.98,50.83 156.5,50.83 155.8,50.14 155.8,46.82 156.22,46.4 157.18,46.4 157.38,46.2 157.38,45.89 158.59,44.68 ; RC752.1 191.99,30.83
  BOTTOM w0.508: 213.04,16.89 212.48,17.45 202.26,17.45 198.83,20.88 198.83,24.51 196.54,26.8 193.48,26.8 191.55,28.73 191.55,30 v5(191.8,30.24) 191.99,30.44 191.99,31.47 192.06,31.53 192.06,36.61 191.49,37.18 188.31,37.18 187.26,38.23 185.47,38.23 184.46,39.24 ; 179.23,32.68 179.23,30.14 179.09,30 v5(179.09,27.53) ; v5(181.86,39.24) 184.46,39.24 ; 184.46,39.24 184.46,40.3 184.44,40.32 ; v4(175.94,23.83) 173.21,23.83 169.02,19.64 151.56,19.64 v5(150.42,18.51) ; v5(224.25,30.01) 222.17,32.09 222.17,35.97 221.91,36.22 221.91,37.14 221.33,37.72 221.33,44.23 221.66,44.56 221.66,47.18 218.73,50.11 218.73,51.27 v4(218.72,51.28) 218.73,51.29 218.73,52.87 219.35,53.49 219.35,59.22 218.8,59.77
  vias: v4(169.16,37.07) v4(169.15,36.25) v5(213.89,16.13) v5(214.03,16.67) v6(168.5,36.61)
+3V_PRIM_R:
  vias: v3(205.96,15.15)
+3V_SPI: length 71.3
  TOP w0.254: RC745.2 236.45,16.08 D20.1 235.49,16.74 235.13,17.09 230.44,17.09 v5(228.47,19.06)
  TOP w0.356: UH8.8 234.22,16.1 235.24,15.09 CH35.1
  TOP w0.508: CH35.1 235.83,15.44 235.49,15.78 D20.1
  IN3 w0.508: v5(228.47,19.06) 227.81,19.06 225.63,21.24 224.12,21.24 223.3,20.42 v4(221.97,20.42)
  BOTTOM w0.508: 188.18,40.3 189.77,40.3 192.86,37.2 v6(192.86,31.09) 192.86,28.84 194.29,27.41 196.92,27.41 199.62,24.71 202.3,24.71 202.92,24.09 208.08,24.09 208.5,24.51 210.12,24.51 211.47,25.87 211.8,25.87 212.99,27.05 216.02,27.05 217.28,25.8 217.28,25.13 219.12,23.29 219.12,22.49 219.55,22.06 220.33,22.06 v4(221.97,20.42)
+3VALW: length 366.6
  TOP w0.203: 271.34,57.12 270.14,57.12 v1(270.01,57) ; CM1.2 15.59,58.35 UM1.13
  TOP w0.254: v5(202.72,66.06) 202.43,66.36 UE5.6 ; PR1102.1 93.93,52.27 94.69,53.03 95.8,53.03 ; CM1.2 15.55,58.74 15.78,58.96 17.46,58.96 17.95,58.47 17.95,57.68 19.15,56.49 v5(19.65,56.49) ; v5(213.2,69.9) 213.1,69.99 211.77,69.99 211.7,69.92 211.25,69.92 211.04,70.13 Q30.2 Q30.5 ; UT2.4 289.26,27.63 289.42,27.48 v1(289.53,27.48) ; v5(143.61,4.99) 143.02,4.99 142.77,5.24 142.77,5.87 ; 142.77,5.87 142.64,5.99 141.32,5.99 141.12,6.2 RC663.1 RC664.1 ; 142.77,5.87 142.93,6.03 142.93,6.39 RE488.2 ; PR1114.1 100.12,52.68 99.22,53.58 v1(99.09,53.58) ; 95.8,53.03 96.33,53.56 v1(96.7,53.56) ; 95.8,53.03 96.9,51.94 97.35,51.94 97.79,51.5 PR1111.1
  TOP w0.356: RE200.2 230.58,2.39 231.02,2.83 231.24,2.83 233.01,4.61 v1(233.01,5.24) ; v5(190.85,47.26) C4202.1 189.94,47.26 189.91,47.23 UC4.5 ; PR509.1 210.14,17.32 v1(210.09,17.28) ; RE111.2 RE112.2 206.6,53.21 v5(206.4,53.01) ; v5(213.2,69.9) 213.2,70.25 213.02,70.43 213.02,71.68 213.76,72.43 RE521.1 ; PD603.2 92.51,12.84 92.34,13.02 92.34,15.77 91.82,16.29 91.03,16.29 90.52,16.8 v1(90.52,17.28) ; v5(188.74,50.77) 188.78,50.74 189.32,50.74 UC5.5 189.85,50.88 190.13,50.61 C4201.1 ; RE123.1 v5(220.74,63.93) ; v5(7.72,14.78) 7.78,14.84 7.82,14.84 RPD84.1 ; RE87.2 198.34,54.57 v5(198.53,54.76) ; v1(203.72,64.74) RE247.1 ; v5(216.67,52.91) 216.55,53.02 RE122.1
  TOP w0.381: PD603.2 PR101.1 PR103.1 ; v5(202.72,66.06) 204.29,66.06 204.55,66.32 RE525.1
  TOP w0.508: 220.95,59.03 220.95,61.23 v5(220.89,61.29)
  TOP w1.016: 243.28,16.2 243.28,13.41 243.78,12.9 245.28,12.9 245.82,12.37 245.82,11.34
  IN1 w0.254: v1(10.69,35.99) 10.69,35.44 11.23,34.9 11.23,30.48 11.82,29.9 14.45,29.9 15.28,29.07 16.69,29.07 16.94,28.82 v1(16.94,27.96) ; v1(96.7,53.56) 96.7,53.32 97.07,52.94 v2(97.9,52.94) 98.45,52.94 v1(99.09,53.58) ; v1(212.92,29.59) 213.15,29.59 v2(213.37,29.81) ; 265.27,21.63 265.27,18.58 264.68,17.99 264.68,14.45 266.19,12.94 272.08,12.94 272.42,13.28 272.42,13.91 273.01,14.51 v1(273.29,14.51) ; v2(269.97,53.63) 270.01,53.67 v1(270.01,57) ; v1(201.84,58.57) 202.09,58.82 v5(202.09,60.07)
  IN1 w0.381: v1(220.42,45.07) 220.38,45.03 v2(220.38,44.61) ; v2(196.39,57.61) 196.35,57.57 v1(196.35,57.11)
  IN1 w0.508: v2(209.69,16.7) 210.09,17.1 v1(210.09,17.28) ; v2(97.44,26.07) 97.44,25.25 96.36,24.17 96.36,21.44 98.08,19.72 98.08,19.15 95.49,16.56 93.98,16.56 93.14,17.41 90.64,17.41 v1(90.52,17.28) ; v5(143.61,4.99) 143.43,5.17 143.43,7.4 142.74,8.09 142.74,12.6 141.01,14.32 v1(139.08,14.32) ; v1(288.32,23.33) 287.93,23.33 287.62,23.63 287.62,24.38 287.14,24.87 287.14,26.07 287.53,26.45 v1(287.62,26.45) 287.56,26.52 v2(287.56,27.15) 288.78,27.15 289.11,27.48 v1(289.53,27.48) ; v1(203.72,64.74) v2(204.12,64.74)
  IN2 w0.254: v2(269.97,53.63) 269.97,52.76 272.19,50.54 272.19,44 271.9,43.71 271.9,37.59 271.62,37.31 v2(271.62,35.85)
  IN2 w0.508: 210.73,10.13 210.73,12.8 209.45,14.07 209.45,16.46 v2(209.69,16.7) ; v5(143.61,4.99) 145.32,4.99 145.46,5.13 152.71,5.13 154.23,3.61 176.64,3.61 178.57,5.53 v2(178.57,5.94) 178.57,8.64 175.96,11.25 175.96,11.25 171.34,15.86 v5(171.34,17.75)
  IN3 w0.254: v2(105,71.73) 105.62,72.35 121.88,72.35 125.78,76.24 v4(125.78,77.4)
  IN3 w0.508: v5(174.37,17.86) 174.3,17.86 173.51,18.64 171.85,18.64 171.34,18.13 v5(171.34,17.75) ; v2(105.93,46.15) 105.93,44.73 105.1,43.9 105.1,38.79 103.88,37.58 103.88,34.22 103.28,33.63 101.61,33.63 101.12,34.11 99,34.11 97.25,32.36 97.25,26.26 v2(97.44,26.07) ; v5(205.68,9.6) 204.26,8.18 198.61,8.18 195.36,4.93 183.01,4.93 182,5.94 v2(178.57,5.94) ; v2(287.56,27.15) 287.43,27.02 v4(287.43,23.98)
  IN3 w1.016: 232.19,6.32 224.08,6.32 221.85,8.56 220.81,8.56 220.01,9.36
  BOTTOM w0.102: v5(220.83,23.47) v6(220.83,22.71)
  BOTTOM w0.254: UW2.6 v4(195.49,62.43)
  BOTTOM w0.356: v5(177.41,65.93) 177.41,65.7 R532.1 ; RW39.2 196.98,57.57 v4(197.03,57.61) 197.03,57.95 RW40.2
  BOTTOM w0.508: v5(7.72,14.78) 8.1,15.16 v6(8.1,15.4) 8.1,16.55 6.26,18.39 6.26,20.99 8.35,23.09 8.35,27.34 9.3,28.29 12.86,28.29 13.43,28.87 17.62,28.87 v5(18.13,28.36) ; v4(287.43,23.98) 286.89,23.98 284.65,21.73 280.32,21.73 280.07,21.48 v5(275.11,21.48)
  vias: v1(17.37,38.84) v1(17.75,38.84) v1(18.54,38.58) v1(106.05,69.5) v1(106.38,69.5) v1(175.78,66.92) v1(176.18,66.92) v1(231.34,10.41) v1(231.91,10.13) v1(241.65,18.77) v1(241.65,18.45) v1(241.99,18.77) v1(241.99,18.45) v1(243.52,18.26) v1(243.52,17.94) v1(243.83,18.26) v1(243.83,17.94) v1(264.07,21.88) v1(264.47,21.91) v1(264.89,21.88) v2(18.13,38.14) v2(59.6,20.56) v2(59.95,20.19) v2(60.31,19.8) v2(66.28,24.73) v2(66.63,24.36) v2(66.99,23.96) v2(104.29,71.75) v2(223.74,28.36) v2(224.25,28.36) v2(224.25,27.87) v2(224.27,27.39) v2(224.69,27.85) v2(224.71,27.37) v2(233.2,6.45) v2(233.62,6.8) v2(239.7,18.88) v2(239.71,18.44) v2(240.15,18.88) v2(240.15,18.44) v2(240.6,18.43) v2(240.93,18.69) v2(264,22.33) v2(264.45,22.33) v2(264.89,22.33) v5(74.37,61.95) v5(74.37,61.34) v5(74.95,61.97) v5(74.95,61.34) v5(75.53,61.97) v5(75.51,61.34) v5(76.09,61.95) v5(76.09,61.34) v5(76.7,61.95) v5(76.68,61.34) v5(77.29,61.95) v5(77.26,61.34) v5(173.43,66.4) v5(173.43,65.82) v5(174.01,66.19) v5(176.74,66.58) v5(176.82,65.94) v5(177.29,66.48) v5(201.52,10.2) v5(202.09,10.2) v5(204.88,26.2) v5(204.88,25.63) v5(205.46,26.2) v5(205.46,25.63) v5(206.27,9.65) v5(209.13,59.92) v5(218.6,9.63) v5(219.17,9.63) v5(219.69,24.05) v5(219.69,23.47) v5(219.74,9.63) v5(220.26,24.05) v5(220.26,23.47) v5(220.83,24.05) v6(213.46,67.73)
+3VALW_DSW: length 233.6
  TOP w0.254: v5(177.14,45.64) 177.01,45.77 177.01,46.89 177.26,47.14 RH653.2 ; v1(175.56,55.62) 175.14,55.62 175.1,55.66 174.4,55.66 173.87,56.2 RH301.2 ; RH460.2 169.01,50.8 168.71,51.1 167.02,51.1 166.89,50.97 166.89,50.78 166.88,50.77 166.88,50.35 166.63,50.1 RH297.2 166.47,49.8 166.11,49.44 v5(165.98,49.44)
  IN1 w0.254: v1(167.43,38.89) 167.68,39.14 v2(167.76,39.14) ; v2(176.16,56.19) 176.01,56.04 175.87,56.04 175.56,55.73 v1(175.56,55.62)
  IN2 w0.254: v2(176.16,56.19) 173.1,53.13 173.1,52.24 171.48,50.62 167.16,50.62 v5(165.98,49.44)
  IN3 w0.254: v4(119.67,3.11) 119.67,3.34 117.49,5.51 112.88,5.51 112.23,6.16 110.84,6.16 108.14,8.86 v4(105.54,8.86) ; v4(168.12,39.09) 168.06,39.14 v2(167.76,39.14) ; v5(177.14,45.64) 177.02,45.64 175.61,44.23 175.61,43.04 175.99,42.66 175.99,40.99 176.55,40.44 176.55,39.23 v4(176.45,39.13)
  BOTTOM w0.254: v5(177.14,45.64) 174.48,45.64 173.64,44.8 172.31,44.8 169.47,47.64 166.28,47.64 165.77,48.15 165.77,49.23 v5(165.98,49.44) ; RH601.2 166.59,48.83 v5(165.98,49.44) ; v5(165.98,49.44) 166.53,49.44 167.28,50.19 167.28,50.92 166.34,51.86 155.14,51.86 154.68,52.32 128.86,52.32 128.44,52.74 126.26,52.74 125.62,53.38 122.65,53.38 120.56,55.47 105.13,55.47 104.87,55.22 104.87,47.85 100.49,43.47 95.54,43.47 93.82,41.76 93.82,32.69 99.74,26.77 103.66,26.77 106.34,24.1 106.34,18.83 105.17,17.67 105.17,9.89 105.54,9.52 v4(105.54,8.86)
  BOTTOM w0.508: 175.99,39.09 v4(168.12,39.09)
  BOTTOM w1.016: 178.87,38.52 178.87,37.1 180.63,35.34 183.36,35.34 192.77,25.93 195.94,25.93 v6(197.71,24.17) 197.71,20.42 200.31,17.82 200.31,17.5
  vias: v5(200.06,16.61) v5(200.63,16.61)
+3VALW_DSW_R:
  vias: v3(201.71,14.07)
+3VALW_TPM: length 1.1
  TOP w0.081: C422.1 207.42,9.12 v6(207.55,8.99)
+3VALWP: length 13.7
  TOP w0.102: v3(78.93,61.09) 77.63,59.79 77.63,59.41
  TOP w0.254: PR304.1 v1(85.49,56.11)
  TOP w0.356: PR304.1 85.48,55.82 86.09,55.2 PC305.2
  IN1 w0.254: v1(76.65,57.65) 76.65,57.02 v2(76.65,57.02) ; v2(85.12,56.41) 85.19,56.41 v1(85.49,56.11)
  IN3 w0.254: v2(85.12,56.41) 77.26,56.41 v2(76.65,57.02)
+3VS: length 920.5
  TOP w0.254: 49.03,12.53 49.03,10.69 v5(49.25,10.48) ; 49.03,12.53 49.06,12.49 49.35,12.49 49.74,12.88 50.11,12.88 51.12,13.88 53.95,13.88 54.42,13.4 54.88,13.4 55.08,13.2 RTCR2.2 ; 49.03,12.53 48.88,12.67 48.88,13.45 49.22,13.79 49.22,16.23 47.73,17.71 v1(47.59,17.71) 47.23,18.07 R232.1 ; v1(170.21,63.79) 170.21,64.34 169.32,65.23 R704.1
  TOP w0.356: v5(157.82,48.66) 157.76,48.72 157.76,50.33 157.41,50.68 RH621.2 RC717.1 ; RC741.1 183.74,41.44 183.85,41.32 184.08,41.32 184.72,40.69 185.27,40.69 185.72,41.13 v1(186.07,41.13) 186.07,40.91 186.52,40.46 186.52,37.48 186.24,37.2 RH655.2 ; v1(235.9,2.6) R39.2 R40.2 ; v1(150.36,15.98) 150.2,16.14 RC631.1 ; RT35.2 274.29,37.98 274.29,37.96 274.26,37.93 274.26,35.95 v5(274.21,35.89) ; v5(203.72,54.39) 203.87,54.39 204.27,54.8 RE1.2 RE93.2 ; RC222.2 RC656.2 RC223.2 v1(177.43,34.71) ; 64.98,12.61 64.98,13.52 R36.2 v1(65.08,14.2) ; R216.2 237.42,18.24 C230.1 v5(236.79,18.77)
  TOP w0.381: RC741.1 183.45,41.55 183.45,42.07 v1(183.6,42.23) ; v1(64.13,14.62) 64.13,15.53 RE237.1 ; R666.1 265.23,25.97 v5(265.46,26.2)
  TOP w0.508: v1(97.63,15.34) 106.01,6.96 v1(106.01,5.05) ; v5(184.74,29.44) 184.74,29.48 185.62,30.36 185.62,30.57 185.9,30.85 185.9,31.82 ; R638.2 60.17,21.06 59.81,21.41 58.43,21.41 v1(57.26,20.24) ; v1(262.06,10.86) 261.43,11.49 261.43,17.34 v1(260.7,18.07) ; PR1200.1 102.55,32.9 v1(102.7,32.75) ; v5(205.42,6.77) 205.42,5.77 206.22,4.98 R200.1 R687.1 ; 64.98,12.61 64.98,11.13 63.91,10.06 v5(61.88,10.06)
  IN1 w0.254: v1(174.72,64.83) 174.72,63.55 v2(174.73,63.54) 174.85,63.54 175.49,64.18 176.39,64.18 176.98,63.59 176.98,60.55 175.77,59.34 175.77,57.19 175.64,57.05 v5(175.64,56.76) ; v1(186.07,41.13) 185.94,40.99 v2(185.94,40.66) ; v1(183.6,42.23) 183.17,42.23 182.4,41.46 v2(181.63,41.46) ; v1(177.43,34.71) 177.07,34.35 176.31,34.35 175.73,33.76 v2(174.83,33.76) ; v1(209.28,12.09) 208.52,11.33 208.52,9.8 206.05,7.34 v2(206.05,6.77) ; v1(4.05,47.88) v2(3.63,47.88)
  IN1 w0.381: v2(170.26,62.99) 170.24,62.99 170.21,63.02 v1(170.21,63.79)
  IN1 w0.508: v1(65.08,14.2) 64.66,14.62 v1(64.13,14.62) ; v1(57.26,20.24) 57.26,19.52 56.61,18.87 51.02,18.87 50.86,18.7 49.3,18.7 48.32,17.71 v1(47.59,17.71) ; v2(260.7,18.64) v1(260.7,18.07) ; v1(262.06,10.86) 262.06,10.35 v2(261.59,9.88) 259.62,9.88 258.73,8.99 258.73,6.07 256.86,4.2 236.35,4.2 v2(235.73,3.58) 235.73,2.77 v1(235.9,2.6) ; v2(110.39,4.28) 110.57,4.45 110.57,5.22 110.06,5.73 109.62,5.73 109.36,5.98 108.47,5.98 107.54,5.05 v1(106.01,5.05) ; v1(102.7,32.75) 103.23,33.29 105.69,33.29 106.2,32.78 106.2,31.91 105.99,31.7 105.7,31.7 105.25,31.26 105.25,29.17 103.73,27.65 103.73,25.45 v1(102.43,24.15) 102.43,23.82 101.81,23.2 100.4,23.2 99.98,22.78 99.98,20.19 97.63,17.84 v1(97.63,15.34) ; v1(150.36,15.98) v2(149.89,15.98) ; v2(205.13,66.84) 204.62,67.35 203.9,67.35 203.39,66.84 203.39,65.61 202.94,65.16 202.94,64.42 203.07,64.3 203.07,63.66 203.28,63.45 203.28,58 203.16,57.88 203.16,54.9 203.67,54.39 v5(203.72,54.39) ; v5(166.87,82.57) 166.87,83.27 167.67,84.07 169.68,84.07 170.48,83.27 170.48,75.4 171.17,74.71 171.17,73.16 172.69,71.64 173.73,71.64 174.89,70.48 176.94,70.48 178.28,69.15 178.28,65.57 177.24,64.53 177.24,63.85 176.98,63.59
  IN2 w0.254: v2(3.63,47.88) 5.96,47.88 7.11,49.02 8.12,49.02 8.35,48.79 8.35,44.73 10.14,42.94 10.14,41.65 10.67,41.12 14.83,41.12 15.69,40.26 15.69,38.33 13.24,35.88 13.24,22.38 17.42,18.2 17.42,17.13 23.27,11.28 30.39,11.28 31.19,10.48 v5(49.25,10.48)
  IN2 w0.457: v5(274.21,35.89) 274.82,35.89 275.41,35.3 275.41,34.52
  IN2 w0.508: v2(170.26,62.99) 170.96,62.99 171.51,63.54 v2(174.73,63.54) ; v5(49.25,10.48) 61.47,10.48 v5(61.88,10.06) 63.78,10.06 64.19,10.48 75.39,10.48 77.78,8.09 77.78,6.58 80.08,4.28 89.88,4.28 90.24,3.92 91.23,3.92 91.59,4.28 103.4,4.28 103.69,3.99 106.76,3.99 107.18,3.57 109.08,3.57 109.8,4.28 v2(110.39,4.28) 110.85,4.28 111.39,3.74 119.08,3.74 120.21,4.88 122.98,4.88 127.3,9.19 132.09,9.19 137.88,14.98 148.51,14.98 149.5,15.98 v2(149.89,15.98) ; v2(260.7,18.64) 259.37,18.64 258.86,19.15 258.86,19.98 261.14,22.26 261.59,22.26 265.46,26.14 v5(265.46,26.2) ; 275.41,34.52 275.41,32.59 274.95,32.12 274.95,30.12 274.24,29.42 274.24,27.78 273.53,27.06 273.53,23.85 269.59,19.91 269.59,14.32 268.07,12.8 264.51,12.8 v2(261.59,9.88) 259.56,9.88 258.67,8.99 253.98,8.99 252.53,10.44 249.45,10.44 v5(249.33,10.32)
  IN3 w0.254: v2(181.63,41.46) 181.73,41.56 181.73,41.58 182,41.85 v4(182,42.01) 182,42.81 180.14,44.66 179.3,44.66 178.05,43.41 176.25,43.41 175.99,43.66 v4(175.99,44.04) ; v5(203.72,54.39) 203.39,54.39 202.37,55.41 201.85,55.41 201.19,54.75 199.49,54.75 198.94,55.29 198.01,55.29 197.81,55.09 195.19,55.09 v4(195,54.9) ; v2(174.83,33.76) 173.71,33.76 v4(173.58,33.63)
  IN3 w0.381: v5(166.87,82.57) 166.87,82.76 166.23,83.41 162.15,83.41 161.87,83.13 161.87,82.41 161.42,81.96 158.58,81.96 157.48,80.86 v4(156.83,80.86)
  IN3 w0.508: v4(189.71,35.47) 189.71,33.63 186.91,30.83 185.61,30.83 184.74,29.97 v5(184.74,29.44) ; v2(110.39,4.28) 110.39,3.95 v4(110.14,3.69) ; v2(235.73,3.58) 225.6,3.58 224.12,5.07 220.74,5.07 219.69,6.12 207.63,6.12 206.98,6.77 v2(206.05,6.77) v5(205.42,6.77) 204.86,6.21 197.5,6.21 195.61,4.32 182.76,4.32 182.35,4.72 178.57,4.72 177.83,5.46 177.83,6.17 178.34,6.68 182.22,6.68 182.58,7.04 182.58,7.55 182.1,8.02 177.63,8.02 175.89,6.28 174.87,6.28 172.27,3.68 145.23,3.68 144.55,4.37 144.55,6.78 142.7,8.62 142.7,11.77 146.91,15.98 v2(149.89,15.98) ; v2(185.94,40.66) 185.94,37.92 v4(186.42,37.44) 186.43,37.44 186.94,37.95 186.94,39.49 189.91,42.46 189.91,45.17 189.01,46.07 v4(188.37,46.07) ; v4(205.84,66.84) v2(205.13,66.84)
  BOTTOM w0.254: v4(195,54.9) 193.86,53.76 189.66,53.76 188.69,54.73 188.69,61.06 182.02,67.73 175.8,67.73 v6(175.61,67.54) 174.59,66.52 174.59,65.19 174.11,64.7 174.11,57.99 174.72,57.38 175.02,57.38 v5(175.64,56.76)
  BOTTOM w0.356: RC665.1 RC666.1 187.26,46.94 188.12,46.07 v4(188.37,46.07) ; v4(189.71,35.47) 188.91,35.47 186.94,37.44 v4(186.42,37.44) 185.48,37.44 184.21,38.71 RC743.1 ; RH40.1 RH41.1 RH631.1 v4(182,42.01) ; 173.58,32.74 v4(173.58,33.63) ; CC17.1 165.77,81.96 F5.1 ; v4(156.83,80.86) 157.22,80.47 157.22,79.49 157.52,79.18 R6157.2 ; RC339.1 157.8,48.05 157.8,48.64 v5(157.82,48.66) 157.85,48.63 159.09,48.63 159.73,48 160.17,48 160.43,47.74 RC338.1 160.98,47.42 161.54,46.87 169.02,46.87 169.56,46.33 170.15,46.33 172.21,44.27 173.86,44.27 174.52,44.93 175.13,44.93 RH727.1 175.99,44.07 v4(175.99,44.04) ; RC668.1 RC667.1 175.27,53.61 175.8,54.14 175.8,56.59 v5(175.64,56.76)
  BOTTOM w0.381: RH738.2 RH739.2 158.48,48.64 158.48,48.63
  BOTTOM w0.508: v4(188.37,46.07) 188.63,46.07 189.21,46.66 192.53,46.66 193.33,47.46 196.02,47.46 199.24,50.68 199.24,55.5 199.6,55.86 200.46,55.86 201.99,54.33 203.04,54.33 ; v5(236.79,18.77) 234.63,16.61 229.37,16.61 227.38,18.61 227.38,24.22 221.56,30.03 221.56,35.72 221.3,35.97 221.3,36.89 220.72,37.47 220.72,44.6 221.05,44.93 221.05,46.93 220.95,47.03 216.25,51.73 212.95,51.73 210.73,53.95 207.8,53.95 ; 173.58,32.74 173.58,29.25 176.12,26.71 177.07,26.71 178.72,25.06 178.72,23.51 181.18,21.06 184.69,21.06 186.41,22.77 186.41,28.23 185.2,29.44 v5(184.74,29.44) 184.74,30.51 185.26,31.02 186.45,31.02 192.41,25.07 193.01,25.07 194.49,23.58 194.49,22.16 186.53,14.19 186.53,11.47 184.25,9.18 184.25,6.45 184.91,5.79 196.83,5.79 197.48,6.44 205.09,6.44 v5(205.42,6.77) ; F5.1 166.45,82.15 v5(166.87,82.57)
+3VS_AUDIO: length 74.7
  TOP w0.254: RA18.1 37.69,13.31 37.31,12.93 36.11,12.93 35.85,12.67 35.85,11.47 v1(35.72,11.34) 35.72,10.64 35.02,9.94 34.32,9.94 33.69,9.31 v3(33.24,9.31) 33.07,9.49 RA29.1 31.66,9.24 31.29,8.87 28.47,8.87 27.97,9.37 27.02,9.37 v1(26.77,9.63) ; R227.2 20.92,22.99 20.92,22.8 C277.1 21.14,22.58 v1(21.14,22.36) ; RA65.2 5.24,6.95 4.73,7.47 4.73,12.23 v1(5.18,12.67)
  IN1 w0.254: v1(35.72,11.34) 32.48,11.34 32.23,11.59 32.23,12.04 31.59,12.67 24.78,12.67 20.82,16.63 20.82,18.42 20.41,18.83 20.41,21.62 v1(21.14,22.36) ; v2(5.05,12.99) 5.18,12.86 v1(5.18,12.67) ; v1(26.77,9.63) v2(26.19,9.63)
  IN2 w0.254: v2(26.19,9.63) 25.43,10.39 22.96,10.39 20.73,12.61 14.51,12.61 10.57,16.55 5.81,16.55 5.05,15.78 v2(5.05,12.99)
+3VS_AUDIO_R:
  vias: v3(21.18,26.2)
+3VS_CR: length 17.3
  TOP w0.203: UCR1.27 280.6,29.53 281.27,30.2 CR20.1
  TOP w0.254: v1(280.39,30.87) 280.49,30.87 281.08,30.29 CR20.1
  IN1 w0.254: v1(280.39,30.87) 279.97,30.87 279.63,31.21 279.62,31.2 279.24,31.2 279.17,31.28 278.38,31.28 v1(277.97,30.87)
  IN1 w1.016: 282.42,27.98 282.1,27.66 282.1,25.46 281.43,24.79 278.88,24.79
  IN1 w1.524: 272.96,23.79 274.1,22.64 277.91,22.64
  vias: v1(271.3,24.55) v1(271.3,24.23) v1(271.3,23.91) v1(279.2,22.33) v1(279.2,22.07) v1(279.43,22.2) v1(282.51,30.28) v1(282.51,29.93) v6(270.92,24.8)
+3VS_FP: length 14.5
  TOP w0.254: QF2.2 59.6,12.05 R629.2 59.67,11.83 60.01,11.49 62.52,11.49 v1(64.32,13.3) ; C4183.1 60.04,18.1 v1(60.04,17.05)
  IN1 w0.254: v1(60.04,17.05) 60.56,16.54 60.56,15.69 63.28,12.97 63.99,12.97 v1(64.32,13.3)
  vias: v3(59.52,18.51)
+3VS_FP_R:
  vias: v3(61.85,19.65)
+3VS_MID: length 4.4
  IN1 w0.254: v5(165.92,82.88) 165.92,81.98 165.66,81.71 165.66,79.36 v1(165.64,79.35)
  BOTTOM w0.508: v5(165.92,82.88) 165.96,82.92 F5.2
+3VS_R: length 1.2
  TOP w0.081: 238.55,16.52 238.55,15.48 v3(238.65,15.39)
+3VS_SSD: length 7.3
  TOP w0.102: RS377.2 203.83,5.25 203.83,7.01 v6(203.98,7.16) ; v6(204.73,8.66) 204.73,7.91 v6(203.98,7.16) ; v6(203.98,7.16) 203.83,7.32 203.83,7.87 v6(203.05,8.64)
  TOP w0.254: v5(204.59,3.95) RS377.2
  vias: v5(218.6,7.66) v5(219.17,7.66) v5(219.74,7.66) v5(220.31,7.66) v5(220.89,7.66)
+3VS_SSD_R:
  vias: v1(217.64,8.8) v1(217.64,8.5) v1(218.14,8.8) v1(218.14,8.5) v1(219.36,8.7) v1(219.36,8.39) v1(219.67,8.7) v1(219.67,8.39)
+3VS_TS: length 65
  TOP w0.254: F4.2 173.32,71.13 v5(173.49,70.97) ; JEDP1.33 128.1,82.98 v5(128.67,82.41)
  IN1 w0.254: v1(127.6,79.41) 127.6,79.92 128.06,80.38 128.52,80.38 128.79,80.64 128.79,82.29 v5(128.67,82.41)
  IN2 w0.381: v5(128.67,82.41) 128.67,81.76 130.04,80.4 130.83,80.4 133.48,77.75 140,77.75 145.44,72.31 152.95,72.31 154.95,74.3 167.83,74.3 167.83,74.3 167.98,74.3 171.32,70.97 v5(173.49,70.97)
  BOTTOM w0.254: v5(128.67,82.41) 128.45,82.19 C452.1 C451.1 128.45,80.51 128.82,80.14 R245.2 R288.2 130.61,80.14 130.84,80.37 v6(130.84,80.43) 130.84,80.78 131.58,81.52 R239.2 R238.2
+3VS_TS_R: length 0.6
  TOP w0.081: v3(172.77,68.17) 172.77,68.73 172.75,68.74
+3VS_WLAN:
  vias: v1(175.42,72.24) v1(175.74,72.24) v1(176.05,72.24) v1(176.37,72.24) v1(176.69,72.24) v1(177.01,72.24) v2(175.55,72.62) v2(175.99,72.62) v2(176.44,72.62) v2(176.88,72.62) v2(183.29,73.13) v2(183.74,73.13) v2(184.18,73.13) v2(184.64,73.13) v5(179.83,70.22) v5(179.83,69.65) v5(182,70.03) v5(182,69.47) v5(190.02,70.05) v5(190.02,69.48) v5(192.25,69.82) v5(192.25,69.25) v6(180.36,70.02)
+5VALW: length 279.8
  TOP w0.254: UC24.4 193.47,53.56 192.82,54.2 v1(187.8,54.2) ; UC13.3 137.07,15.27 137.22,15.12 137.22,14.24 136.74,13.75 125.51,13.75 124.43,12.67 124.43,7.21 120.77,3.55 104.43,3.55 102.74,5.24 v1(101.19,5.24) v1(100.78,5.24) ; v5(68.55,9.59) 67.34,10.79 67.34,11.09 66.39,12.04 66.39,14.41 66.66,14.68 66.66,16.21 67.1,16.65 UC25.4
  TOP w0.305: 109.19,48.61 108.86,48.94 UC27.3
  TOP w0.356: 109.19,48.61 109.19,47.53 108.62,46.96 v1(108.62,46.77)
  IN1 w0.254: v5(187.74,56.23) 187.74,54.27 v1(187.8,54.2) ; v2(170.77,57.37) 170.61,57.53 170.61,61.4 171.21,62 171.21,67.94 v1(170.95,68.2) 170.95,69 164.43,75.51 164.43,76.05 164.02,76.47 162.95,76.47 162.46,75.98 159.65,75.98 159.43,76.2 v5(159.42,76.2) ; v2(133.51,16.99) 133.51,17.22 v1(133.73,17.44)
  IN1 w0.508: v2(107.14,50.91) 107.14,48.95 108.62,47.47 v1(108.62,46.77) 108.49,46.77 v2(107.88,46.16)
  IN2 w0.254: v5(187.74,56.23) 178.15,56.23 175.94,58.44 174.49,58.44 173.73,57.68 172.66,57.68 172.34,57.37 v2(170.77,57.37) ; v2(133.51,16.99) 133.51,16.78 130.02,13.29 113.4,13.29 109.11,9 109.11,6.55 107.73,5.17 105.19,5.17 104.88,5.47 v2(100.16,5.47)
  IN2 w0.508: v2(107.88,46.16) 106.73,46.16 106.07,45.5 105.76,45.5 105.38,45.88 104.49,45.88 103.85,45.25 103.5,45.25 100.98,42.72 97.84,42.72 96.44,41.32 96.44,39.25 97.2,38.49 97.2,29.29 98.03,28.47 98.03,9.12 v2(97.35,8.44) ; v2(170.77,57.37) 170.77,56.98 169.31,55.52 168.45,55.52 167.61,54.68 167.61,53.88 165.52,51.79 155.79,51.79 155.12,52.46 150.93,52.46 150.78,52.31 144.17,52.31 144.03,52.46 131.06,52.46 130.45,51.85 128.59,51.85 128.47,51.98 114.91,51.98 113.71,50.79 110.9,50.79 110.34,51.34 109.14,51.34 108.7,50.91 v2(107.14,50.91)
  BOTTOM w0.102: v5(6.63,8.16) v6(6.63,7.59) ; v6(4.41,19.47) 4.35,19.53 v5(2.64,19.53) ; v5(6.06,10.99) v6(6.06,11.6)
  BOTTOM w0.254: R6207.1 159.23,78.64 159.18,78.59 QC1.1 159.18,76.44 v5(159.42,76.2)
  vias: v1(46.39,9.82) v1(46.71,9.82) v1(47.02,9.82) v1(47.34,9.82) v1(47.66,9.82) v1(47.98,9.82) v1(98.05,4.61) v1(98.46,4.61) v2(46.07,9.31) v2(46.51,9.31) v2(46.96,9.31) v2(47.4,9.31) v2(47.85,9.31) v2(48.29,9.31) v2(99.52,5.47) v5(2,20.78) v5(2,20.14) v5(2,19.53) v5(2,18.95) v5(2,18.36) v5(2.57,20.78) v5(2.57,20.14) v5(6.06,10.43) v5(6.06,9.86) v5(6.07,9.28) v5(6.07,8.72) v5(6.07,8.16) v5(6.62,10.99) v5(6.62,10.43) v5(6.62,9.86) v5(6.63,9.28) v5(6.63,8.72)
+5VALW_L_TBT: length 0.5
  TOP w0.102: 19.08,17.31 v1(19.09,17.31)
  BOTTOM w0.102: v5(7.14,20.99) v6(7.53,21.37)
  vias: v1(6.51,20.52) v1(6.51,20.21) v1(6.51,19.89) v1(8.12,21.98) v1(8.43,21.94) v1(9.18,20.17) v1(9.41,20.4) v1(9.37,19.92) v1(9.6,20.14) v1(9.82,20.37) v1(19.34,17.56) v2(17.94,14.77) v2(18.45,14.58) v5(7.08,20.42)
+5VALWB: length 232.1
  TOP w0.203: U31.4 v1(203.99,11.2) ; v5(175.26,66.24) 174.98,66.52 U34.4
  TOP w0.254: U734.4 188.93,12.55 189.19,12.29 189.96,12.29 190.28,11.97 190.28,10.9 v5(189.9,10.51) ; US1.4 216.64,10.59 216.31,10.26 v5(216.31,9.41) ; U733.4 v1(204.82,27.27)
  IN1 w0.254: v5(175.26,66.24) 175.26,67.45 175.5,67.69 175.5,69.59 175.12,69.96 172.89,69.96 171.57,68.64 171.57,61.85 170.96,61.25 170.96,57.81 171.74,57.03 v1(171.74,56.84) ; 270.16,18.83 269.06,19.93 v1(269.06,20.71) ; v1(203.99,11.2) v5(203.99,9.19) 203.99,5.61 202.92,4.55 199.58,4.55 199.35,4.77 196.6,4.77 195.16,3.33 184.38,3.33 182.71,4.99 182.71,8.71 181.36,10.06 177.65,10.06 177.43,10.27 173.46,10.27 172.89,9.7 169.96,9.7 169.45,10.21 169.45,10.34 168.94,10.84 165.39,10.84 164.88,11.35 164.88,12.5 164.37,13 163.9,13 161.7,15.2 161.13,15.2 159.77,16.56 157.99,16.56 157.88,16.67 154.18,16.67 153.64,16.13 151.17,16.13 150.74,16.57 v1(148.56,16.57)
  IN1 w0.508: v5(203.35,25.31) 203.35,25.79 v1(204.82,27.27)
  IN2 w0.254: v5(195.07,49.24) 195.36,49.24 197.58,47.03 197.58,40.84 198.01,40.41 215.03,40.41 v5(217.84,43.22)
  BOTTOM w0.254: v5(195.07,49.24) 191.77,52.54 190.38,52.54 188.25,54.67 188.25,60.93 181.87,67.31 176.21,67.31 175.26,66.36 v5(175.26,66.24) ; v5(203.35,25.31) v3(203.69,24.97) 207.77,24.97 209.29,26.49 210.37,26.49 210.96,27.07 211.26,27.07 214.12,29.93 214.12,38.11 216.84,40.82 216.84,42.88 217.18,43.22 v5(217.84,43.22)
  BOTTOM w0.508: 225.36,9.97 225.36,19.21 225.2,19.36 225.2,24.66 220.53,29.33 220.53,35.38 220.34,35.57 220.34,36.49 219.76,37.07 219.76,42.71 219.25,43.22 v5(217.84,43.22)
  vias: v1(273.91,18.75) v1(273.91,18.44) v1(274.21,18.75) v1(274.21,18.44) v5(227.63,8.08) v5(228.03,7.69) v5(228.42,7.29) v5(245.12,10.18) v5(270.72,18.7) v5(270.72,18.12) v5(271.05,19.21) v5(271.29,18.7) v5(271.29,18.12) v5(271.62,19.34) v5(271.93,18.82) v5(271.93,18.25) v5(286.66,6.22) v5(286.66,5.56) v5(286.66,4.93) v5(286.67,4.29) v5(286.67,3.66) v5(287.24,6.22) v5(287.24,5.56) v5(287.24,4.93) v5(287.24,4.29) v5(287.24,3.66)

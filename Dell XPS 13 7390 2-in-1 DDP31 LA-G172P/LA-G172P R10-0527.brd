# Allegro board LA-G172P R10-0527.brd (continued)
## Nets (continued)
PCH_RTCRST#: CH47.2 JAPS1.9 R271.2 RH573.2 UC1.DT47
PCH_RTCX1: CH12.1 RH16.1 UC1.DL48 YC1.1
PCH_RTCX2: RH16.2 RH637.2 UC1.DL49
PCH_RTCX2_R: CH13.1 RH637.1 YC1.2
PCH_SPI_CLK: RC734.1 RH687.2 RH719.2 UC1.DB42
PCH_SPI_CLK_R: JSPI1.4 R703.1 RH24.2 RH719.1
PCH_SPI_CLK_TPM: R648.2 R703.2 U712.19
PCH_SPI_CS0#: RH736.2 UC1.DB43
PCH_SPI_CS0#_R: JSPI1.5 RH736.1 UH8.1
PCH_SPI_CS1#: RH735.2 UC1.DF41
PCH_SPI_CS1#_R: JSPI1.1 RH735.1
PCH_SPI_CS2#: R702.1 UC1.DB41
PCH_SPI_CS2#_TPM: R702.2 U712.20
PCH_SPI_IO2: RH141.1 RH142.1 RH634.2 RH722.2 UC1.DF42
PCH_SPI_IO2_R: RH26.2 RH722.1
PCH_SPI_IO3: RH635.1 RH636.1 RH723.2 UC1.DD41
PCH_SPI_IO3_R: JSPI1.7 RH27.2 RH723.1
PCH_SPI_SI: RH640.2 RH641.1 RH643.1 RH720.2 UC1.DD43
PCH_SPI_SI_R: JSPI1.2 R700.1 RH23.2 RH720.1
PCH_SPI_SI_TPM: R700.2 U712.21
PCH_SPI_SO: RH721.2 UC1.DF43
PCH_SPI_SO_R: JSPI1.3 R701.1 RH25.2 RH721.1
PCH_SPI_SO_TPM: R701.2 U712.24
PCH_TBT_PERST#: RH300.2 RH646.2 RH713.2 RT59.2 RT62.2 UC1.DP21
PCH_TOUCHPAD_INTR#: JIO1.29 RH631.2 UC1.CR38
PCIE_PRX_C_DTX_N3: CH1.2 UWL1.36
PCIE_PRX_C_DTX_N9: CS4.2 USSD1.H5
PCIE_PRX_C_DTX_N10: CS8.2 USSD1.M5
PCIE_PRX_C_DTX_N11: CS21.2 USSD1.T5
PCIE_PRX_C_DTX_N12: CS17.2 USSD1.Y5
PCIE_PRX_C_DTX_N16: CR4.2 UCR1.8
PCIE_PRX_C_DTX_P3: CH2.2 UWL1.37
PCIE_PRX_C_DTX_P9: CS3.2 USSD1.H4
PCIE_PRX_C_DTX_P10: CS7.2 USSD1.M4
PCIE_PRX_C_DTX_P11: CS20.2 USSD1.T4
PCIE_PRX_C_DTX_P12: CS16.2 USSD1.Y4
PCIE_PRX_C_DTX_P16: CR3.2 UCR1.7
PCIE_PRX_DTX_N3: CH1.1 UC1.DE7
PCIE_PRX_DTX_N9: CS4.1 UC1.CP7
PCIE_PRX_DTX_N10: CS8.1 UC1.CM7
PCIE_PRX_DTX_N11: CS21.1 UC1.CK7
PCIE_PRX_DTX_N12: CS17.1 UC1.CJ6
PCIE_PRX_DTX_N13: JNGFF1.33 UC1.CG7
PCIE_PRX_DTX_N14: JNGFF1.21 UC1.CE6
PCIE_PRX_DTX_N16: CR4.1 UC1.CA6
PCIE_PRX_DTX_P3: CH2.1 UC1.DE9
PCIE_PRX_DTX_P9: CS3.1 UC1.CP6
PCIE_PRX_DTX_P10: CS7.1 UC1.CM6
PCIE_PRX_DTX_P11: CS20.1 UC1.CK6
PCIE_PRX_DTX_P12: CS16.1 UC1.CJ7
PCIE_PRX_DTX_P13: JNGFF1.35 UC1.CG6
PCIE_PRX_DTX_P14: JNGFF1.23 UC1.CE7
PCIE_PRX_DTX_P16: CR3.1 UC1.CA5
PCIE_PTX_C_DRX_N3: CH3.2 UWL1.39
PCIE_PTX_C_DRX_N9: CS2.2 USSD1.F5
PCIE_PTX_C_DRX_N10: CS6.2 USSD1.K5
PCIE_PTX_C_DRX_N11: CS23.2 USSD1.P5
PCIE_PTX_C_DRX_N12: CS19.2 USSD1.V5
PCIE_PTX_C_DRX_N13: CS25.2 JNGFF1.39
PCIE_PTX_C_DRX_N14: CS26.2 JNGFF1.27
PCIE_PTX_C_DRX_N16: CR2.2 UCR1.4
PCIE_PTX_C_DRX_P3: CH4.2 UWL1.40
PCIE_PTX_C_DRX_P9: CS1.2 USSD1.F4
PCIE_PTX_C_DRX_P10: CS5.2 USSD1.K4
PCIE_PTX_C_DRX_P11: CS22.2 USSD1.P4
PCIE_PTX_C_DRX_P12: CS18.2 USSD1.V4
PCIE_PTX_C_DRX_P13: CS24.2 JNGFF1.41
PCIE_PTX_C_DRX_P14: CS27.2 JNGFF1.29
PCIE_PTX_C_DRX_P16: CR1.2 UCR1.3
PCIE_PTX_DRX_N3: CH3.1 UC1.DF3
PCIE_PTX_DRX_N9: CS2.1 UC1.DA2
PCIE_PTX_DRX_N10: CS6.1 UC1.CY3
PCIE_PTX_DRX_N11: CS23.1 UC1.CW2
PCIE_PTX_DRX_N12: CS19.1 UC1.CW5
PCIE_PTX_DRX_N13: CS25.1 UC1.CT3
PCIE_PTX_DRX_N14: CS26.1 UC1.CT2
PCIE_PTX_DRX_N16: CR2.1 UC1.CP1
PCIE_PTX_DRX_P3: CH4.1 UC1.DF5
PCIE_PTX_DRX_P9: CS1.1 UC1.DA1
PCIE_PTX_DRX_P10: CS5.1 UC1.CY4
PCIE_PTX_DRX_P11: CS22.1 UC1.CW1
PCIE_PTX_DRX_P12: CS18.1 UC1.CW3
PCIE_PTX_DRX_P13: CS24.1 UC1.CT5
PCIE_PTX_DRX_P14: CS27.1 UC1.CT1
PCIE_PTX_DRX_P16: CR1.1 UC1.CP2
PCIE_RCOMPN: RH1.1 UC1.DN1
PCIE_RCOMPP: RH1.2 UC1.DN3
PCIE_WAKE#: RE185.2 RE186.1 UWL1.29
PCIE_WAKE#_R: RE185.1 RE481.1 UE1.N13
PD_EE_CLK_L: JDB1.2 UPD1.38 UPD3.6
PD_EE_CLK_R: JDB2.2 UPD2.38 UPD4.6
PD_EE_CS#_L: JDB1.5 RPD11.2 UPD1.39 UPD3.1
PD_EE_CS#_R: JDB2.5 RPD59.2 UPD2.39 UPD4.1
PD_EE_MISO_L: JDB1.4 RPD12.2 RPD181.2 UPD1.36 UPD3.2
PD_EE_MISO_R: JDB2.4 RPD60.2 RPD182.2 UPD2.36 UPD4.2
PD_EE_MOSI_L: JDB1.3 UPD1.37 UPD3.5
PD_EE_MOSI_R: JDB2.3 UPD2.37 UPD4.5
PD_EE_WP#_L: RPD14.2 UPD3.3
PD_EE_WP#_R: RPD62.2 UPD4.3
PD_HOLD#_L: RPD13.2 UPD3.7
PD_HOLD#_R: RPD61.2 UPD4.7
PD_ID: RE486.1 RE526.2 UE1.J10
PD_L_DDM_MUX1_EN: RM2.1 RPD123.1
PD_L_DDM_MUX1_EN_R: RPD123.2 RPD191.1 UPD1.42
PD_L_DRAIN1: UPD1.8 UPD1.15 UPD1.19 UPD1.58
PD_L_DRAIN2: UPD1.7 UPD1.52 UPD1.56 UPD1.57
PD_L_GPIO2: RPD139.2 UPD1.18
PD_L_GPIO4: RPD141.1 UPD1.31
PD_L_GPIO16: RPD141.2 UPD1.48
PD_L_GPIO17: RPD139.1 UPD1.49
PD_L_GPIO18: RPD204.1 UPD1.50
PD_L_GPIO19: RPD204.2 UPD1.53
PD_L_PROCHOT#: RPD183.1 RPD185.2 UPD1.40
PD_L_R_PROCHOT#: PR104.1 PR105.1 RPD185.1 RPD186.1
PD_L_SINK_ARB_MASTER_OUT: RPD174.2 UPD1.54
PD_L_SINK_ARB_SLAVE_IN: RPD172.2 RPD189.1 UPD1.55
PD_L_SLAVE_IN: RPD171.1 RPD172.1
PD_L_USB_MUX1_EN: RM1.1 RPD187.1
PD_L_USB_MUX1_EN_R: RPD187.2 RPD190.1 UPD1.16
PD_R_DDM_MUX1_EN: RM18.1 RPD157.1
PD_R_DDM_MUX1_EN_R: RPD157.2 RPD192.1 UPD2.42
PD_R_DRAIN1: UPD2.8 UPD2.15 UPD2.19 UPD2.58
PD_R_DRAIN2: UPD2.7 UPD2.52 UPD2.56 UPD2.57
PD_R_GPIO2: RPD144.2 UPD2.18
PD_R_GPIO4: RPD147.1 UPD2.31
PD_R_GPIO16: RPD147.2 UPD2.48
PD_R_GPIO17: RPD144.1 UPD2.49
PD_R_GPIO18: RPD205.1 UPD2.50
PD_R_GPIO19: RPD205.2 UPD2.53
PD_R_PROCHOT#: RPD184.1 RPD186.2 UPD2.40
PD_R_SINK_ARB_MASTER_OUT: RPD171.2 UPD2.54
PD_R_SINK_ARB_SLAVE_IN: RPD173.2 RPD177.1 UPD2.55
PD_R_SLAVE_IN: RPD173.1 RPD174.1
PD_R_USB_MUX1_EN: RM17.1 RPD188.1
PD_R_USB_MUX1_EN_R: RPD188.2 RPD193.1 UPD2.16
PD_TCP0_LS_EN: RPD126.1 RT83.1
PD_TCP0_LS_EN_R: RPD126.2 UPD1.30
PD_TCP2_LS_EN: RPD134.1 RT94.1
PD_TCP2_LS_EN_R: RPD134.2 UPD2.30
PE: PR1111.2 PR1115.1 PU1100.20
PECI_EC: RE153.2 UC1.CD5
PECI_EC_R: RE153.1 UE1.K13
PM_RSMRST_PWRGD_MIPI60: JMIPI60.42 RC247.2 RC647.2
POWER_SW_IN#: CE104.1 QE25.3 RE184.2 RE187.2 UE1.D5
PRIM_PWRGD: RE245.1 RE461.1 UE1.L7
PROCHOT#_R1: RE158.1 UE1.H13
PROM_BIOS_R: JSPI1.6 R466.1
PS2_CLK1B_TP: C1229.1 D50.2 JIO1.40 RE467.1
PS2_DAT1B_TP: C1226.1 D51.2 JIO1.38 RE468.1
PWM1: PU1100.24 PU1200.9
PWM2: PU1100.23 PU1201.9
PWM_FAN1: JFAN1.2 R36.1 UE1.L10
PWM_FAN2: JFAN2.2 R39.1 UE1.L11
PWRBTN#: CE68.2 JAPS1.11 PD600.1 QF1.1 R208.2 RE187.1 SW1.1 SW1.3 SW2.1 SW2.3
PWRBTN#_FPR: JFP1.7 QF1.3 R208.1
REM_DIODE1_N: CE57.2 CE58.2 CE76.1 QE4.3 QE14.1 QE14.2 UE1.A8
REM_DIODE1_P: CE57.1 CE58.1 CE76.2 QE4.1 QE4.2 QE14.3 UE1.A7
REM_DIODE2_N: CE55.2 CE69.2 CE93.1 QE8.1 QE8.2 QE17.3 UE1.A10
REM_DIODE2_P: CE55.1 CE69.1 CE93.2 QE8.3 QE17.1 QE17.2 UE1.A9
REM_DIODE3_N: CE39.1 CE60.2 CE67.2 QE3.1 QE3.2 QE10.3 UE1.B9
REM_DIODE3_P: CE39.2 CE60.1 CE67.1 QE3.3 QE10.1 QE10.2 UE1.B8
REM_DIODE4_N: CE86.1 CE110.2 QE22.3 UE1.A11
REM_DIODE4_P: CE86.2 CE110.1 QE22.1 QE22.2 UE1.B10
RESET_IN#: RE247.2 UE1.C1
RING2: CA62.1 L15.1 RA2.2 UA1.30
RING2_CONN: CA59.1 DA3.1 JHP1.3 L15.2
RREF: RR1.2 UCR1.9
RSVD_1: TP99.1(TP-1) UC1.J3
RSVD_AA35: TP71.1(TP-1) UC1.AA35
RSVD_L34: TP67.1(TP-1) UC1.L34
RSVD_M34: TP68.1(TP-1) UC1.M34
RSVD_W35: TP72.1(TP-1) UC1.W35
RSVD_Y34: TP73.1(TP-1) UC1.Y34
RT_FORCE_PWR: RPD130.1 RPD138.1 RT6.1 RT109.1 UC1.DT34 URT1.B10 URT2.B10
RT_L_FORCE_PWR: RPD130.2 UPD1.43
RT_R_FORCE_PWR: RPD138.2 UPD2.43
RTC_DET#: RH734.1 UC1.CT38
RTC_DET#_R: QRTC1.1 RH734.2 RTCR2.1
RTCRST_ON: Q3.2 RTCR4.2 UE1.F11
RTCRST_ON_POWER: R5779.2 UE1.N10
RTCRST_ON_R: C1132.1 D116.2 Q348.2 R5769.1
RUN_ON#: QE18.2 QE18.3 RE87.1
RUN_ON_EC: RE15.1 RE475.2 RS378.1 UC4.2 UE1.E8
RUN_ON_P: QE18.5 R6169.1 R6170.1 R6181.1 R6199.1 RC731.1 RE14.2 RE15.2 RE460.2 UC4.4
RUN_ON_P_1P8VS: R6170.2 UC24.3
RUN_ON_P_3VS: R6169.2 UC30.3
RUN_ON_P_5VBS: R6199.2 U60.3
RUN_ON_P_5VS: R6181.2 UC28.3
RUN_ON_R: RC730.2 RC731.2 UC10.2
RUNPWROK: RE448.1 UE1.G3
SBIOS_TX: RE206.1 UC1.DK21
SD3_RCOMP: RC20.1 UC1.CJ43
SD_CD#: JCR1.9 UCR1.30
SD_CLK: CR13.1 JCR1.5 RR4.2
SD_CLK_L: RR4.1 UCR1.17
SD_CMD: CR16.1 JCR1.3 RR6.2
SD_CMD_L: RR6.1 UCR1.19
SD_D2: CR18.1 JCR1.1 RR9.2
SD_D2_L: RR9.1 UCR1.21
SD_D3: CR17.1 JCR1.2 RR8.2
SD_D3_L: RR8.1 UCR1.20
SD_LN0_M: JCR1.14 UCR1.25
SD_LN0_P: JCR1.13 UCR1.26
SD_LN1_M: JCR1.16 UCR1.23
SD_LN1_P: JCR1.17 UCR1.22
SD_PWR_EN: R6171.1 UC1.DU12
SD_PWR_EN_R: R666.2 R667.2 R6171.2 UC31.4
SD_RCLK_M: CR10.1 JCR1.8 RR2.2
SD_RCLK_M_L: RR2.1 UCR1.15
SD_RCLK_P: CR11.1 JCR1.7 RR3.2
SD_RCLK_P_L: RR3.1 UCR1.16
SD_REG2: CR19.1 UCR1.24
SIO_EXT_WAKE#: RC671.2 RE482.1 UC1.DK22
SIO_EXT_WAKE#_EC: RE482.2 UE1.M12
SIO_PWRBTN#: R257.1 RH57.2 UE1.K11
SIO_PWRBTN#_R: RH57.1 UC1.CY42
SIO_SLP_A#: CH55.2 JAPS1.6 RH685.2 UC1.DH47
SIO_SLP_S0#: JAPS1.15 R54.1 R649.2 R747.1 RH689.2 RH709.2 UC1.CL45
SIO_SLP_S3#: CH53.2 JAPS1.2 QE15.2 RC730.1 RE460.1 RH683.2 U15.1 UC1.DF47 UC4.1 UC7.1
SIO_SLP_S4#: CH54.2 JAPS1.5 RC695.1 RH684.2 UC1.DC48 UC5.1 UE1.N12
SIO_SLP_S5#: CH57.2 JAPS1.4 RH691.2 UC1.DF45
SIO_SLP_SUS#: CH56.2 RC699.1 RE115.1 RH686.2 RT84.1 RT95.1 UC1.DM49
SIO_SLP_SUS#_EC: RE115.2 UE1.N4
SIO_SLP_WLAN#: CH52.2 Q124.1 Q350.3 RH682.2 UC1.DE49
SLEEVE: CA63.1 L12.1 RA1.2 UA1.31
SLEEVE_CONN: CA58.1 DA1.1 JHP1.4 L12.2
SLP_VCCST_MIPI60_OVRD: RC619.2 RC623.2 RC626.1 UC9.1
SLP_VCCST_OVRD: RC619.1 RC700.1 UC7.4 UC8.3
SLP_WLAN#_GATE: Q124.2 R322.2 RE476.1
SLP_WLAN#_GATE_R: RE476.2 UE1.K10
SLP_WLAN#_M: D23.2 Q124.3 R616.2 RE321.1
SMB_CLK: CC655.1 R725.2 UC1.DK27
SMB_CLK_MIPI60: JMIPI60.48 R210.2 R725.1
SMB_DATA: R726.2 UC1.DP24
SMB_DATA_MIPI60: JMIPI60.50 R311.2 R726.1
SMC_ONOFF_MIPI60_N: C285.1 JMIPI60.40 R257.2 R267.1
SML0_SMBCLK: CC656.1 RH143.1 RT159.2 RT200.2 UC1.DK24
SML0_SMBDATA: RH144.1 RT160.2 RT201.2 UC1.DJ24
SML0B_SMBCLK: RC673.2 UC1.DW33 UE1.D8
SML0B_SMBDATA: RC672.2 UC1.DV33 UE1.E11
SML0BALERT#: RC727.1 UC1.DU33
SML1_SMBCLK: RH639.2 RPD21.2 RPD105.2 RT124.2 RT197.2
SML1_SMBCLK_R: CC657.1 RH606.1 RH639.1 UC1.DN22
SML1_SMBDATA: RH638.2 RPD22.2 RPD106.2 RT125.2 RT198.2
SML1_SMBDATA_R: RH607.1 RH638.1 UC1.DL22
SNDW_RCOMP: RC16.1 UC1.CV38
SNUB_CHG1: PC236.1 PR215.2
SNUB_CHG2: PC237.1 PR216.2
SOC_SVID_ALERT#: RC601.2 UC1.H1
SOC_SVID_CLK: RC605.2 UC1.H2
SOC_SVID_DAT: RC603.2 UC1.H3
SOC_UART2_MIPI60_RXD: JMIPI60.56 R157.1
SOC_UART2_MIPI60_TXD: JMIPI60.54 R249.1
SOLC: JEDP1.21 TP118.1(TP-1) UE1.K3
SP7_SDWP: QR1.1 UCR1.29
SPI0_MOSI_SYS_PWROK_MIPI60: C220.1 JMIPI60.36 R260.2 R644.2
SPI_CLK_VROM0: RH24.1 UH8.6
SPI_IO2_VROM0: RH26.1 UH8.3
SPI_IO3_VROM0: RH27.1 UH8.7
SPI_SI_VROM0: RH23.1 UH8.5
SPI_SO_VROM0: RH25.1 UH8.2
SPK_-OUT-L+: LA8.1 UA1.42
SPK_-OUT-L-: LA7.1 UA1.43
SPK_-OUT-R+: LA6.1 UA1.45
SPK_-OUT-R-: LA5.1 UA1.44
SPK_DET#: JSPK1.5 RA65.1 UC1.CF49
SPK_L+: CA45.1 DA8.1 JSPK1.1 LA8.2
SPK_L-: CA44.1 DA9.1 JSPK1.2 LA7.2
SPK_R+: CA49.1 DA15.1 JSPK1.3 LA6.2
SPK_R-: CA50.1 DA14.1 JSPK1.4 LA5.2
SPKR: RA9.1 RH667.1 UC1.CH47
SRTCRST#: CH46.1 RH572.2 UC1.DK46
SSD_ALERT#: JSSD1.24 R724.1 USSD1.W18
SSD_C14: R1143.1 USSD1.C14
SSD_CLK_T: JSSD1.12 R444.2 USSD1.U17
SSD_D15: R1134.2 USSD1.D15
SSD_DATA_T: JSSD1.13 R445.2 USSD1.U18
SSD_F15: R1133.1 USSD1.F15
SSD_FORCE_ROM_H: R609.2 USSD1.AA12
SSD_FORCE_ROM_H_R: JSSD1.15 R609.1 R681.1 TP85.1(TP-1)
SSD_FORCE_ROM_I: JSSD1.14 R678.1 USSD1.B4
SSD_FORCE_ROM_T1_S: JSSD1.16 R679.1 USSD1.G16
SSD_FORCE_ROM_T2: R610.2 USSD1.AB4
SSD_FORCE_ROM_T2_R: JSSD1.17 R610.1 R680.1
SSD_H14: R1150.1 USSD1.H14
SSD_H14_R: R1135.2 R1136.1 R1150.2
SSD_JTAG_TCK: JSSD1.2 TP41.1(TP-1) USSD1.N17
SSD_JTAG_TDI: JSSD1.4 TP43.1(TP-1) USSD1.R17
SSD_JTAG_TDO: JSSD1.5 TP44.1(TP-1) USSD1.R18
SSD_JTAG_TMS: JSSD1.3 TP42.1(TP-1) USSD1.N18
SSD_JTAG_TRST#: JSSD1.1 TP40.1(TP-1) USSD1.L18
SSD_PERST#: R470.2 R471.2 USSD1.D7
SSD_PWR1_EN_R: R6166.2 R6185.2 U733.3
SSD_PWR2_EN: R6193.1 UE1.M4
SSD_PWR2_EN_P: CE431.1 PU1500.11 RE490.2 RE491.1
SSD_PWR2_EN_R: R6183.2 R6193.2 U734.3
SSD_PWR2_FB: PR1503.2 PU1500.10 R1141.1 R1142.2 R1143.2
SSD_PWR3_EN: R6164.1 UE1.L9
SSD_PWR3_EN_P: CE410.1 PU1400.15 RE402.2 RE412.1
SSD_PWR3_EN_R: R6164.2 R6184.2 U735.3
SSD_PWR3_FB: PR1403.2 PU1400.13 R1000.1 R1133.2 R1134.1 R1136.2
SSD_SCP#: R787.1 RE48.1 RE426.1 RE522.1 UE1.H5
SSD_SCP#_R: R787.2 USSD1.H15
SSD_SCP_PWR_EN: R6166.1 RE402.1 RE490.1 UE1.N6
SSD_SUSCLK: R6152.2 R6155.2 USSD1.D14
SUS_ON_EC: RE22.1 RE95.2 UC5.2 UE1.D2
SUS_ON_P: RC695.2 RC736.1 RE21.1 RE22.2 UC5.4 UC23.4
SUSCLK: CH49.1 R6155.1 RW8.2 UC1.DF49
SUSCLK_R: RW8.1 UWL1.27 UWL1.A25
SVID_ALERT#: PR1127.2 PR1130.2 RC601.1 RC602.2
SVID_ALERT#_VR: PR1130.1 PU1100.14
SVID_CLK: C4195.1 PR1129.2 PR1132.2 RC605.1 RC606.2
SVID_CLK_VR: PR1132.1 PU1100.12
SVID_DAT: PR1128.2 PR1131.2 RC603.1 RC604.2
SVID_DAT_VR: PR1131.1 PU1100.13
SW_TBT_L_USB20_N1: ML6.1 UM1.2
SW_TBT_L_USB20_N1_R: D408.2 JUSBC1.A7 ML6.2
SW_TBT_L_USB20_N2: ML7.1 UM1.4
SW_TBT_L_USB20_N2_R: D410.2 JUSBC1.B7 ML7.2
SW_TBT_L_USB20_P1: ML6.4 UM1.1
SW_TBT_L_USB20_P1_R: D407.1 JUSBC1.A6 ML6.3
SW_TBT_L_USB20_P2: ML7.4 UM1.3
SW_TBT_L_USB20_P2_R: D409.1 JUSBC1.B6 ML7.3
SW_TBT_R_USB20_N1: ML16.1 UM2.2
SW_TBT_R_USB20_N1_R: D416.2 JUSBC2.A7 ML16.2
SW_TBT_R_USB20_N2: ML17.1 UM2.4
SW_TBT_R_USB20_N2_R: D418.2 JUSBC2.B7 ML17.2
SW_TBT_R_USB20_P1: ML16.4 UM2.1
SW_TBT_R_USB20_P1_R: D415.1 JUSBC2.A6 ML16.3
SW_TBT_R_USB20_P2: ML17.4 UM2.3
SW_TBT_R_USB20_P2_R: D417.1 JUSBC2.B6 ML17.3
SYNC: PU1100.19 PU1200.10 PU1201.10
SYS_PRES#: JT101.2 PR605.1 PU600.5
SYS_PWROK: R644.1 RE157.2 RH594.2 UE1.G4
SYS_PWROK_R: RH594.1 UC1.DP19
SYS_RESET#: CC651.1 JAPS1.13 RC244.1 RC432.1 UC1.DK19
SYS_RESET#_R: RC430.2 RC432.2 UC29.4
SYSPWR_PRES: RE152.2 RE154.2 UE1.B1
TAB_LID#: DE2.1 DE4.1 JIO1.39
TABLE_MODE#: RC679.1 RC680.2 RE431.2 UC1.DU34
TABLE_MODE#_EC: RE431.1 UE1.H8
TACH_FAN1: D132.2 R37.1 UE1.E3
TACH_FAN2: D12.2 R40.1 UE1.D1
TAP_FW_RDY#: JIO1.24 RE493.1 UE1.M10
TAP_RESET#: JIO1.30 UE1.M11
TAP_SMBCLK: RE483.1 RE523.2 UE1.D7
TAP_SMBCLK_R: D476.2 JIO1.26 RE523.1
TAP_SMBDAT: RE484.1 RE524.2 UE1.E7
TAP_SMBDAT_R: D477.2 JIO1.28 RE524.1
TBT_0_DP_AUXN: RT113.1 UC1.AY5
TBT_0_DP_AUXN_R: RT113.2 URT1.M8
TBT_0_DP_AUXP: RT112.1 UC1.AY6
TBT_0_DP_AUXP_R: RT112.2 URT1.L8
TBT_0_LSX_RX: R6172.2 RC691.2 RT165.1 UC1.DK17
TBT_0_LSX_RX_R: RT2.2 RT165.2 URT1.L7
TBT_0_LSX_TX: RT164.1 UC1.DL17
TBT_0_LSX_TX_R: RT1.2 RT164.2 URT1.M7
TBT_0_SBU1: CT206.1 D412.2 JUSBC1.A8 RT118.1 URT1.M10
TBT_0_SBU2: CT207.1 D413.1 JUSBC1.B8 RT119.1 URT1.L10
TBT_0_TRX_C_RD_DTX_N0: CT4.2 URT1.G2
TBT_0_TRX_C_RD_DTX_N1: CT8.2 URT1.E2
TBT_0_TRX_C_RD_DTX_P0: CT3.2 URT1.G1
TBT_0_TRX_C_RD_DTX_P1: CT7.2 URT1.E1
TBT_0_TRX_DTX_N0: CT4.1 UC1.BH2
TBT_0_TRX_DTX_N1: CT8.1 UC1.BF1
TBT_0_TRX_DTX_P0: CT3.1 UC1.BH1
TBT_0_TRX_DTX_P1: CT7.1 UC1.BF2
TBT_0_TRX_RT_DTX_N0: D81.1 JUSBC1.B10 URT1.J11
TBT_0_TRX_RT_DTX_N1: D82.2 JUSBC1.A10 URT1.C11
TBT_0_TRX_RT_DTX_P0: D79.1 JUSBC1.B11 URT1.J12
TBT_0_TRX_RT_DTX_P1: D80.2 JUSBC1.A11 URT1.C12
TBT_0_TTX_C_DRX_N0: CT31.2 D77.1 JUSBC1.A3
TBT_0_TTX_C_DRX_N1: CT33.2 D78.2 JUSBC1.B3
TBT_0_TTX_C_DRX_P0: CT30.2 D75.1 JUSBC1.A2
TBT_0_TTX_C_DRX_P1: CT32.2 D76.2 JUSBC1.B2
TBT_0_TTX_C_RD_DRX_N0: CT2.2 URT1.J2
TBT_0_TTX_C_RD_DRX_N1: CT6.2 URT1.C2
TBT_0_TTX_C_RD_DRX_P0: CT1.2 URT1.J1
TBT_0_TTX_C_RD_DRX_P1: CT5.2 URT1.C1
TBT_0_TTX_CD_DRX_N0: CT31.1 URT1.G11
TBT_0_TTX_CD_DRX_N1: CT33.1 URT1.E11
TBT_0_TTX_CD_DRX_P0: CT30.1 URT1.G12
TBT_0_TTX_CD_DRX_P1: CT32.1 URT1.E12
TBT_0_TTX_DRX_N0: CT2.1 UC1.BB5
TBT_0_TTX_DRX_N1: CT6.1 UC1.AV6
TBT_0_TTX_DRX_P0: CT1.1 UC1.BB6
TBT_0_TTX_DRX_P1: CT5.1 UC1.AV5
TBT_1_LSX_RX: R6173.2 RC692.2 UC1.DP17
TBT_2_DP_AUXN: RT117.1 UC1.BG6
TBT_2_DP_AUXN_R: RT117.2 URT2.M8
TBT_2_DP_AUXP: RT116.1 UC1.BG5
TBT_2_DP_AUXP_R: RT116.2 URT2.L8
TBT_2_LSX_RX: R6174.2 RC693.2 RT166.1 UC1.DL34
TBT_2_LSX_RX_R: RT4.2 RT166.2 URT2.L7
TBT_2_LSX_TX: RT167.1 UC1.DK34
TBT_2_LSX_TX_R: RT3.2 RT167.2 URT2.M7
TBT_2_SBU1: CT306.1 D419.2 JUSBC2.A8 RT120.1 URT2.M10
TBT_2_SBU2: CT307.1 D422.1 JUSBC2.B8 RT121.1 URT2.L10
TBT_2_TRX_C_RD_DTX_N0: CT12.2 URT2.G2
TBT_2_TRX_C_RD_DTX_N1: CT16.2 URT2.E2
TBT_2_TRX_C_RD_DTX_P0: CT11.2 URT2.G1
TBT_2_TRX_C_RD_DTX_P1: CT15.2 URT2.E1
TBT_2_TRX_DTX_N0: CT12.1 UC1.BL1
TBT_2_TRX_DTX_N1: CT16.1 UC1.BM2
TBT_2_TRX_DTX_P0: CT11.1 UC1.BL2
TBT_2_TRX_DTX_P1: CT15.1 UC1.BM1
TBT_2_TRX_RT_DTX_N0: D89.1 JUSBC2.B10 URT2.J11
TBT_2_TRX_RT_DTX_N1: D90.2 JUSBC2.A10 URT2.C11
TBT_2_TRX_RT_DTX_P0: D87.1 JUSBC2.B11 URT2.J12
TBT_2_TRX_RT_DTX_P1: D88.2 JUSBC2.A11 URT2.C12
TBT_2_TTX_C_DRX_N0: CT39.2 D85.1 JUSBC2.A3
TBT_2_TTX_C_DRX_N1: CT41.2 D86.2 JUSBC2.B3
TBT_2_TTX_C_DRX_P0: CT38.2 D83.1 JUSBC2.A2
TBT_2_TTX_C_DRX_P1: CT40.2 D84.2 JUSBC2.B2
TBT_2_TTX_C_RD_DRX_N0: CT10.2 URT2.J2
TBT_2_TTX_C_RD_DRX_N1: CT14.2 URT2.C2
TBT_2_TTX_C_RD_DRX_P0: CT9.2 URT2.J1
TBT_2_TTX_C_RD_DRX_P1: CT13.2 URT2.C1
TBT_2_TTX_CD_DRX_N0: CT39.1 URT2.G11
TBT_2_TTX_CD_DRX_N1: CT41.1 URT2.E11
TBT_2_TTX_CD_DRX_P0: CT38.1 URT2.G12
TBT_2_TTX_CD_DRX_P1: CT40.1 URT2.E12
TBT_2_TTX_DRX_N0: CT10.1 UC1.BF6
TBT_2_TTX_DRX_N1: CT14.1 UC1.BJ5
TBT_2_TTX_DRX_P0: CT9.1 UC1.BF5
TBT_2_TTX_DRX_P1: CT13.1 UC1.BJ6
TBT_3_LSX_RX: R6175.2 RC694.2 UC1.DL33
TBT_CIO_PLUG_EVENT#: TP53.1(TP-1) UC1.CC49
TBT_I2C_INT#: RC687.1 RH659.2 RPD112.2 RPD113.2 RT152.2 RT199.2
TBT_L_CC1: CPD3.1 D411.1 JUSBC1.A5 UPD1.24
TBT_L_CC2: CPD2.1 D414.2 JUSBC1.B5 UPD1.26
TBT_L_FLASH_BUSY#: RT8.1 RT9.1 URT1.A9
TBT_L_FLASH_MSTR_SLV: RT15.1 RT16.1 URT1.A5
TBT_L_FLASH_SHARE_EN: RT13.1 RT14.1 URT1.A4
TBT_L_GPIO_5: RT10.1 RT172.1 URT1.B9
TBT_L_GPIO_6: RT11.1 RT12.1 URT1.A8
TBT_L_GPIO_12: RT17.1 RT18.1 URT1.A6
TBT_L_JTAG_TCK: RT64.1 RT218.1 TP46.1(TP-1) URT1.B5
TBT_L_JTAG_TDI: RT63.1 TP45.1(TP-1) URT1.A3
TBT_L_JTAG_TDO: RT97.1 TP48.1(TP-1) URT1.C5
TBT_L_JTAG_TMS: RT65.1 TP47.1(TP-1) URT1.C3
TBT_L_PERST#: RT59.1 RT162.1 URT1.B8
TBT_L_RBIAS: RT19.2 URT1.L4
TBT_L_RESET#: QT1.3 RT174.1 RT222.1 URT1.L11
TBT_L_ROM_CLK: JDB3.2 URT1.C7 UTS1.6
TBT_L_ROM_CS#: JDB3.5 RT20.1 URT1.B6 UTS1.1
TBT_L_ROM_DI: JDB3.3 URT1.C6 UTS1.5
TBT_L_ROM_DO: JDB3.4 RT21.1 URT1.B4 UTS1.2
TBT_L_ROM_HOLD#: RT23.1 UTS1.7
TBT_L_ROM_WP#: RT22.1 UTS1.3
TBT_L_RSENSE: RT19.1 URT1.L5
TBT_L_SMBCLK: RT159.1 RT193.1 URT1.A7
TBT_L_SMBDAT: RT160.1 RT194.1 URT1.B7
TBT_L_TEST_PWR_GOOD: RT7.2 URT1.B3
TBT_L_THERMDA: TP6A4.1(TP-1) URT1.M11
TBT_L_XTAL_25_IN: RT53.1 URT1.L9
TBT_L_XTAL_25_IN_R: CT42.1 RT53.2 YT1.1
TBT_L_XTAL_25_OUT: RT54.1 URT1.M9
TBT_L_XTAL_25_OUT_R: CT43.1 RT54.2 YT1.3
TBT_R_CC1: CPD12.1 D420.1 JUSBC2.A5 UPD2.24
TBT_R_CC2: CPD13.1 D421.2 JUSBC2.B5 UPD2.26
TBT_R_FLASH_BUSY#: RT189.1 RT190.1 URT2.A9
TBT_R_FLASH_MSTR_SLV: RT38.1 RT39.1 URT2.A5
TBT_R_FLASH_SHARE_EN: RT36.1 RT37.1 URT2.A4
TBT_R_GPIO_5: RT33.1 RT173.1 URT2.B9
TBT_R_GPIO_6: RT34.1 RT35.1 URT2.A8
TBT_R_GPIO_12: RT40.1 RT41.1 URT2.A6
TBT_R_JTAG_TCK: RT98.1 RT219.1 TP51.1(TP-1) URT2.B5
TBT_R_JTAG_TDI: RT71.1 TP49.1(TP-1) URT2.A3
TBT_R_JTAG_TDO: RT73.1 TP52.1(TP-1) URT2.C5
TBT_R_JTAG_TMS: RT72.1 TP50.1(TP-1) URT2.C3
TBT_R_PERST#: RT62.1 RT163.1 URT2.B8
TBT_R_RBIAS: RT50.2 URT2.L4
TBT_R_RESET#: QT2.3 RT175.1 RT224.1 URT2.L11
TBT_R_ROM_CLK: JDB4.2 URT2.C7 UTS2.6
TBT_R_ROM_CS#: JDB4.5 RT42.1 URT2.B6 UTS2.1
TBT_R_ROM_DI: JDB4.3 URT2.C6 UTS2.5
TBT_R_ROM_DO: JDB4.4 RT43.1 URT2.B4 UTS2.2
TBT_R_ROM_HOLD#: RT45.1 UTS2.7
TBT_R_ROM_WP#: RT44.1 UTS2.3
TBT_R_RSENSE: RT50.1 URT2.L5
TBT_R_SMBCLK: RT196.1 RT200.1 URT2.A7
TBT_R_SMBDAT: RT195.1 RT201.1 URT2.B7
TBT_R_TEST_PWR_GOOD: RT30.2 URT2.B3
TBT_R_THERMDA: TP6A5.1(TP-1) URT2.M11
TBT_R_XTAL_25_IN: RT55.1 URT2.L9
TBT_R_XTAL_25_IN_R: CT45.1 RT55.2 YT2.1
TBT_R_XTAL_25_OUT: RT56.1 URT2.M9
TBT_R_XTAL_25_OUT_R: CT44.1 RT56.2 YT2.3
TCP0_RST#: QT1.1 RPD124.1 RPD169.1 RPD170.1 RT174.2
TCP0_RST#_R: RPD124.2 UPD1.17
TCP2_RST#: QT2.1 RPD132.1 RPD167.1 RPD168.1 RT175.2
TCP2_RST#_R: RPD132.2 UPD2.17
TCRCOMP_DN: RC1.1 UC1.AY1
TCRCOMP_DP: RC1.2 UC1.AY2
TESMODE: R452.2 USSD1.Y6
THERMTRIP1#: RE124.1 UE1.B12
THERMTRIP2#: CE61.1 QE16.1 RE215.2 UE1.H3
TOUCH_SCREEN_PD#: D468.1 RH654.1 RH655.1 UC1.DT11
TOUCH_SCREEN_PD#_R: D465.2 D468.2 JEDP1.27 QC2.3 RH654.2 RH743.2 TP123.1(TP-1)
TP_A47: TP1.1(TP-1) UC1.A47
TP_AH10: TP90.1(TP-1) UC1.AH10
TP_AK10: TP89.1(TP-1) UC1.AK10
TP_AM10: TP93.1(TP-1) UC1.AM10
TP_AT1: TP29.1(TP-1) UC1.AT1
TP_AT2: TP28.1(TP-1) UC1.AT2
TP_AU1: TP30.1(TP-1) UC1.AU1
TP_AU2: TP31.1(TP-1) UC1.AU2
TP_AV1: TP27.1(TP-1) UC1.AV1
TP_AV2: TP32.1(TP-1) UC1.AV2
TP_B47: TP2.1(TP-1) UC1.B47
TP_BC10: TP91.1(TP-1) UC1.BC10
TP_BH10: TP94.1(TP-1) UC1.BH10
TP_BW11: TP3.1(TP-1) UC1.BW11
TP_C1: TP59.1(TP-1) UC1.C1
TP_CA11: TP4.1(TP-1) UC1.CA11
TP_CH33: TP92.1(TP-1) UC1.CH33
TP_CL32: TP97.1(TP-1) UC1.CL32
TP_CM33: TP16.1(TP-1) UC1.CM33
TP_CN32: TP98.1(TP-1) UC1.CN32
TP_CT32: TP6.1(TP-1) UC1.CT32
TP_CV32: TP5.1(TP-1) UC1.CV32
TP_DA11: TP96.1(TP-1) UC1.DA11
TP_DB10: TP15.1(TP-1) UC1.DB10
TP_DH49: TP20.1(TP-1) UC1.DH49
TP_DISABLE#: JIO1.33 UE1.F4
TP_DL8: TP22.1(TP-1) UC1.DL8
TP_DP1: TP11.1(TP-1) UC1.DP1
TP_DP2: TP12.1(TP-1) UC1.DP2
TP_DV3: TP19.1(TP-1) UC1.DV3
TP_DV4: TP14.1(TP-1) UC1.DV4
TP_DV6: TP10.1(TP-1) UC1.DV6
TP_DV47: TP24.1(TP-1) UC1.DV47
TP_DW3: TP17.1(TP-1) UC1.DW3
TP_DW4: TP13.1(TP-1) UC1.DW4
TP_DW6: TP9.1(TP-1) UC1.DW6
TP_DW47: TP23.1(TP-1) UC1.DW47
TP_E1: TP60.1(TP-1) UC1.E1
TP_EN: JIO1.35 UE1.H9
TP_F15: TP7.1(TP-1) UC1.F15
TP_G15: TP8.1(TP-1) UC1.G15
TP_J34: TP95.1(TP-1) UC1.J34
TP_N34: TP88.1(TP-1) UC1.N34
TP_P10: TP87.1(TP-1) UC1.P10
TP_R1: TP18.1(TP-1) UC1.R1
TPM_GPIO0: R747.2 U712.6
TPM_GPIO0_NU: R54.2 U712.29
TPM_GPP_B17_SMI#_NMI: RC254.2 RC339.2 UC1.CF47
TPM_PIRQ#: RC255.2 RC338.2 RH737.2
TPM_PIRQ#_B20: RH737.1 UC1.CL47
TPM_PIRQ#_R: R656.2 RC254.1 RC255.1 U712.18
TS_EN_R: R220.2 R672.2 R6168.2 R6194.2 U34.3
TS_I2C_SCL: R1015.1 UC1.DT23
TS_I2C_SCL_R: JEDP1.26 R239.1 R1015.2 TP122.1(TP-1)
TS_I2C_SDA: R1016.1 UC1.DT24
TS_I2C_SDA_R: JEDP1.25 R238.1 R1016.2 TP121.1(TP-1)
TS_INT#: D471.2 JEDP1.28 R288.1 TP124.1(TP-1) UC1.DV14
TS_RST#: D466.2 JEDP1.29 R245.1 TP125.1(TP-1) UC1.CV47
UART2_CTS#: JUART1.4 RC656.1 UC1.DU22
UART2_RTS#: JUART1.1 RC655.1 UC1.DV22
UART2_RXD: JUART1.3 R157.2 RC222.1 UC1.DT22
UART2_TXD: JUART1.2 R249.2 RC223.1 UC1.DW22
UART_RX_I_S: JSSD1.6 USSD1.AA17
UART_TX_I_S: JSSD1.7 USSD1.AA18
UFCAM_LED: QC1.2 R709.1 UC1.CV48
UFCAM_LED_R: JUFC1.24 R710.2 TP136.1(TP-1)
UFCAM_MCLK: R6141.1 UC1.DP38
UFCAM_MCLK_R: JUFC1.27 R6141.2 TP139.1(TP-1)
UFCAM_RESET#: D450.2 R6142.1 RH658.1 UC1.DU24
UFCAM_RESET#_R: JUFC1.25 R6142.2 TP137.1(TP-1)
UPD_L_SMBCLK: RM19.1 UM1.18
UPD_L_SMBDAT: RM20.1 UM1.17
UPD_L_SMBINT#: RE108.1 RPD17.2 UE1.F10
UPD_R_SMBCLK: RM21.1 UM2.18
UPD_R_SMBDAT: RM22.1 UM2.17
UPD_R_SMBINT#: RE109.1 RPD109.2 UE1.F5
UPD_SMBCLK: Q30.1 RE445.1 RE462.1 UE1.C3
UPD_SMBCLK_Q: Q30.6 RE462.2 RM19.2 RM21.2 RPD163.2 RPD165.2
UPD_SMBDAT: Q30.4 RE446.1 RE463.1 UE1.B4
UPD_SMBDAT_Q: Q30.3 RE463.2 RM20.2 RM22.2 RPD164.2 RPD166.2
USB2_COMP: RH10.1 UC1.DN5
USB2_ID: RH8.1 UC1.DL6
USB2_VBUSSENSE: RH9.1 UC1.DL11
USB3_PRX_DTX_N2: JDEBUG1.10 UC1.DG9
USB3_PRX_DTX_P2: JDEBUG1.9 UC1.DG7
USB3_PTX_C_DRX_N2: CH45.2 JDEBUG1.7
USB3_PTX_C_DRX_P2: CH44.2 JDEBUG1.6
USB3_PTX_DRX_N2: CH45.1 UC1.DJ3
USB3_PTX_DRX_P2: CH44.1 UC1.DJ5
USB20_N1: JDEBUG1.4 UC1.DN8
USB20_N5: ML18.4 UC1.DL5
USB20_N5_R: D14.1 JFP1.6 ML18.3
USB20_N8: UC1.DN6 UM1.9
USB20_N9: UC1.DL2 UM2.9
USB20_N10: ML1.4 RW4.1 UC1.DP10
USB20_N10_R: ML1.3 RW4.2 UWL1.69
USB20_P1: JDEBUG1.3 UC1.DP8
USB20_P5: ML18.1 UC1.DL3
USB20_P5_R: D13.1 JFP1.5 ML18.2
USB20_P8: UC1.DP6 UM1.8
USB20_P9: UC1.DL1 UM2.8
USB20_P10: ML1.1 RW5.1 UC1.DN10
USB20_P10_R: ML1.2 RW5.2 UWL1.70
USB_OC0#: RH604.1 UC1.DW14
USB_OC1#: RH718.1 RH742.1 UC1.CR41
USB_OC2#: RH603.1 UC1.CT41
USB_OC3#: RH605.1 UC1.CT43
VCI_IN3#: RE244.1 UE1.E4
VFB: PC1103.1 PR1117.1 PR1120.2 PU1100.5
VRACPU_VTEMP: PC1100.1 PR1101.1 PR1204.1 PR1205.1 PU1100.26
VRALERT#: RC688.1 UC1.CN38
VRALERT#_R: D21.1 PR217.1 RC688.2 RC744.1
VSET_5105: CE79.1 RE199.1 UE1.C9
WAKE#: RH207.1 UC1.DL45
WLAN_PWR_EN: R533.2 R534.2 U34.5
WLAN_PWR_EN_EC: D23.1 R533.1 R6137.2 RE321.2 RE322.2
WLAN_PWR_EN_PCH: Q350.1 R532.2 R534.1
WLAN_WIGIG60GHZ_DIS#: DZ4.1 RE208.2 UE1.L13
WLAN_WIGIG60GHZ_DIS#_R: DZ4.2 UWL1.28
WOV_DMIC_CLK0: RH705.1 UC1.DG36
WOV_DMIC_DATA0: RH706.1 UC1.DG34
XTAL_38P4M_IN: CH11.2 RH14.2 RH17.2 YH1.3
XTAL_38P4M_IN_CPU: RH14.1 UC1.DW8
XTAL_38P4M_OUT: CH10.2 RH15.2 RH17.1 YH1.1
XTAL_38P4M_OUT_CPU: RH15.1 UC1.DU8
N04830: PC235.1 PR218.1 PU200.3
N20151644: PR200.2 PR202.1
N20151664: PR200.3 PR203.1
N27076067: PC243.1 PR231.2
N30248348: PR211.2 PR221.1
N30252391: PC230.2 PR210.2
N30253802: PC244.1 PR230.2 PR233.1 PR234.1
N30256954: PR220.2 PU200.24
N30258320: PC225.1 PR205.1
N30277718: PD201.1 PD202.1 PR208.1
N35975325: PR224.2 PU200.25
N39629096: LED1.2 R530.2
N39629103: LED2.2 R531.2
N41228936: PR226.1 PU200.27
N49696201: PC1206.1 PR1200.2 PU1200.14
N49776653: CE65.1 RE172.2
N51014739: PR901.2 PU900.7
N52032474: PC501.1 PC502.1 PC503.1 PC504.1 PL501.2 PU500.1
N52343314: RD21.2 UD2.A5
N52343316: RD22.2 UD2.A8
N52343354: RD2.2 UD1.A5
N52343360: RD1.2 UD1.A8
N52360782: RD4.2 UD3.A5
N52360800: RD3.2 UD3.A8
N52360829: RD24.2 UD4.A8
N52416800: PQ205.2 PR223.2 PR227.1
N52576195: RM10.1 UM1.11
N52576366: RM9.1 UM1.15
N52676089: RR10.2 UCR1.28
N52692386: PC1105.2 PR1120.1
N52692507: PC1101.1 PR1102.2 PU1100.25
N52692519: PC1104.1 PR1104.2 PR1106.1 PU1100.28
N52692565: PR1134.1 PU1100.10
N52692863: PR1114.2 PR1125.1 PU1100.15
N52692927: PC1102.1 PR1100.1 PR1103.2 PU1100.27
N52693170: PR1108.2 PR1110.2 PU1100.2
N52693178: PR1107.2 PR1116.2 PU1100.3
N52751344: PC510.1 PR503.2 PU500.8
N52752182: PC500.1 PR507.2
N52752447: PC505.1 PR501.1 PR510.2
N52755459: PC911.1 PR912.2 PU900.8
N52755987: PR907.1 PU900.14
N52759880: PC900.1 PR900.2 PU900.18
N52761358: PC901.1 PR902.2
N52765760: PC1208.1 PR1201.2
N52768180: PC1219.1 PR1202.2 PU1201.14
N52768296: PC1221.1 PR1203.2
N52827933: RT122.1 URT1.J6
N52905539: PC713.1 PR703.2 PR705.1 PU700.17
N52905567: PR705.2 PR706.1 PU700.18
N52905575: PC714.1 PU700.14
N52905683: PC700.1 PC701.1 PC702.1 PC703.1 PC704.1 PC705.1 PL700.2 PU700.2 PU700.11
N52924590: PC802.1 PC803.1 PC804.1 PC805.1 PL800.2 PU800.1
N52924674: PC810.1 PR802.2 PU800.8
N52928923: PC512.1 PR506.2
N52929367: PC715.1 PR707.2
N52929663: PC811.1 PR804.2
N52929949: PC912.1 PR910.2
N52994087: PC1412.1 PR1411.2
N52994160: PC1401.1 PC1402.1 PC1403.1 PC1404.1 PL1400.2 PU1400.1 PU1400.16
N52994210: PC1411.1 PR1406.2 PR1409.2 PU1400.3
N52994226: PR1406.1 PU1400.12
N52994410: PC1400.1 PR1401.2
N52995203: PQ600.2 PR603.2 PR604.1
N53109404: PC706.1 PR708.2
N53135832: CC176.1 RC589.2
N53160037: PC711.2 PR712.2
N53169467: PC600.1 PR602.2 PU600.7
N53177904: PC910.1 PR904.2
N53193542: PR211.3 PR222.1
N53198392: PC301.1 PC302.1 PC303.1 PC304.1 PL300.2 PL302.2 PU300.1
N53198778: PR300.2 PU300.16
N53198810: PC300.1 PR303.2
N53198814: PR301.2 PU300.11
N53198852: PC305.1 PR306.2 PR307.1
N53198984: PR310.1 PU300.14
N53199059: PC314.1 PR311.2
N53201443: PC401.1 PC402.1 PC403.1 PC404.1 PC432.1 PL400.2 PL404.2 PU400.1
N53201562: PR400.2 PU400.16
N53201576: PC400.1 PR403.2
N53201602: PR401.2 PU400.11
N53201659: PC405.1 PR406.2 PR407.1
N53201824: PC414.1 PR408.2 PU400.3
N53201840: PR411.1 PU400.14
N53201891: PC415.1 PR410.2
N53202040: PC417.1 PC418.1 PC419.1 PC420.1 PC433.1 PL402.2 PL405.2 PU401.1
N53202160: PR412.2 PU401.16
N53202164: PC416.1 PR415.2
N53202194: PR413.2 PU401.11
N53202247: PC421.1 PR418.2 PR419.1
N53202418: PC430.1 PR420.2 PU401.3
N53202436: PR423.1 PU401.14
N53202478: PC431.1 PR422.2
N53208559: PR1400.2 PU1400.11
N53208718: PR1408.1 PU1400.14
N53270797: PC1405.2 PR1403.1
N53355134: PR1123.1 PU1100.16
N53373804: QM1.2 QM1.3 RC616.2
N53375471: RC627.1 UC9.4
N53408431: C1467.1 U31.10
N53408470: C217.1 U31.12
N53437419: R160.2 R161.2 R162.2 R163.2 R164.2 R165.2 R166.2 R167.2 R168.2 R169.2 R170.2 R171.2 R172.2 R173.2 R174.2 R175.2 R360.1
N53659927: RD23.2 UD4.A5
N54122777: RC623.1 UC8.4
N54819198: RT101.2 URT1.A12
N54819372: RT102.2 URT2.A12
N55030338: RT123.1 URT2.J6
N55957128: CA13.1 CA14.1 CA48.1 RA9.2 RA28.2 RA30.1
N55957255: CA47.1 RA27.2 RA28.1
N55957257: CA46.1 RA8.2 RA27.1
N55962826: CA15.1 UA1.32
N55978423: CA17.2 UA1.38
N55978441: CA20.2 RA10.2 UA1.39
N56357496: RA63.2 UA1.1
N56357525: RA64.1 UA1.33
N56877756: RM12.1 UM2.11
N56877758: RM11.1 UM2.15
N56965750: RPD149.2 UPD2.45
N56965760: RPD150.2 UPD2.46
N56965771: RPD151.2 UPD2.47
N56966161: RPD152.2 UPD1.45
N56966164: RPD153.2 UPD1.46
N56966167: RPD154.2 UPD1.47
N57277748: RC624.1 UC6.4
N57317701: PC1501.1 PC1503.1 PC1504.1 PC1505.1 PL1500.2 PU1500.1
N57317721: PC1511.1 PR1507.2 PU1500.8
N57317772: PC1512.1 PR1509.2
N57317835: PR1507.1 PU1500.5
N57317853: PC1502.1 PR1502.2
N57406634: PC1506.2 PR1503.1
N57457324: PC1103.2 PR1117.2 PU1100.4
N57485049: PR1204.2 PU1200.11
N57485111: PR1205.2 PU1201.11
N57581670: PC801.1 PR801.2
N57612688: PR908.1 PU900.15
N57652232: PQ100.5 PR100.1 PR103.2 PR104.2
N57652736: PQ100.6 PR102.1
N57652767: PQ100.2 PQ100.3 PR101.2
N57792379: C100.1 JMIPI60.12 R113.2 R114.2
N57957180: CW5.1 JANTL3.1 L24.1
N57957195: CW6.1 JANTL1.1 L24.2
N57957882: CW7.1 CW8.1 JANTR3.1 L27.2
N58351095: JDEBUG2.8 RE193.2 RE428.2
N58362161: QC1.3 R710.1 R6207.2
N58555592: CV633.1 DV11.1 R621.2 R624.1
N58555606: CV651.1 DV12.1 R622.2 R623.1
N58555679: QV20.1 R628.2
N58555687: QV20.2 R622.1
N58555721: QV20.3 R652.2
N58555838: QV18.1 R627.2
N58555842: QV18.2 R621.1
N59045842: QE15.3 RE219.1 RE477.2
N59045862: QE16.2 RE219.2
N59074234: CE109.1 RE479.2 UE6.7
N59074244: QE19.2 RE480.1 UE6.5
N59074258: RE478.2 UE6.3
N59591429: C224.1 U34.12
N59591541: C237.1 U34.10
N59636611: C1131.1 D116.1 Q349.2 R2745.1 R5769.2 R5779.1
N59636658: Q348.1 R5768.2
N60250631: F1.1 R636.2 R6205.2 R6206.2
N60434250: CC659.1 RC734.2
N61867318: JNGFF1.46 RS377.1
N62320917: CS95.1 US1.6
N62322923: CT362.1 UT1.6
N62323625: CT210.1 UT2.6
N62327553: C4189.1 UC24.6
N62327555: C234.1 UC25.6
N62327559: C4205.1 UC28.6
N62327561: C4209.1 U734.6
N62327579: C1676.1 U733.6
N62332316: C1683.1 U735.6
N64510614: C4213.1 U60.6
N65197718: C245.1 U36.6
N65755618: C227.1 UC30.6
N65757083: C244.1 U51.6
N66149970: RW1.1 RW36.1 UW2.4
N66651145: QW2.2 QW2.3 RW39.1
N66651168: QW2.6 RW40.1 RW45.2
N67742614: C453.1 R648.1
N67754895: RE494.1 UE1.K1
N71871431: Q16.6 R30.2 R633.2
N72909470: D132.1 JFAN1.3 R38.1
N72910554: D12.1 JFAN2.3 R41.1
N73050981: QZ20.1 R789.1
N73546395: JANTR1.1 L27.1
N73773655: Q16.5 R633.1
N73857547: QC2.5 QC2.6 RC147.1
N73891446: Q16.3 R931.2 R932.2
N76201276: Q3.1 R271.1
N76327865: QT1.2 RT223.1
N76328430: QT2.2 RT225.1

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JCR1 11; JEDP1 37; JMIPI60 18 20 22 24 26 28 30 32 34 44 46; JNGFF1 1 6 7 8 9 10 12 13 14 15 16 17 18 20 22 24 26 28 30 32 34 36 38 40 48 50 51 52 53 54 55 56 57 58 59 60 61 67; JSPK1 7 8; JSSD1 10 11; JUFC1 3 7; PD101 3; PU200 13 26; PU300 8; PU400 8; PU401 8; PU1100 1 22; RA63 1; RC727 2; RE485 1; RH200 2; RH201 2; RH202 2; RH203 2; RH632 1; RH633 1; RH730 2; RH731 2; U7 3; U55 3; U712 3 4 5 7 10 11 12 13 15 25 26 27 28 30 31; UA1 6 7 8 9 10 11 12 13 47; UC1 A4 A5 A7 A9 A33 AC1 AC2 AC3 AC5 AD3 AD4 AE1 AE2 AE3 AE5 AE11 AF10 AJ11 AL3 AL5 AL11 AN3 AN5 AN7 AN9 AN11 AP10 AR5 AR6 AR10 B7 B9 B33 B45 BB1 BB2 BB45 BB47 BB48 BD1 BD2 BD47 BE48 BE49 BF39 BG11 BG39 BJ11 BJ38 BJ39 BJ46 BL10 BL45 BL49 BM36 BP5 BP6 BP36 BP41 BR1 BR2 BT1 BT2 BT5 BT6 BT36 BV5 BV6 C2 C5 C7 C8 C9 C33 C44 CC5 CC6 CC48 CD3 CF3 CF5 CG32 CH45 CH48 CJ32 CJ39 CK3 CK4 CK33 CK47 CL41 CP3 CR3 CR4 CR39 CR42 CR43 CT6 CT7 CT49 CV6 CV7 CV37 CV42 CY6 CY7 CY35 CY37 CY38 CY39 CY43 D1 D4 D7 D8 D9 D14 D33 DA3 DA5 DA6 DA7 DA45 DA47 DA48 DB37 DB39 DC7 DC9 DD1 DD2 DD3 DD5 DD38 DE3 DE4 DF1 DF2 DF37 DF48 DJ1 DJ2 DJ6 DJ8 DJ10 DJ11 DJ13 DJ17 DJ22 DJ34 DJ40 DK10 DK11 DK13 DK15 DK31 DK36 DK40 DL36 DL38 DL40 DN11 DN13 DN17 DN27 DN33 DN38 DN48 DP3 DP5 DP11 DP13 DP15 DP29 DP36 DP40 DP42 DR5 DT2 DT16 DT18 DT19 DT28 DT33 DT38 DU11 DU16 DU18 DU29 DU38 DU42 DV16 DV19 DV24 DV28 DV38 DW12 DW16 DW18 DW19 DW28 DW29 DW30 DW38 DW42 E16 F6 F10 F13 G6 G8 G10 G11 G13 G34 H5 H34 J8 J11 K6 K10 K13 L6 L8 L10 L11 L13 M8 M11 M13 M38 M48 N46 N47 P38 P39 P42 R48 T42 U47 V38 V43 Y11 Y45 Y49; UC31 3; UCR1 31; UD1 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; UD2 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; UD3 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; UD4 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; UE1 B3 B13 C11 E5 F13 G5 H2 J3 J8 K4 K9 K12 L6 M6 N3 N9; UE5 1 5; UE8 1; UE10 1 5; UM1 6 7 19 20; UM2 6 7 19 20; URT1 A1 A2 L3; URT2 A1 A2 L3; USSD1 A1 A2 A4 A6 A8 A11 A13 A15 A17 A18 AA6 AA7 AA8 AA9 AA10 AA11 AA16 AB1 AB2 AB6 AB8 AB11 AB15 AB17 AB18 AC1 AC2 AC4 AC6 AC8 AC11 AC15 AC17 B1 B2 B6 B8 B11 B13 B15 B17 B18 C6 C7 C8 C9 C10 C11 C12 C13 C18 D12 E8 E12 E16 E17 E18 F14 G17 G18 J16 J17 J18 K14 K15 L7 L8 L9 L10 L11 L12 L16 L17 M7 M8 M11 M12 M14 M15 N7 N8 N9 N10 N11 N12 N16 P14 P15 R16 T14 T15 U16 V14 V15 W7 W8 W12 W13 W16 W17 Y7 Y8 Y12 Y15; UW2 1 5; UWL1 1 2 3 7 8 9 10 11 12 13 14 15 16 18 19 21 22 24 25 42 43 44 45 46 47 48 49 50 51 52 53 60 61 64 65 66 67 A08 A09 A10 A11 A12 A13 A14 A16 A17 A18 A27 A28 A29 A30 A45 A46 A47

## Via types
v1: diameter 0.254, hole 0.102, TOP to IN1, 2287 vias
v2: diameter 0.406, hole 0.203, IN1 to IN3, 2397 vias
v3: diameter 0.305, hole 0.152, TOP to BOTTOM, 445 vias
v4: diameter 0.254, hole 0.102, IN3 to BOTTOM, 606 vias
v5: diameter 0.457, hole 0.203, TOP to BOTTOM, 2701 vias
v6: diameter 0.406, hole 0.203, TOP to BOTTOM, 207 vias
v7: diameter 0.508, hole 0.254, TOP to BOTTOM, 39 vias
v8: diameter 0.254, hole 0.102, TOP to GND2, 3342 vias
v9: diameter 0.254, hole 0.102, GND3 to BOTTOM, 1615 vias
v10: diameter 0.254, hole 0.102, TOP to GND1, 1688 vias
v11: diameter 0.254, hole 0.102, GND4 to BOTTOM, 1698 vias
v12: diameter 0.254, hole 0.102, GND1 to GND2, 1103 vias
v13: diameter 0.254, hole 0.102, GND1 to IN1, 415 vias
v14: diameter 0.254, hole 0.102, GND3 to GND4, 1348 vias
v15: diameter 0.254, hole 0.102, GND3 to IN3, 47 vias
v16: diameter 0.254, hole 0.102, IN3 to GND4, 415 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_VDDQ_EN: length 11.8
  TOP w0.081: RD43.1 RD44.2 91.61,65.44 91.42,65.25 91.04,65.25 90.6,64.81 90.6,64.25 90.46,64.11 90.46,63.54 90.27,63.35 89.99,63.35 v1(89.68,63.65)
  IN1 w0.064: v1(89.68,63.65) 88.95,63.65 88.28,64.31 83.65,64.31 v1(82.88,65.08)
0.6V_VDDQ_EN_P: length 3.3
  TOP w0.254: RD300.1 83.75,64.94 CD309.1 83.47,65.7 83.18,65.98 RD400.2 82.88,66.28 82.25,66.91 PU800.11
0.6V_VDDQ_PG: length 2.2
  TOP w0.254: RD41.2 81.34,71.12 80.93,70.71 80.73,70.71 PR802.1 80.6,70.15 80.75,70 PU800.5
1.1V_MEM_EN: length 11.5
  TOP w0.254: PU700.15 92.99,61.06 92.95,61.1 90.82,61.1 v3(90.79,61.13) 90.08,61.85 90.08,62.71 90.84,63.47 90.84,63.87 90.95,63.98 90.95,64.69 91.21,64.95 91.68,64.95 91.82,65.09 RD43.2 92.31,65 RC736.2 92.96,65.05 CC707.1 93.95,64.98 RC737.1
1.1V_MEM_PG: length 16.8
  TOP w0.254: v1(92.61,60.68) 92.73,60.56 PU700.16
  IN1 w0.254: v1(92.61,60.68) 92.61,61.46 87.46,66.61 87.46,68.38 84.62,71.22 v1(83.19,71.22)
1.8V_PRIM_PG: length 144.5
  TOP w0.254: v5(213.9,53.01) 213.58,53.33 RE245.2 ; D475.1 202.98,51.31 202.98,46.83 v5(202.72,46.57) ; v1(209.17,20.14) 209.17,19.83 208.5,19.17 208.5,17.65 208.64,17.51 PR503.1 209.19,17.51 PR509.2
  IN1 w0.064: v5(202.72,46.57) 202.52,46.37 202.52,44.5 203.49,43.53 203.49,31.02 202.03,29.56 202.03,25.3 v2(202.66,24.66) 202.89,24.66 203.58,23.98 208.76,23.98 209.3,23.44 209.3,22.69 v1(209.63,22.36) 209.63,21.8 209.17,21.34 v1(209.17,20.14) ; v2(143.23,4.13) 142.65,4.7 142.65,6.09 v1(142.29,6.46)
  IN2 w0.051: v2(143.23,4.13) 144.55,4.13 145.08,3.59 153.27,3.59 153.99,2.88 176.88,2.88 179.25,5.25 179.25,8.92 176.25,11.93 175.56,12.62 175.56,17.01 176.72,18.17 193.42,18.17 195.55,20.31 197.78,20.31 198.99,21.51 198.99,23.72 200.05,24.79 202.54,24.79 v2(202.66,24.66)
  IN2 w0.254: v5(213.9,53.01) 213.9,52.55 211.79,50.44 210.5,50.44 209.93,49.88 207,49.88 206.19,49.06 203.84,49.06 202.72,47.94 v5(202.72,46.57)
  BOTTOM w0.081: v5(213.9,53.01) 214.38,53.01 v3(214.41,53.04)
3.3V_CAM_EN: length 35.7
  TOP w0.081: R6163.1 168.75,65.42 169.77,64.4 169.77,63.6 169.96,63.41 v3(170.28,63.41) 170.84,63.41 171.04,63.6 173.61,63.6 v1(174.03,63.18)
  IN1 w0.064: 165.31,45.69 165.87,46.25 165.87,48.12 166.12,48.37 167.17,48.37 167.33,48.53 169.48,48.53 169.68,48.72 170.1,48.72 171.88,50.5 173.06,50.5 174.96,52.4 174.96,55.17 174.68,55.45 174.68,56.91 175.12,57.36 175.12,58.79 174.63,59.28 174.63,59.7 174.9,59.97 175.38,59.97 176.17,60.76 176.17,62.23 175.87,62.53 174.91,62.53 174.26,63.18 v1(174.03,63.18)
  IN1 w0.081: 165.31,45.69 164.52,44.91 v1(164.25,44.91)
3.3V_CAM_EN_R: length 3.4
  TOP w0.081: U55.4 167.42,66.78 v3(167.13,66.49) 167.44,66.18 R6162.2 R6163.2 R704.2
3.3V_TBT_L_EN: length 7.5
  TOP w0.081: v1(19.08,40.49) 19.12,40.45 RT83.2 RT179.1 RT178.1
  IN1 w0.064: v1(17.58,37.05) 16.93,37.7 16.93,39.02 18.07,40.15 18.07,40.68 18.19,40.8 18.77,40.8 v1(19.08,40.49)
3.3V_TBT_R_EN: length 3.7
  TOP w0.254: RT95.2 RT94.2 RT158.1 RT93.1 289.31,26.96 288.76,27.51 UT2.3
3.3V_TS_EN: length 42.9
  TOP w0.081: v1(177.75,61.44) 177.75,63.48 176.74,64.49 176.33,64.49 R6168.1
  IN1 w0.064: v1(211.9,59.56) v2(211.9,59.09) ; v1(177.75,61.44) 177.95,61.23 v2(177.95,60.79)
  IN2 w0.051: v2(211.9,59.09) 211.81,59.18 209.67,59.18 209.34,58.85 207.66,58.85 207.39,59.13 205.14,59.13 204.94,58.93 202.89,58.93 202.65,58.69 201.02,58.69 200.39,59.33 196.11,59.33 195.49,59.94 193.14,59.94 190.7,57.5 189.32,57.5 188.31,58.51 183.26,58.51 182.15,59.62 180.88,59.62 180,60.5 178.24,60.5 v2(177.95,60.79)
3V_PRIM_EN: length 1.5
  TOP w0.081: U31.5 204.39,10.95 204.57,10.77 RC657.2
3VALW_DSW_EN: length 1.6
  TOP w0.081: RC651.2 203.99,10.7 203.59,11.11 U31.3
3VALW_PG: length 214.2
  TOP w0.081: v5(60.93,9.41) 60.93,9.65 58.67,11.9 58.67,12.51 55.6,15.59 v5(55.6,16.17) ; RC702.1 175.65,16.24 v1(176.06,16.65)
  TOP w0.254: PU300.12 83.67,56.43 84.06,56.04 v5(84.06,55.47) 84.34,55.2 PR308.1
  IN1 w0.064: v1(176.06,16.65) 176.06,16.54 v2(176.23,16.37)
  IN2 w0.051: v5(60.93,9.41) 61.77,9.41 61.82,9.37 66.45,9.37 67.02,9.94 75.17,9.94 77.25,7.87 77.25,6.36 81.14,2.46 92.73,2.46 93.7,3.42 95.17,3.42 96.3,2.28 132.76,2.28 133.52,3.05 152.87,3.05 153.56,2.35 177.02,2.35 179.71,5.05 179.71,9.27 176.05,12.92 176.05,16.19 v2(176.23,16.37)
  BOTTOM w0.081: v5(55.6,16.17) 55.79,15.98 57.94,15.98 59.59,17.62 65.46,17.62 67.9,20.05 v3(68.55,20.05) 69.05,20.05 69.31,20.31 69.31,29.37 72.44,32.49 72.44,55.05 72.86,55.47 v5(84.06,55.47)
3VS_SSD_EN: length 2.9
  TOP w0.081: v3(217.14,13.5) 217.27,13.37 217.27,12.36 216.96,12.05 RS378.2 217.14,11.84 US1.3
5VALW_PG: length 179.1
  TOP w0.081: RC703.1 175.65,13.74 175.11,13.21 173.6,13.21 v3(173.35,13.46) 171.7,13.46 171.31,13.07 v1(171.31,11.78)
  TOP w0.254: v1(22.96,4.46) 22.96,4.67 22.59,5.04 PU400.12
  IN1 w0.064: v1(22.96,4.46) 22.96,6.45 23.46,6.96 28.8,6.96 30.74,8.9 34.83,8.9 35.01,8.72 40.86,8.72 42.77,10.63 44.05,10.63 46.03,8.66 54.65,8.66 59.09,4.23 60.23,4.23 61.58,5.58 68.13,5.58 68.68,6.13 71.77,6.13 75.27,2.63 81.4,2.63 82.59,3.81 88.14,3.81 89.4,5.08 89.85,5.08 93.25,8.48 96.58,8.48 97.08,7.99 108.91,7.99 110.39,6.51 118.93,6.51 121,4.44 123.02,4.44 128.73,10.16 132.72,10.16 135.36,12.79 136.15,12.79 136.34,12.99 136.34,13.29 139.26,16.21 140.76,16.21 141.88,17.33 150.77,17.33 151.64,18.2 157.37,18.2 158.29,17.28 160.19,17.28 161.55,15.92 162.32,15.92 163.93,14.31 164.27,14.31 165.79,12.79 167.71,12.79 168.72,11.78 v1(171.31,11.78)
5VALWB_PG: length 111.2
  TOP w0.254: v1(176.02,17.5) RC704.1
  IN1 w0.254: v2(177.71,16.7) 176.82,16.7 v1(176.02,17.5) ; v1(271.76,2.64) 271.76,5.74 v1(270.6,6.91) 270.11,6.91 269.72,6.51 v2(265.91,6.51)
  IN2 w0.254: v2(177.71,16.7) 177.96,16.95 189.39,16.95 199.74,6.6 200.58,6.6 201.77,5.41 204.08,5.41 204.69,6.02 206.84,6.02 208.04,7.21 213.96,7.21 214.57,6.6 217.8,6.6 218,6.4 221.21,6.4 222.41,7.6 222.86,7.6 227.32,3.15 236.88,3.15 237.61,3.87 247.69,3.87 249.64,5.83 250.83,5.83 252.44,4.21 263.61,4.21 v2(265.91,6.51)
+0.6V_VDDQ: length 0.6
  BOTTOM w0.102: v5(74.96,63.09) v6(74.39,63.09)
  vias: v5(75.53,63.09) v5(76.11,63.09) v5(76.68,63.09) v5(103.03,61.38) v5(103.03,60.74) v5(103.03,60.11) v5(103.03,59.47)
+0.6V_VDDQP: length 5.2
  IN1 w0.254: v1(75.89,65.07) 76.47,64.49 v1(80.86,64.49)
  vias: v3(76.49,66.65)
+0.9V_TBT_L_LC: length 1
  IN1 w0.254: v2(12.79,43.87) 12.79,44.06 v1(13.05,44.32)
  IN3 w0.254: v4(13.05,44.21) 12.79,43.95 v2(12.79,43.87)
+0.9V_TBT_L_LVR: length 0.9
  IN1 w0.254: v2(14.96,45.69) v1(15.4,45.69)
  IN3 w0.254: v2(14.96,45.69) 14.89,45.69 14.76,45.82 v4(14.54,45.82)
+0.9V_TBT_L_SVR: length 4.5
  IN1 w0.254: v2(11.78,45.29) 11.75,45.31 v1(11.75,45.62) ; v2(12.42,45.29) 12.4,45.3 v1(12.4,45.62) ; v1(12.4,46.92) 12.4,47.22 v2(12.45,47.27) ; v1(12.4,44.32) 12.29,44.2 v2(12.29,43.92) ; v1(11.1,46.92) v2(11.1,47.25) ; v1(11.1,44.32) 11.1,44.21 11.27,44.04 11.27,44.03 v2(11.28,44.03)
  IN3 w0.254: v2(11.28,44.03) 11.27,44.03 11.27,44.04 11.06,44.26 v4(11.06,44.3) ; v2(11.1,47.25) 11.1,47 11.15,46.96 v4(11.15,46.9) ; v4(12.45,46.84) v2(12.45,47.27) ; v4(12.42,45.65) v2(12.42,45.29) ; v2(12.29,43.92) 12.29,44.13 v4(12.45,44.3) ; v4(11.78,45.65) v2(11.78,45.29)
  vias: v1(16.35,40.3) v1(16.35,39.98) v2(16.03,42.01) v2(16.03,41.38) v5(16.48,41.69) v5(16.48,41.06) v6(12.1,47.92)
+0.9V_TBT_R_LC: length 0.9
  IN1 w0.203: v2(280.72,36.02) 280.72,36.19 v1(280.92,36.39)
  IN3 w0.254: v2(280.72,36.02) 280.72,36.04 v4(281.02,36.33)
+0.9V_TBT_R_LVR: length 4.9
  TOP w0.203: URT2.L6 URT2.M6 282.9,37.46
  TOP w0.254: CT201.1 284.15,37.41 v5(282.95,37.41) 282.9,37.46
  BOTTOM w0.102: v5(282.95,37.41) v6(283.6,37.41)
  BOTTOM w0.356: CT84.1 281.82,37.82 282.54,37.82 v5(282.95,37.41)
+0.9V_TBT_R_SVR: length 3.8
  IN1 w0.203: v2(279.18,36.07) 279.18,36.19 v1(278.97,36.39) ; v1(280.27,36.39) 280.26,36.39 v2(279.94,36.07)
  IN1 w0.254: v2(279.32,38.68) 279,38.99 v1(278.97,38.99)
  IN3 w0.203: v2(279.18,36.07) 279.18,36.09 278.98,36.3 v4(278.89,36.3) ; v2(280.09,38.02) 280.28,37.82 v4(280.28,37.73) ; v4(279.69,37.78) v2(279.92,37.55)
  IN3 w0.254: v4(279.03,38.96) 279.03,38.96 v2(279.32,38.68) ; v4(280.3,38.96) 280.35,38.96 v2(280.58,38.73) ; v4(280.39,36.33) 280.2,36.33 v2(279.94,36.07)
  vias: v1(279.62,37.69) v1(280.27,38.99) v1(280.27,37.69) v1(283.12,32.68) v1(283.43,32.68) v1(283.75,32.68) v1(284.07,32.68) v1(284.39,32.68) v1(284.7,32.68) v2(283.27,33.06) v2(283.77,33.06) v2(284.24,33.06) v3(284.71,30.39)
+1.1V_MEM: length 111.9
  TOP w0.089: 128.9,55.08 128.86,55.04 128.22,55.04 128.21,55.03 ; 154.67,47.47 154.67,47.76
  TOP w0.094: 113.57,55.03 113.67,55.03
  TOP w0.127: UC1.BD36 147.31,41.6 ; UC1.BD36 147.53,41.39 UC1.BE37 ; UC1.BD36 147.92,40.99 v5(147.98,40.99) 148.05,40.99 UC1.BF36 ; UC1.BD36 147.31,41.17 147.24,41.17 v5(147.06,40.99) 147,40.99 UC1.BB36 ; v4(152.56,41.85) 152.77,41.64 ; v4(152.56,41.85) 152.35,41.64 ; v4(152.56,41.85) 152.35,42.06 ; v4(152.56,41.85) 152.77,42.06 ; UC1.BJ36 150.66,40.99 v5(150.72,40.99) ; UC1.BJ36 150.06,41.6 ; UC1.BJ36 150.27,41.39 UC1.BL37 ; UC1.BJ36 149.88,40.99 v5(149.81,40.99) ; UC1.AW37 145.45,42.06 ; UC1.AW37 145.03,42.06 ; UC1.AW37 144.78,41.39 UC1.AV36 ; UC1.AW37 145.24,41.84 UC1.AY36 ; UC1.AN36 142.43,40.99 v5(142.49,40.99) 142.56,40.99 UC1.AR36 ; UC1.AN36 141.65,40.99 v5(141.58,40.99) 141.51,40.99 UC1.AL36 ; UC1.AN36 142.24,41.59 ; UC1.AN36 141.82,41.6 ; UC1.AC35 136.79,41.14 ; UC1.AC35 136.79,40.71 ; UC1.AC35 137.21,40.72 ; UC1.AC35 137.21,41.13 ; UC1.AG36 138.9,40.99 v5(138.83,40.99) 138.77,40.99 UC1.AE36 ; UC1.AG36 139.08,41.6 ; UC1.AG36 139.5,41.59 ; UC1.AG36 139.68,40.99 v5(139.75,40.99) 139.82,40.99 UC1.AJ36 ; UC1.AY36 145.7,41.39 UC1.BA37 ; UC1.AY36 145.9,41.18 145.96,41.18 v5(146.15,40.99) 146.22,40.99 UC1.BB36 ; UC1.AY36 145.48,41.17 145.41,41.17 v5(145.23,40.99) 145.17,40.99 UC1.AV36 ; v5(149.81,40.99) 149.75,40.99 149.36,41.39 ; v5(149.81,40.99) 149.41,41.39 UC1.BG36 149.36,41.39 UC1.BF37 148.44,41.39 UC1.BF36 ; 150.94,42.06 UC1.BL37 ; UC1.BL37 150.52,42.06 ; UC1.BL37 150.94,41.64 ; UC1.AA37 136.3,42.06 ; UC1.AA37 135.88,41.64 ; UC1.AA37 136.3,41.64 ; UC1.AA37 135.88,42.06 ; 149.36,41.39 149.56,41.59 ; 149.36,41.39 148.96,40.99 v5(148.89,40.99) 148.83,40.99 UC1.BF36 ; UC1.BE37 147.98,41.84 UC1.BF36 ; UC1.BE37 148.19,42.06 ; UC1.BE37 147.77,42.06 ; UC1.AC37 137.21,42.06 ; UC1.AC37 136.79,42.06 ; UC1.AC37 136.79,41.64 ; UC1.AC37 137.21,41.64 ; UC1.AJ36 139.99,41.6 ; UC1.AJ36 140.6,40.99 v5(140.66,40.99) 140.73,40.99 UC1.AL36 ; UC1.AJ36 140.41,41.59 ; 132.64,41.29 132.41,41.29 v1(132.31,41.39) ; UC1.BA37 145.94,42.06 ; UC1.BA37 146.61,41.39 UC1.BB36 ; UC1.BA37 146.36,42.06 ; 137.71,40.71 UC1.AD35 ; UC1.AD35 137.71,41.14 ; UC1.AD35 138.13,40.72 ; UC1.AD35 138.13,41.13 ; v1(155.76,42.96) 155.55,42.75 ; v1(155.76,42.96) 155.97,42.75 ; v1(155.76,42.96) 155.55,43.17 ; v1(155.76,42.96) 155.97,43.17 ; UC1.AR37 143.41,41.84 UC1.AT36 ; UC1.AR37 143.2,42.06 ; UC1.AR37 142.95,41.39 142.95,41.39 ; UC1.AR37 143.62,42.06 ; v1(152.1,42.96) 152.31,42.75 ; v1(152.1,42.96) 151.89,43.17 ; v1(152.1,42.96) 152.31,43.17 ; v1(152.1,42.96) 151.89,42.75 ; 137.67,41.18 UC1.AD36 ; UC1.AD36 137.67,41.59 ; UC1.AD36 137.25,41.17 ; UC1.AD36 137.25,41.6 ; v1(131.06,42.31) 131.26,42.52 ; v1(131.06,42.31) 131.26,42.1 ; v1(131.06,42.31) 130.84,42.52 ; v1(131.06,42.31) 130.84,42.1 ; v1(152.1,42.31) 151.89,42.52 ; v1(152.1,42.31) 152.31,42.52 ; v1(152.1,42.31) 151.89,42.1 ; v1(152.1,42.31) 152.31,42.1 ; UC1.BU37 153.26,41.64 ; UC1.BU37 153.02,42.31 UC1.BT38 ; UC1.BU37 153.68,42.06 ; UC1.BU37 153.47,41.84 153.66,41.65 ; UC1.AL36 141.33,41.59 ; UC1.AL36 140.91,41.6 ; UC1.AT36 143.88,41.39 144.1,41.6 ; UC1.AT36 143.48,40.99 v5(143.41,40.99) 143.34,40.99 UC1.AR36 ; UC1.AT36 144.26,40.99 v5(144.32,40.99) 144.39,40.99 UC1.AV36 ; UC1.AB36 136.75,41.59 ; UC1.AB36 136.34,41.6 ; UC1.AB36 136.75,41.18 ; UC1.AB36 136.34,41.17 ; UC1.AP37 142.95,41.39 ; UC1.AP37 142.28,42.06 ; UC1.AP37 142.7,42.06 ; UC1.AP37 142.28,41.64 ; 142.95,41.39 UC1.AR36 ; UC1.BB36 146.82,41.59 ; 149.11,42.06 148.9,41.85 148.69,42.06 ; UC1.AV36 144.57,41.6 ; 151.64,41.85 151.85,42.06 ; 151.64,41.85 151.85,41.64 ; 151.64,41.85 151.43,41.64 ; 151.64,41.85 151.43,42.06 ; 132.02,41.27 132.19,41.27 v1(132.31,41.39) ; v1(132.31,41.39) 132.51,41.6 ; v1(132.31,41.39) 132.09,41.6 ; UC1.AE36 138.16,41.17 ; UC1.AE36 138.16,41.6 ; UC1.AE36 138.58,41.59 ; 153.22,42.52 UC1.BT38 ; UC1.BT38 152.8,42.52 ; UC1.BT38 152.8,42.1
  TOP w0.2: UD1.U8 159.39,65.11 v5(159.72,65.43) ; v5(146.13,65.43) 145.8,65.11 UD2.U8 ; v5(114.14,65.49) 113.76,65.11 UD4.F5 ; UD3.F5 128.66,65.11 v5(128.98,65.43)
  TOP w0.203: UD2.F8 145.8,57.96 146.1,57.67 v5(146.1,57.63) ; UD4.U8 115.84,57.96 v5(115.51,58.29) ; UD3.U5 128.63,57.96 129.13,58.46 v5(129.19,58.46) ; v5(130.35,58.29) 130.67,57.96 UD3.U8 ; v5(114.12,57.64) 113.8,57.96 UD4.U5
  TOP w0.25: UD1.N12 v5(154.71,62.51) ; 119.22,60.56 v5(120.7,60.56) ; 164.81,60.56 165.63,60.56 v5(165.73,60.66) ; v5(158.27,54.1) 158.27,54.57 UD1.A9 ; UD4.N1 v5(109.89,60.56) ; 151.22,60.56 152.31,60.56 v5(152.5,60.74) ; v5(144.51,54.32) 144.82,54.63 144.82,54.71 ; 112.57,54.27 v5(112.55,54.27) ; UD3.N12 v5(134.93,60.56) ; UD1.K12 v5(154.71,60.56)
  TOP w0.254: v5(117.22,68.67) 117.22,68.67 117.2,68.68 117.14,68.68 UD4.A9 ; UD4.AB9 v5(116.82,54.08) ; UD2.K12 142.42,60.55 CD59.1 140.22,60.88 v5(140.43,61.1) ; UD2.N1 151.79,62.51 v5(152.5,63.22) ; CD7.1 153.9,63.81 v5(154.91,63.81) UD1.R12 ; v5(147.31,65.16) 147.37,65.11 UD2.U5 ; UD1.N1 165.59,62.51 v5(165.7,62.39) ; CD20.1 120.77,60.49 v5(120.7,60.56) ; v5(115.51,64.78) 115.84,65.11 UD4.F8 ; v5(124.24,62.51) UD3.K1 ; v5(140.42,63.52) 140.22,63.32 CD58.1 141.24,62.97 141.7,62.51 UD2.N12 ; UD3.K12 v5(134.93,62.51) 135.72,61.72 CD38.1 ; UD3.N1 v5(124.37,60.56) ; UD1.A4 v5(162.41,54.07) ; v5(134.93,60.56) 135.46,61.09 CD37.1 ; UD1.F5 161.43,57.96 v5(161.11,58.28) ; UD4.AB4 112.82,54.53 v5(112.55,54.27) ; UD2.A4 v5(148.83,54.19) ; UD1.U5 161.43,65.11 v5(161.11,64.78) ; UD4.K12 120.7,62.51 v5(120.7,62.51) 120.71,62.5 CD21.1
  TOP w0.356: CD55.1 144.84,50.75
  IN1 w0.203: v1(155.76,42.96) 155.43,42.63 v2(155.33,42.63)
  IN1 w0.254: v2(149.21,60.56) v1(149.63,60.56) ; v1(152.1,42.96) v2(152.49,42.96) ; v2(146.91,63.6) 146.7,63.81 v1(145.63,63.81) ; v2(151.23,41.82) 151.25,41.85 v1(151.65,41.85) ; v2(152.12,41.85) v4(152.56,41.85) ; v2(144.03,62.9) v1(144.03,62.51) ; v2(164.5,59.03) 164.73,59.26 v1(164.82,59.26) ; v1(113.62,59.26) v2(114.08,59.26) ; v2(132.07,41.62) 132.31,41.39 v1(132.31,41.39) ; v1(112.02,60.56) 112.02,60.55 v2(111.62,60.15) ; v2(142.16,63.5) 142.17,63.5 142.42,63.76 v1(142.42,63.81) ; v1(130.88,59.26) 130.55,59.26 v2(130.53,59.24) ; v2(109.95,59.47) 110.16,59.26 v1(110.42,59.26) ; v1(110.42,63.81) 110.03,63.81 v2(109.98,63.85) ; v2(118.84,59.49) 119.08,59.26 v1(119.22,59.26) ; v1(131.06,42.31) v2(131.29,42.08) ; v1(148.03,63.81) 147.75,63.81 v2(147.61,63.66) ; v2(142.78,58.96) 142.72,58.96 v1(142.42,59.26) ; v2(115.6,59.26) v1(116.02,59.26) ; v2(146.03,59.33) 145.96,59.26 v1(145.63,59.26) ; v1(113.62,63.81) v2(114.11,63.81) ; v1(132.67,41.57) v2(133,41.57) ; v2(110,62.43) 110.08,62.51 v1(110.42,62.51) ; v1(110.01,61.95) v2(110.01,61.62) ; v2(152.94,41.54) v1(152.94,41.88) ; v1(116.02,63.81) v2(115.54,63.81) ; v1(152.1,42.31) v2(152.43,42.31) ; v1(148.03,59.26) v2(147.61,59.26)
  IN3 w0.254: v2(151.23,41.82) 151.25,41.85 v4(151.66,41.85) ; v4(132.68,41.76) 132.87,41.57 v2(133,41.57) ; v2(152.12,41.85) v4(152.56,41.85) ; v2(132.07,41.62) v4(132.07,41.95) ; v2(155.33,42.63) 155.5,42.46 v4(155.5,42.33) ; v2(152.43,42.31) v4(152.76,42.31) ; v2(152.94,41.54) 152.97,41.54 v4(153.19,41.32) ; v2(131.29,42.08) v4(131.29,42.45) ; v2(152.49,42.96) v4(152.16,42.96)
  vias: v5(105.76,57.95) v5(105.76,57.38) v5(105.94,54.89) v5(105.94,54.33) v5(105.94,53.74) v5(106.33,57.95) v5(106.33,57.38) v5(106.53,54.89) v5(106.53,54.33) v5(106.53,53.74) v5(106.9,57.95) v5(106.9,57.38) v5(107.11,54.89) v5(107.11,54.33) v5(107.11,53.74) v5(151.63,40.99) v5(152.55,40.99) v6(123.29,49.95)
+1.1V_MEMP: length 21.3
  TOP w0.254: PR702.1 92.17,63.35 92.32,63.5 93.01,63.5 93.2,63.69 v1(93.2,64.04)
  IN1 w0.254: v2(102.29,53.29) v1(102.54,53.54) ; v1(93.2,64.04) 93.2,64.03 93.63,63.6 v2(93.63,63.47)
  IN3 w0.254: v2(93.63,63.47) 93.76,63.35 v4(93.76,63.09) ; v2(102.29,53.29) v4(101.91,52.91)
  BOTTOM w0.254: v4(101.91,52.91) 101.42,52.42 96.49,52.42 93.76,55.15 v4(93.76,63.09)
+1.05V_VCCST: length 212.5
  TOP w0.254: v1(104.72,47.14) PR1129.1 PR1127.1 PR1128.1
  TOP w0.356: RH588.2 170.05,19.66 169.69,20.01 169.69,20.9 169.33,21.25 169.33,22.35 v5(169.28,22.41) ; RE477.1 197.41,55.39 v5(197.41,54.33)
  TOP w0.508: v5(146.5,21.23) 146.13,21.59 145.42,21.59 144.94,21.12 144.94,19.63 144.86,19.55 144.86,18.5 144.17,17.82 141.64,17.82 139.8,19.66 RC592.2
  IN1 w0.254: v1(125.95,20.57) 126.18,20.8 v2(126.52,20.8) 127.25,21.52 v1(129.19,21.52)
  IN1 w0.508: v1(104.72,47.14) 104.81,47.06 104.81,46.07 105.14,45.74 105.14,45.16 v2(105.18,45.12)
  IN2 w0.508: v2(105.18,45.12) 105.3,44.99 105.3,34.43 106.33,33.4 106.33,32.17 105.82,31.66 105.65,31.66 105.28,31.28 105.28,25.22 109.38,21.12 v5(110.26,21.12) 110.36,21.22 112.95,21.22 116.64,17.53 119.85,17.53 121.7,19.38 125.1,19.38 v2(126.52,20.8)
  IN3 w0.762: v2(126.52,20.8) 126.6,20.72 v4(127.48,20.72) ; v5(197.41,54.33) 197.41,54.22 195.64,52.45 194.74,52.45 192.84,50.55 192.84,46.29 192.81,46.26 192.81,36.95 191.23,35.37 191.23,33.37 v4(187.14,29.28)
  BOTTOM w0.356: RE147.2 213.1,58.99 212.99,58.88
  BOTTOM w0.508: 167.29,22.17 169.04,22.17 v5(169.28,22.41) 169.95,23.08 ; 212.99,58.88 211.87,57.76 211.87,56.12 211.22,55.47 211.22,55.47 210.81,55.06 209.01,55.06 206.84,57.23 206.2,57.23 204.95,58.49 199.56,58.49 198.99,57.92 198.99,56.63 197.41,55.05 v5(197.41,54.33)
  BOTTOM w0.762: 169.95,23.08 171.17,24.29 v6(171.17,26.38) 171.88,27.1 172.9,27.1 175.43,24.57 176.28,24.57 176.75,24.09 176.75,22.72 180.46,19.02 187.17,19.02 189.75,21.6 192.89,21.6 193.66,22.36 193.66,23.38 192.83,24.2 192.21,24.2 v4(187.14,29.28) ; 167.29,22.17 157.35,22.17 156.42,21.24 150.81,21.24 149.52,22.53 148.33,22.53 148.14,22.34 147.61,22.34 v5(146.5,21.23) 145.99,20.72 v4(127.48,20.72)

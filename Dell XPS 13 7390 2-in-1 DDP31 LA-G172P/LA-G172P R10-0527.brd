# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_CS2#_TPM: length 31.9
  TOP w0.081: U712.20 214.54,8.08 214.77,8.31 214.96,8.31 215.05,8.22 215.05,8.14 215.15,8.04 215.28,8.04 215.38,8.14 v3(215.38,8.22) 215.47,8.31 215.92,8.31 v1(216.24,8.63)
  IN1 w0.064: v1(216.24,8.63) 216.1,8.77 216.1,8.98 216.16,9.04 216.61,9.04 216.69,9.12 216.69,9.42 217.27,10 217.27,12.74 217.36,12.83 217.8,12.83 217.89,12.92 217.89,13.05 217.8,13.15 217.36,13.15 217.27,13.24 217.27,13.36 217.36,13.45 217.8,13.45 217.89,13.54 217.89,13.68 217.8,13.77 217.51,13.77 217.4,13.88 217.4,14.02 217.46,14.09 217.8,14.09 217.89,14.18 217.89,14.31 217.8,14.4 217.46,14.4 217.4,14.47 217.4,14.66 217.46,14.72 217.8,14.72 217.89,14.81 217.89,14.95 217.8,15.04 217.46,15.04 217.4,15.1 217.4,15.29 217.46,15.36 217.8,15.36 217.89,15.45 217.89,15.58 217.8,15.67 217.46,15.67 217.4,15.74 217.4,17.31 217.46,17.37 219.22,17.37 219.28,17.44 219.28,17.61 219.21,17.69 217.84,17.69 217.76,17.76 217.76,17.87 217.84,17.94 219.21,17.94 219.28,18.02 219.28,18.12 219.21,18.2 218.35,18.2 218.27,18.27 218.27,18.38 218.35,18.45 219.21,18.45 219.28,18.52 219.28,18.63 219.21,18.7 218.8,18.7 218.73,18.78 218.73,18.88 218.8,18.96 219.21,18.96 219.28,19.03 219.28,19.24 219.2,19.32 217.81,19.32 217.22,19.91 217.21,19.91 216.4,20.72 215.02,20.72 v2(214.68,20.38)
  IN3 w0.064: v4(214.29,20) v2(214.68,20.38)
PCH_SPI_IO2: length 63.7
  IN1 w0.064: v1(167.91,44.26) 167.91,44.51 v2(168.13,44.74)
  IN2 w0.051: v2(206.09,32.26) 205.99,32.26 203.3,34.95 201.52,34.95 200.81,35.66 195.47,35.66 195.35,35.54 193.76,35.54 193.1,36.19 192.18,36.19 190.09,38.29 189.96,38.29 187.31,40.94 186.68,40.94 186.09,41.54 185.2,41.54 183.91,42.83 182.54,42.83 182.2,43.17 181.21,43.17 179.88,44.5 174.01,44.5 173.24,43.72 171.45,43.72 171.14,44.03 168.76,44.03 168.13,44.66 v2(168.13,44.74)
  IN3 w0.064: v2(206.09,32.26) 206.49,31.86 206.75,31.86 207.04,32.15 209.15,32.15 211.09,30.21 211.09,28.76 212.84,27.01 213.85,27.01 214.32,26.54 v4(214.43,26.54)
  IN3 w0.081: v2(168.13,44.74) 167.8,44.74 v4(167.74,44.8)
  BOTTOM w0.081: RH141.1 RH142.1 168.4,44.37 RH634.2 168.2,44.36 167.88,44.69 167.85,44.69 v4(167.74,44.8) ; RH722.2 213.9,24.92 214.13,25.14 214.13,26.24 v4(214.43,26.54)
PCH_SPI_IO2_R: length 1.1
  BOTTOM w0.081: RH26.2 213.65,20.76 213.9,21.02 RH722.1
PCH_SPI_IO3: length 64.3
  TOP w0.089: UC1.DD41 v1(167.54,42.9)
  IN1 w0.064: v2(167.24,43.32) 167.24,43.21 v1(167.54,42.9)
  IN2 w0.051: v2(167.24,43.32) 167.32,43.32 167.67,43.66 168.26,43.66 168.45,43.47 170.84,43.47 171.27,43.04 178.5,43.04 178.62,43.17 179.43,43.17 180.29,42.3 181.84,42.3 182.18,41.97 183.54,41.97 185.67,39.84 186.56,39.84 189.05,37.35 189.8,37.35 192.01,35.14 192.93,35.14 193.98,34.09 202.94,34.09 205.64,31.39 208.05,31.39 v2(208.22,31.57)
  IN3 w0.064: v4(167.74,42.33) 167.74,42.82 v2(167.24,43.32) ; v2(208.22,31.57) 208.59,31.2 209.56,31.2 210.71,30.05 210.71,28.6 212.8,26.52 v4(213.65,26.52)
  BOTTOM w0.081: RH635.1 RH636.1 166.75,42.81 167.23,42.33 v3(167.35,42.33) v4(167.74,42.33) ; RH723.2 212.63,22.17 212.63,25.5 v4(213.65,26.52)
PCH_SPI_IO3_R: length 42.7
  IN2 w0.051: v2(186.8,42.05) 187.17,41.68 187.6,41.68 190.26,39.01 190.37,39.01 192.48,36.9 195,36.9 195.53,36.37 197.87,36.37 198.49,36.99 202.89,36.99 207.99,31.9 209.15,31.9 214.78,26.27 v2(214.78,22.69)
  IN3 w0.064: v4(186.43,41.51) 186.8,41.89 v2(186.8,42.05) ; v2(214.78,22.69) 213.86,22.69 v4(212.69,21.52)
  BOTTOM w0.081: v4(212.69,21.52) RH27.2
PCH_SPI_SI: length 64.9
  IN1 w0.064: v2(167.35,45.01) 167.25,44.91 v1(166.99,44.91)
  IN2 w0.051: v2(205.85,33.13) 205.85,33.34 202.55,36.64 198.64,36.64 198.02,36.02 195.39,36.02 194.85,36.55 192.33,36.55 190.23,38.64 190.11,38.64 187.43,41.32 186.81,41.32 186.22,41.91 185.33,41.91 184.04,43.2 182.67,43.2 182.34,43.53 181.36,43.53 179.98,44.92 172.78,44.92 172.73,44.97 171.01,44.97 170.63,45.35 168.43,45.35 168.22,45.57 167.86,45.57 167.35,45.05 v2(167.35,45.01)
  IN3 w0.064: v2(205.85,33.13) 205.85,33.02 206.28,32.59 209.26,32.59 211.47,30.37 211.47,28.92 212.99,27.41 214.31,27.41 215.18,26.53 v4(215.18,26.34)
  IN3 w0.081: v4(167.1,45.27) 167.35,45.03 v2(167.35,45.01)
  BOTTOM w0.081: v4(215.18,26.34) 215.93,25.59 RH720.2 ; RH641.1 v4(167.1,45.27) RH643.1
PCH_SPI_SI_R: length 45.6
  IN2 w0.051: v2(217.33,22.64) 216.82,23.16 216.82,27.08 212.74,31.15 212.59,31.15 212.59,31.15 212.16,31.15 209.83,33.48 208.64,33.48 203.2,38.91 197.02,38.91 196.3,39.63 192.2,39.63 191.08,40.74 190.98,40.74 187.72,44 v2(187.34,44)
  IN3 w0.064: v2(217.33,22.64) 217.33,22.45 216.82,21.94 216.35,21.94 v4(215.93,21.52) ; v4(187,44.01) 187.33,44.01 v2(187.34,44)
  BOTTOM w0.081: JSPI1.2 v4(187,44.01) ; RH23.2 R700.1 216.08,21.37 v4(215.93,21.52)
PCH_SPI_SI_TPM: length 38.8
  TOP w0.081: U712.21 v1(215.79,8.58)
  IN1 w0.064: v1(215.79,8.58) 215.79,11.12 215.86,11.19 216.05,11.19 216.12,11.11 216.12,9.85 216.21,9.77 216.43,9.77 216.51,9.84 216.51,13.56 216.57,13.63 216.7,13.63 216.76,13.56 216.76,10.07 216.83,9.99 216.97,9.99 217.08,10.1 217.08,13.5 217.21,13.63 217.21,17.58 218.5,18.87 218.5,18.96 218.33,19.13 218.24,19.13 217.14,18.03 217.05,18.03 216.94,18.14 216.94,18.23 217.71,19 217.71,19.09 217.61,19.19 217.52,19.19 216.76,18.43 216.65,18.43 216.56,18.51 216.56,18.62 217.35,19.4 217.35,19.51 217.27,19.58 217.17,19.58 216.38,18.8 216.28,18.8 216.2,18.87 216.2,18.98 216.99,19.76 216.99,19.87 216.91,19.94 216.81,19.94 216.02,19.16 215.92,19.16 215.84,19.23 215.84,19.34 216.43,19.93 216.43,20.03 216.36,20.11 216.25,20.11 215.54,19.39 215.45,19.39 215.18,19.67 215.18,19.76 215.46,20.05 215.76,20.05 v2(216.08,20.37)
  IN3 w0.064: v4(216.08,19.99) v2(216.08,20.37)
PCH_SPI_SO: length 62.7
  TOP w0.089: v1(167.64,44.68) 167.68,44.68 UC1.DF43
  IN1 w0.064: v1(167.64,44.68) 168.02,45.07 v2(168.02,45.23)
  IN2 w0.051: v2(168.02,45.23) 168.06,45.19 170.52,45.19 170.78,44.93 170.78,44.59 171.48,43.89 172.88,43.89 173.72,44.73 179.9,44.73 181.29,43.34 182.28,43.34 182.61,43.01 183.98,43.01 185.27,41.72 186.16,41.72 186.76,41.12 187.38,41.12 190.04,38.47 190.16,38.47 192.25,36.37 193.17,36.37 193.83,35.72 195.28,35.72 195.4,35.84 198.09,35.84 198.71,36.46 201.01,36.46 201.78,35.69 202.82,35.69 205.9,32.6 206.29,32.6 v2(206.65,32.24)
  IN3 w0.064: v2(206.65,32.24) 206.8,32.4 209.18,32.4 211.28,30.29 211.28,28.84 212.91,27.21 214.23,27.21 214.8,26.64 214.8,26.15 v4(215.17,25.78)
  BOTTOM w0.081: RH721.2 v4(215.17,25.78)
PCH_SPI_SO_R: length 45.4
  IN2 w0.051: v2(216.64,22.33) 216.64,27 212.67,30.97 212.08,30.97 209.76,33.3 208.57,33.3 203.13,38.73 196.83,38.73 196.38,39.18 195.22,39.18 194.95,38.92 192.66,38.92 191.01,40.56 190.9,40.56 188.02,43.45 v2(187.34,43.45)
  IN3 w0.064: v2(216.64,22.33) 216.12,22.33 215.35,21.55 215.2,21.55 215.18,21.52 v4(215.17,21.52) ; v4(186.43,43.51) 187.02,43.51 187.09,43.45 v2(187.34,43.45)
  BOTTOM w0.081: R701.1 RH25.2 214.92,21.27 v4(215.17,21.52)
PCH_SPI_SO_TPM: length 39.3
  TOP w0.081: v1(215.23,12.68) v3(215.23,12.29) 215.23,11.9 215.15,11.82 213.78,11.82 213.68,11.73 213.68,11.59 213.78,11.5 214.55,11.5 214.65,11.4 214.65,11.27 214.55,11.17 213.78,11.17 213.68,11.08 213.68,10.94 213.78,10.85 214.55,10.85 214.65,10.75 214.65,10.25 214.48,10.08 U712.24
  IN1 w0.064: v1(215.23,12.68) 214.9,13.01 214.9,13.1 215.46,13.66 215.73,13.66 215.8,13.74 215.8,14.01 215.86,14.07 215.99,14.07 216.05,14.01 216.05,13.63 216.12,13.56 216.25,13.56 216.31,13.63 216.31,14.51 216.41,14.62 216.5,14.62 216.56,14.55 216.56,13.88 216.63,13.82 216.95,13.82 217.02,13.88 217.02,17.79 215.68,19.13 215.44,19.13 215.1,19.47 214.82,19.47 214.75,19.55 214.75,19.66 214.68,19.73 214.57,19.73 214.5,19.66 214.5,19.21 214.42,19.13 214.32,19.13 214.24,19.21 214.24,19.88 214.17,19.95 214.05,19.95 213.99,19.89 213.99,19.2 213.92,19.13 213.81,19.13 213.74,19.21 213.74,21.56 213.67,21.63 213.54,21.63 213.48,21.56 213.48,19.19 213.42,19.13 213.33,19.13 213.25,19.21 213.25,19.9 213.19,19.96 213.05,19.96 212.97,19.89 212.97,19.22 212.9,19.15 212.79,19.15 212.72,19.22 212.72,19.9 212.65,19.96 212.54,19.96 212.46,19.89 212.46,19.68 212.4,19.62 212.25,19.62 212.14,19.74 212.14,20.24 212.21,20.32 213.08,20.32 213.14,20.38 213.14,21.95 213.2,22.01 213.88,22.01 214,21.89 214,20.49 214.45,20.05 215.16,20.05 v2(215.5,20.38)
  IN3 w0.064: v4(215.5,19.99) v2(215.5,20.38)
PCH_TBT_PERST#: length 381.1
  IN1 w0.064: v2(103.92,4.55) v2(103.92,3.34) ; v1(5.93,49.05) v2(6.42,49.05)
  IN1 w0.089: v2(172.31,33.88) 172.24,33.88 v1(171.98,34.14)
  IN2 w0.051: v2(208.87,29.91) 209.57,29.91 211.82,27.66 211.82,25.17 213.3,23.68 213.3,19.99 215.81,17.48 216.25,17.48 217,16.74 217,15.52 218.79,13.73 222.49,13.73 229.49,6.73 231.33,6.73 231.65,7.05 232.31,7.05 233.69,8.43 247.21,8.43 248.8,10.02 248.8,10.54 250.06,11.81 262.08,11.81 264.12,13.85 265.86,13.85 268.59,16.59 268.59,20.61 270.19,22.22 270.19,24.51 273.7,28.01 273.7,33.05 v5(273.94,33.29) ; v2(103.92,3.34) 104.19,3.61 106.61,3.61 107.02,3.19 109.24,3.19 109.79,3.74 110.86,3.74 111.23,3.36 119.23,3.36 119.99,4.11 122.17,4.11 122.75,3.53 126.88,3.53 128.65,5.31 138.72,5.31 141.22,7.8 144,7.8 145.23,6.58 170.15,6.58 170.81,7.23 170.81,13.42 169.26,14.97 169.26,19.77 172.42,22.93 174.85,22.93 175.43,23.51 v2(175.43,26.7) ; v2(6.42,49.05) 6.65,49.27 8.28,49.27 9.3,48.25 9.3,44.37 10.99,42.68 10.99,41.91 11.4,41.5 14.99,41.5 16.07,40.42 16.07,38.17 13.62,35.72 13.62,22.54 17.8,18.36 17.8,17.49 17.8,17.11 23.36,11.55 30.51,11.55 31.2,10.86 75.55,10.86 78.16,8.24 78.16,6.73 80.24,4.66 90.04,4.66 90.38,4.32 91.09,4.32 91.43,4.66 103.8,4.66 v2(103.92,4.55)
  IN3 w0.064: v2(208.87,29.91) 207.5,29.91 207.44,29.86 207.44,29.69 207.15,29.39 205.88,29.39 205.33,29.95 192.8,29.95 190.14,27.28 186.73,27.28 186.12,26.67 185.15,26.67 184.02,27.8 179.75,27.8 179.49,28.06 178.23,28.06 178.02,27.85 176.63,27.85 176.25,27.47 v4(176.05,27.47) 176.05,27.44 175.43,26.82 v2(175.43,26.7) ; v4(172.94,34.21) 172.64,34.21 v2(172.31,33.88)
  BOTTOM w0.081: v4(172.94,34.21) RH713.2 ; RH713.2 174.45,34.21 174.53,34.13 174.53,32.1 v3(174.91,31.72) 174.91,28.61 v4(176.05,27.47) ; RH713.2 RH646.2 ; v5(273.94,33.29) 274.16,33.29 274.58,33.71 274.58,36.33 274.29,36.61 274.29,37.73 RT62.2
PCH_TOUCHPAD_INTR#: length 114.8
  TOP w0.081: JIO1.29 252.05,6.47 251.49,7.03 249.37,7.03 248.67,7.72 243.36,7.72 v1(242.03,9.05)
  IN1 w0.064: v1(242.03,9.05) 241.6,9.48 239.09,9.48 v2(238.92,9.31) ; v2(180.69,41.23) 180.13,41.23 179.44,41.92 173.2,41.92 172.65,41.37 171.76,41.37 171.43,41.7 167.22,41.7 166.91,42 163.05,42 162.74,42.31 v1(162.42,42.31)
  IN2 w0.051: v2(238.92,9.31) 233.92,9.31 232.12,7.5 231.46,7.5 231.14,7.19 229.68,7.19 222.65,14.21 219.05,14.21 217.55,15.72 217.55,17.43 215.02,19.96 215.02,20.53 214.79,20.76 214.79,21.28 213.96,22.11 213.96,26.45 209.53,30.89 205.42,30.89 202.73,33.58 193.77,33.58 192.72,34.63 191.8,34.63 190.14,36.29 189.39,36.29 186.35,39.33 185.46,39.33 183.65,41.13 180.78,41.13 v2(180.69,41.23)
  IN3 w0.064: v2(180.69,41.23) 179.88,41.23 v4(179.74,41.38)
  BOTTOM w0.081: RH631.2 180.69,41.38 180.44,41.12 v3(180.18,41.12) 179.99,41.12 v4(179.74,41.38)
PCIE_PRX_C_DTX_N3: length 3.9
  IN1 w0.081: v1(184.77,57.02) 184.92,56.87 184.92,56.36 184.85,56.28 184.85,53.6 184.76,53.52 v1(184.5,53.52)
PCIE_PRX_C_DTX_N9: length 6.4
  TOP w0.076: 193.26,41.69 193.28,41.69 193.29,41.7 194.96,41.7 195.1,41.56 196.54,41.56 196.82,41.83 196.82,42 196.9,42.07 USSD1.H5
  TOP w0.091: CS4.2 191.45,41.3 192.3,41.3 192.69,41.69 193.26,41.69
PCIE_PRX_C_DTX_N10: length 6.4
  TOP w0.076: 193.26,38.77 193.28,38.77 193.29,38.76 195.22,38.76 195.85,39.39 196.61,39.39 196.86,39.13 196.86,39.02 197.01,38.87 USSD1.M5
  TOP w0.091: 193.26,38.77 191.46,38.77 CS8.2
PCIE_PRX_C_DTX_N11: length 6.4
  TOP w0.076: USSD1.T5 197.04,35.67 196.87,35.84 196.87,35.91 196.61,36.17 195.54,36.17 195.09,35.72 194.09,35.72 193.88,35.93 193.29,35.93 193.28,35.94 193.26,35.94
  TOP w0.091: CS21.2 191.5,35.94 193.26,35.94
PCIE_PRX_C_DTX_N12: length 7.9
  TOP w0.076: USSD1.Y5 196.95,32.62 196.95,32.73 196.7,32.98 195.78,32.98 195.09,32.29 193.84,32.29 193.42,32.71 193.42,32.72 193.41,32.73
  TOP w0.091: 193.41,32.73 192.31,33.83 191.11,33.83 190.9,33.62 190.9,33.47 CS17.2
PCIE_PRX_C_DTX_N16: length 2
  TOP w0.091: UCR1.8 277.47,25.24 277.37,25.34 277.24,25.34 277.15,25.25 277.15,25.01 276.94,24.8 276.61,24.8 CR4.2
PCIE_PRX_C_DTX_P3: length 3.9
  IN1 w0.081: v1(185.39,53.52) 185.12,53.52 185.04,53.6 185.04,56.2 185.12,56.28 185.12,56.87 v1(185.27,57.02)
PCIE_PRX_C_DTX_P9: length 6.4
  TOP w0.076: USSD1.H4 196.42,42.19 196.55,42.19 196.63,42.12 196.63,41.91 196.46,41.75 195.18,41.75 195.04,41.88 193.29,41.88 193.28,41.89 193.26,41.89
  TOP w0.091: 193.26,41.89 192.6,41.89 192.21,41.5 191.52,41.5 CS3.2
PCIE_PRX_C_DTX_P10: length 6.4
  TOP w0.076: 193.26,38.57 193.28,38.57 193.29,38.58 195.3,38.58 195.92,39.2 196.53,39.2 196.67,39.05 196.67,38.95 196.56,38.84 196.34,38.84 USSD1.M4
  TOP w0.091: CS7.2 191.51,38.57 193.26,38.57
PCIE_PRX_C_DTX_P11: length 6.4
  TOP w0.076: 193.26,35.74 193.28,35.74 193.27,35.74 193.8,35.74 194.01,35.53 195.17,35.53 195.62,35.98 196.53,35.98 196.68,35.83 196.68,35.67 196.6,35.6 196.37,35.6 USSD1.T4
  TOP w0.091: 193.26,35.74 191.47,35.74 CS20.2
PCIE_PRX_C_DTX_P12: length 7.9
  TOP w0.076: USSD1.Y4 196.5,32.27 196.69,32.27 196.77,32.35 196.77,32.65 196.62,32.8 195.86,32.8 195.17,32.1 193.76,32.1 193.29,32.58 193.28,32.58 193.26,32.59
  TOP w0.091: 193.26,32.59 192.22,33.63 191.2,33.63 191.1,33.54 191.1,33.41 CS16.2
PCIE_PRX_C_DTX_P16: length 2
  TOP w0.091: UCR1.7 277.48,25.64 277.38,25.54 277.15,25.54 276.94,25.33 276.94,25.1 276.85,25 276.6,25 CR3.2
PCIE_PRX_DTX_N3: length 38.7
  TOP w0.091: v5(184.47,50.88) 184.56,50.98 184.56,51.66 184.75,51.85 184.75,52.35 CH1.1
  IN1 w0.089: v1(167.66,27.53) 167.4,27.79 v2(167.36,27.79)
  IN3 w0.081: v5(184.47,50.88) 184.47,50.87 184.56,50.77 184.56,49.73 186.42,47.87 186.42,46.08 184.35,44.01 184.35,37.68 178.4,31.73 171.83,31.73 170.66,30.56 169.41,30.56 167.41,28.55 167.38,28.27 167.44,28.16 v2(167.36,27.79)
PCIE_PRX_DTX_N9: length 51.2
  TOP w0.089: UC1.CP7 162.17,27.39 162.34,27.22 162.47,27.22 162.65,27.4 162.65,27.53 162.35,27.83 v1(162.32,27.83)
  IN1 w0.081: v1(162.32,27.83) 162.22,27.93 162.22,28.11 162.36,28.25 164.33,28.25 167.56,25.01 167.56,22.76 168.51,21.81 177.73,21.81 178.46,21.08 184.23,21.08 186.1,22.95 187.43,26.15 187.43,38.27 190,40.84 190,41.16 190.21,41.37 190.6,41.37 190.68,41.29 v1(190.68,41.12)
PCIE_PRX_DTX_N10: length 50
  IN1 w0.081: v1(190.68,38.96) 190.47,38.74 189.93,38.74 188.4,37.21 188.4,25.96 186.92,22.4 184.64,20.11 178.06,20.11 177.33,20.84 168.11,20.84 166.59,22.36 166.59,24.23 165.64,25.18 165.64,26.58 164.69,27.53 161.64,27.53 161.41,27.31 161.33,27.31 161.25,27.39 v1(161.25,27.53)
PCIE_PRX_DTX_N11: length 51.6
  IN1 w0.081: v1(190.68,36.17) 190.68,36.02 190.6,35.94 189.92,35.94 189.57,35.58 189.57,25.66 187.96,21.78 187.68,21.5 187.68,21.5 185.12,18.94 177.57,18.94 176.84,19.67 167.62,19.67 165.42,21.87 165.42,23.83 164.94,24.31 164.94,24.88 165.27,25.21 165.27,26.43 164.54,27.16 161.88,27.16 161.3,26.59 160.96,26.59 160.88,26.67 160.88,27.11 160.68,27.31 160.42,27.31 160.34,27.39 v1(160.34,27.53)
PCIE_PRX_DTX_N12: length 53.3
  IN1 w0.081: v1(159.42,26.88) 159.48,26.88 159.56,26.96 159.56,27.04 159.49,27.11 159.49,27.21 159.41,27.29 159.17,27.29 159.09,27.21 159.09,26.35 159,26.26 159,25.79 159.29,25.5 160.24,25.5 160.42,25.68 160.42,25.82 160.3,25.94 160.3,26.05 160.42,26.17 160.53,26.17 160.65,26.05 160.79,26.05 160.96,26.22 161.61,26.22 162.19,26.8 163.5,26.8 163.8,26.5 163.8,23.8 164.26,23.34 164.26,21.39 167.01,18.64 167.19,18.45 176.41,18.45 177.09,17.78 185.61,17.78 188.97,21.13 190.89,25.77 190.89,32.47 v1(190.68,32.67)
PCIE_PRX_DTX_N13: length 64.7
  IN1 w0.081: v1(158.51,27.53) 158.36,27.39 158.17,27.39 157.95,27.17 157.95,26.64 158.04,26.55 158.04,25.64 159.06,24.62 159.06,23.84 159.46,23.44 159.46,19.9 159.9,19.46 161.09,19.46 162.45,18.1 163.57,18.1 166.72,14.95 172.64,14.95 174.22,13.36 202.54,13.36 204.13,14.95 208.14,14.95 208.37,15.18 208.37,15.6 v5(208.56,15.78)
  BOTTOM w0.091: v5(208.56,15.78) 208.49,15.72 208.49,15.07 208.64,14.92 JNGFF1.33
PCIE_PRX_DTX_N14: length 71
  IN1 w0.081: v5(211.91,16.2) 211.71,16 211.39,16 211.15,15.76 211.15,14.9 210.81,14.57 204.36,14.57 202.77,12.98 174.06,12.98 172.54,14.5 166.62,14.5 163.41,17.71 162.29,17.71 160.93,19.07 159.74,19.07 159.07,19.74 159.07,23.28 158.68,23.68 158.68,24.46 156.89,26.25 156.89,26.82 157.15,27.08 157.39,27.08 v1(157.59,26.88)
  BOTTOM w0.091: v5(211.91,16.2) 212.29,15.82 212.41,15.82 212.62,15.61 212.62,15.08 211.9,14.36 211.46,14.36 211.35,14.25 211.35,13.96 211.64,13.66 JNGFF1.21
PCIE_PRX_DTX_N16: length 135.7
  TOP w0.091: v5(274.16,24.28) 274.49,24.61 274.8,24.61 274.97,24.79 275.65,24.79 275.83,24.61 CR4.1
  IN1 w0.081: v2(158.17,20.75) 158.17,20.7 157.96,20.49 157.84,20.49 157.69,20.64 157.69,21.05 158.49,21.85 158.49,23.04 158.02,23.51 158.02,24.29 156.31,26.01 156.31,26.39 156.11,26.59 155.91,26.59 155.76,26.74 v1(155.76,26.88)
  IN3 w0.081: v2(158.17,20.75) 158.51,20.41 159.11,20.41 160.13,19.39 166.7,19.39 166.97,19.66 173.92,19.66 176.03,17.55 224.8,17.55 226.02,16.33 263.85,16.33 264.95,17.44 267.81,17.44 273.4,23.02 274.99,23.02 275.3,23.33 275.3,23.99 275.68,24.37 275.68,24.59 275.6,24.67 274.55,24.67 v5(274.16,24.28)
PCIE_PRX_DTX_P3: length 38.8
  TOP w0.091: CH2.1 184.96,52.17 184.96,51.77 184.77,51.58 184.77,51.16 185.04,50.88 v5(185.05,50.88)
  IN1 w0.089: v1(167.66,28.18) v2(167.99,28.18)
  IN3 w0.081: v2(167.99,28.18) 167.61,28.27 167.58,28.32 167.6,28.46 169.5,30.36 170.74,30.36 171.91,31.53 178.48,31.53 184.55,37.6 184.55,43.93 186.62,46 186.62,47.95 184.76,49.81 184.76,50.59 v5(185.05,50.88)
PCIE_PRX_DTX_P9: length 51.1
  TOP w0.091: UC1.CP6 161.88,27.17 161.88,27.81 v1(161.94,27.88)
  IN1 w0.081: v1(161.94,27.88) 162.02,27.95 162.02,28.19 162.27,28.45 164.41,28.45 167.76,25.09 167.76,22.84 168.59,22.01 177.81,22.01 178.54,21.28 184.15,21.28 185.93,23.06 187.23,26.19 187.23,38.35 189.8,40.92 189.8,41.24 190.13,41.57 190.5,41.57 v1(190.68,41.76)
PCIE_PRX_DTX_P10: length 50
  IN1 w0.081: v1(190.68,38.33) 190.47,38.55 190.01,38.55 188.59,37.13 188.59,25.92 187.09,22.29 184.72,19.91 177.97,19.91 177.24,20.64 168.03,20.64 166.39,22.27 166.39,24.15 165.44,25.1 165.44,26.5 164.61,27.33 161.72,27.33 161.5,27.11 161.33,27.11 161.25,27.02 v1(161.25,26.88)
PCIE_PRX_DTX_P11: length 51.5
  IN1 w0.081: v1(160.34,26.88) 160.34,27.03 160.42,27.11 160.6,27.11 160.68,27.03 160.68,26.59 160.88,26.39 161.38,26.39 161.96,26.97 164.45,26.97 165.07,26.34 165.07,25.29 164.74,24.96 164.74,24.23 165.23,23.74 165.23,21.79 167.54,19.48 176.76,19.48 177.49,18.75 185.21,18.75 187.82,21.36 187.82,21.36 188.13,21.67 189.76,25.62 189.76,35.5 190.01,35.74 190.48,35.74 v1(190.68,35.53)
PCIE_PRX_DTX_P12: length 53.3
  IN1 w0.081: v1(159.42,27.53) 159.42,27.53 159.09,27.53 158.89,27.33 158.89,26.44 158.8,26.34 158.8,25.71 159.21,25.3 160.33,25.3 161.04,26.02 161.69,26.02 162.27,26.6 163.42,26.6 163.6,26.42 163.6,23.72 164.06,23.26 164.06,21.31 166.87,18.5 166.87,18.5 167.11,18.25 176.33,18.25 177,17.58 185.69,17.58 189.14,21.02 191.08,25.73 191.08,32.5 v1(191.26,32.67)
PCIE_PRX_DTX_P13: length 64.7
  IN1 w0.081: v1(158.51,26.88) 158.51,27.11 158.42,27.19 158.25,27.19 158.15,27.09 158.15,26.72 158.24,26.63 158.24,25.73 159.26,24.7 159.26,23.92 159.65,23.53 159.65,19.99 159.98,19.66 161.17,19.66 162.54,18.3 163.65,18.3 166.8,15.15 172.72,15.15 174.31,13.56 202.46,13.56 204.05,15.15 208.06,15.15 208.17,15.27 208.17,15.67 208.06,15.78 v5(207.97,15.78)
  BOTTOM w0.091: JNGFF1.35 208.14,13.69 208.21,13.75 208.36,13.75 208.44,13.83 208.44,14.83 208.29,14.98 208.29,15.25 208.2,15.34 207.87,15.34 207.78,15.43 207.78,15.59 v5(207.97,15.78)
PCIE_PRX_DTX_P14: length 71.1
  IN1 w0.081: v5(211.91,15.62) 211.72,15.81 211.47,15.81 211.35,15.68 211.35,14.82 210.9,14.37 204.45,14.37 202.86,12.78 173.98,12.78 172.46,14.3 166.54,14.3 163.33,17.51 162.21,17.51 160.85,18.88 159.66,18.88 158.87,19.66 158.87,23.2 158.48,23.6 158.48,24.38 156.69,26.17 156.69,26.9 157.07,27.28 157.34,27.28 v1(157.59,27.53)
  BOTTOM w0.091: JNGFF1.23 211.14,14.33 211.38,14.56 211.82,14.56 212.42,15.16 212.42,15.52 212.33,15.62 v5(211.91,15.62)
PCIE_PRX_DTX_P16: length 135.7
  TOP w0.091: v5(274.16,24.87) 274.21,24.81 274.41,24.81 274.71,24.81 274.89,24.99 275.64,24.99 275.83,25.18 CR3.1
  IN1 w0.081: v2(158.17,20.21) 158.09,20.29 157.76,20.29 157.49,20.56 157.49,21.13 158.29,21.93 158.29,22.96 157.82,23.42 157.82,24.21 156.11,25.92 156.11,26.31 156.03,26.39 155.84,26.39 155.76,26.31 v1(155.76,26.23)
  IN3 w0.081: v2(158.17,20.21) 159.03,20.21 160.05,19.19 166.79,19.19 167.06,19.46 173.83,19.46 175.94,17.35 224.72,17.35 225.94,16.13 263.93,16.13 265.04,17.24 267.89,17.24 273.48,22.83 275.07,22.83 275.5,23.25 275.5,23.9 275.88,24.29 275.88,24.53 275.88,24.67 275.68,24.87 v5(274.16,24.87)
PCIE_PTX_C_DRX_N3: length 4
  IN1 w0.081: v1(186.41,53.52) 186.67,53.52 186.75,53.6 186.75,55.13 186.43,55.45 186.43,56.87 v1(186.27,57.02)
PCIE_PTX_C_DRX_N9: length 6.8
  TOP w0.076: USSD1.F5 196.94,43.67 196.88,43.73 196.88,43.95 196.64,44.19 195.64,44.19 195.61,44.15 195.59,44.15 195.55,44.11 195.54,44.11 195.53,44.1
  TOP w0.091: 195.53,44.1 194.8,43.37 192.46,43.37 192.03,42.94 191.49,42.94 CS2.2
PCIE_PTX_C_DRX_N10: length 6.2
  TOP w0.076: USSD1.K5 197.02,40.47 196.84,40.29 196.84,40.19 196.61,39.96 193.29,39.96 193.28,39.95 193.26,39.95
  TOP w0.091: 193.26,39.95 192.98,39.95 192.76,39.72 CS6.2
PCIE_PTX_C_DRX_N11: length 6.6
  TOP w0.076: USSD1.P5 196.99,37.27 196.88,37.37 196.88,37.54 196.67,37.75 195.73,37.75 195.28,37.3 193.29,37.3 193.28,37.31 193.26,37.31
  TOP w0.091: 193.26,37.31 192.98,37.31 192.8,37.13 191.7,37.13 CS23.2
PCIE_PTX_C_DRX_N12: length 6.6
  TOP w0.076: 193.26,34.25 193.27,34.24 193.95,33.57 196.61,33.57 196.88,33.84 196.88,33.94 197.01,34.07 USSD1.V5
  TOP w0.091: CS19.2 191.27,34.27 191.49,34.48 193.03,34.48 193.26,34.25
PCIE_PTX_C_DRX_N13: length 2
  BOTTOM w0.091: CS25.2 206.99,14.36 206.99,13.85 207.14,13.7 JNGFF1.39
PCIE_PTX_C_DRX_N14: length 2
  BOTTOM w0.091: CS26.2 210,14.45 210,13.84 210.14,13.7 JNGFF1.27
PCIE_PTX_C_DRX_N16: length 2.1
  TOP w0.091: CR2.2 276.61,27.66 276.73,27.66 276.94,27.45 276.94,27.15 277.15,26.94 277.36,26.94 277.45,26.84 UCR1.4
PCIE_PTX_C_DRX_P3: length 4
  IN1 w0.081: v1(187.29,53.52) 187.03,53.52 186.95,53.6 186.95,55.21 186.62,55.53 186.62,56.87 v1(186.77,57.02)
PCIE_PTX_C_DRX_P9: length 6.7
  TOP w0.076: 195.68,43.95 195.72,44 196.56,44 196.69,43.87 196.69,43.67 196.62,43.59 196.38,43.59 USSD1.F4
  TOP w0.091: CS1.2 191.49,42.73 192.12,42.73 192.55,43.17 194.89,43.17 195.68,43.95
PCIE_PTX_C_DRX_P10: length 6.2
  TOP w0.076: USSD1.K4 196.58,40.47 196.65,40.4 196.65,40.27 196.53,40.14 193.29,40.14 193.28,40.15 193.26,40.15
  TOP w0.091: 193.26,40.15 192.9,40.15 192.67,39.93 191.7,39.93 CS5.2
PCIE_PTX_C_DRX_P11: length 6.5
  TOP w0.076: USSD1.P4 196.3,37.21 196.38,37.13 196.62,37.13 196.7,37.21 196.7,37.46 196.59,37.57 195.8,37.57 195.35,37.12 193.29,37.12 193.28,37.11 193.26,37.11
  TOP w0.091: CS22.2 192.88,36.93 193.06,37.11 193.26,37.11
PCIE_PTX_C_DRX_P12: length 6.6
  TOP w0.076: USSD1.V4 196.42,34.19 196.62,34.19 196.69,34.11 196.69,33.92 196.53,33.76 194.03,33.76 193.46,34.32 193.46,34.33 193.42,34.38 193.42,34.39 193.26,34.54
  TOP w0.091: 193.26,34.54 193.12,34.69 191.48,34.69 CS18.2
PCIE_PTX_C_DRX_P13: length 2
  BOTTOM w0.091: JNGFF1.41 206.64,13.7 206.79,13.85 206.79,14.54 CS24.2
PCIE_PTX_C_DRX_P14: length 2
  BOTTOM w0.091: JNGFF1.29 209.64,13.7 209.8,13.86 209.8,14.45 CS27.2
PCIE_PTX_C_DRX_P16: length 2.1
  TOP w0.091: UCR1.3 277.49,27.24 277.39,27.14 277.24,27.14 277.15,27.24 277.15,27.53 276.82,27.86 276.6,27.86 CR1.2
PCIE_PTX_DRX_N3: length 40.8
  TOP w0.089: UC1.DF3 168.25,25.63 v1(168.05,25.82)
  TOP w0.091: v5(185.84,50.88) 186.01,51.06 186.01,51.52 186.55,52.05 186.7,52.05 186.79,52.14 186.79,52.22 CH3.1
  IN1 w0.081: v2(167.69,27.08) 167.92,26.85 167.92,26.43 168.24,26.12 168.24,26 v1(168.05,25.82)
  IN3 w0.081: v2(167.69,27.08) 167.86,27.25 167.86,27.52 168.17,27.84 168.33,27.94 168.35,28.02 169.9,29.57 170.56,29.57 172.13,31.14 178.52,31.14 178.63,31.14 184.93,37.44 184.93,43.73 187.01,45.8 187.01,48.11 186.98,48.14 186.98,48.17 186.23,48.92 186.23,48.95 186.02,49.16 186.02,50.7 v5(185.84,50.88)
PCIE_PTX_DRX_N9: length 43.7
  TOP w0.091: v1(168.11,23.63) 166.47,23.63 166.09,24.02 166.09,24.3 165.77,24.61 UC1.DA2
  IN1 w0.081: v1(168.11,23.63) 168.22,23.52 169.01,23.52 169.9,22.63 178.02,22.63 178.78,21.87 183.91,21.87 185.44,23.39 186.64,26.31 186.64,38.59 189.21,41.16 189.21,41.48 189.27,41.53 189.27,42.1 190.06,42.9 190.32,42.9 190.41,42.99 190.53,42.99 190.55,43.02 v1(190.68,43.15)
PCIE_PTX_DRX_N10: length 45.1
  TOP w0.089: UC1.CY3 v1(166.08,25.18)
  IN1 w0.081: v1(166.08,25.18) 166.08,25.36 166.16,25.44 166.28,25.44 166.98,24.73 166.98,22.52 168.27,21.23 177.49,21.23 178.22,20.5 184.48,20.5 186.6,22.62 188.01,26.03 188.01,38.02 189.94,39.94 190.47,39.94 v1(190.68,39.72)
PCIE_PTX_DRX_N11: length 44.4
  TOP w0.089: UC1.CW2 164.71,24.79 v1(165.2,24.79)
  IN1 w0.081: v1(165.2,24.79) 165.31,24.67 165.51,24.67 166.01,24.18 166.01,22.11 167.87,20.26 177.08,20.26 177.81,19.53 184.88,19.53 187.42,22.07 188.98,25.84 188.98,36.97 189.4,37.38 190.5,37.38 v1(190.68,37.57)
PCIE_PTX_DRX_N12: length 46.3
  TOP w0.091: UC1.CW5 164.66,26.14 164.66,26 164.57,25.91 164.41,25.91 v1(164.31,26)
  IN1 w0.081: v1(190.68,34.26) 190.65,34.26 190.57,34.34 190.57,34.46 190.65,34.55 190.9,34.55 190.98,34.46 190.98,33.68 190.56,33.26 190.44,33.26 190.15,32.96 190.15,25.53 188.46,21.45 185.37,18.36 177.33,18.36 176.65,19.04 167.43,19.04 164.84,21.63 164.84,23.58 164.38,24.04 164.38,24.85 164.77,25.23 164.77,25.62 164.57,25.82 164.5,25.82 v1(164.31,26)
PCIE_PTX_DRX_N13: length 55.6
  IN1 w0.081: v1(163.3,25.51) 163.3,25.65 163.22,25.73 162.87,25.73 162.02,24.88 162.02,20.75 163.1,19.67 164.22,19.67 167.37,16.52 173.29,16.52 174.88,14.93 201.89,14.93 203.6,16.65 206.73,16.65 206.92,16.45 206.92,16.23 v5(207.26,15.9)
  BOTTOM w0.091: CS25.1 207.02,15.53 207.02,15.66 v5(207.26,15.9)
PCIE_PTX_DRX_N14: length 56.4
  IN1 w0.081: v1(163.3,24.85) 163.3,24.72 163.2,24.63 163.03,24.63 162.82,24.42 162.82,23.66 163.47,23 163.47,21.06 166.74,17.8 167.63,16.9 173.46,16.9 175.05,15.32 201.73,15.32 203.44,17.03 208,17.03 209.35,15.68 210.11,15.68 210.34,15.92 210.42,15.92 v5(210.59,15.75)
  BOTTOM w0.091: CS26.1 210.1,15.37 210.1,15.76 210.19,15.85 210.49,15.85 v5(210.59,15.75)
PCIE_PTX_DRX_N16: length 124.5
  TOP w0.089: 162.39,23.95 162.39,23.99 UC1.CP1
  TOP w0.091: 162.39,23.95 162.39,23.41 v1(162.32,23.34) ; v5(275.28,27.46) 275.5,27.68 275.63,27.68 CR2.1
  IN1 w0.081: v2(163.08,20.5) 162.91,20.66 162.65,20.66 162.41,20.91 162.41,23.25 v1(162.32,23.34)
  IN3 w0.081: v5(275.28,27.46) 274.9,27.85 274.34,27.85 272.9,26.4 272.9,24.19 267.35,18.63 264.34,18.63 263.21,17.5 226.51,17.5 225.29,18.72 176.51,18.72 174.4,20.83 163.41,20.83 v2(163.08,20.5)
PCIE_PTX_DRX_P3: length 40.8
  TOP w0.089: v1(168.56,25.82) 168.25,26.13 UC1.DF5
  TOP w0.091: v5(186.42,50.88) 186.21,51.09 186.21,51.43 186.63,51.85 186.78,51.85 186.99,52.06 186.99,52.3 CH4.1
  IN1 w0.081: v1(168.56,25.82) 168.43,25.94 168.43,26.2 168.12,26.52 168.12,26.98 v2(168.22,27.08)
  IN3 w0.081: v2(168.22,27.08) 168.05,27.25 168.05,27.44 168.29,27.68 168.5,27.81 168.53,27.92 169.98,29.37 170.64,29.37 172.21,30.94 178.44,30.94 178.72,30.94 185.13,37.35 185.13,43.65 187.21,45.72 187.21,48.03 187.21,48.2 187.18,48.22 187.18,48.25 186.43,49 186.43,49.04 186.22,49.24 186.22,50.68 v5(186.42,50.88)
PCIE_PTX_DRX_P9: length 43.7
  TOP w0.091: v1(168.11,23.25) 167.93,23.43 166.39,23.43 165.88,23.93 165.88,24.11 165.79,24.2 UC1.DA1
  IN1 w0.081: v1(168.11,23.25) 168.18,23.32 168.93,23.32 169.82,22.43 177.94,22.43 178.7,21.67 183.99,21.67 185.6,23.28 186.84,26.27 186.84,38.51 189.41,41.08 189.41,41.4 189.46,41.45 189.46,42.02 190.14,42.7 190.4,42.7 190.49,42.8 190.68,42.8 190.77,42.71 190.77,42.6 v1(190.68,42.52)
PCIE_PTX_DRX_P10: length 45
  TOP w0.089: UC1.CY4 v1(166.09,25.83)
  IN1 w0.081: v1(166.09,25.83) 166.09,25.72 166.17,25.63 166.36,25.63 167.18,24.82 167.18,22.6 168.35,21.43 177.57,21.43 178.3,20.7 184.39,20.7 186.43,22.73 187.81,26.07 187.81,38.1 189.85,40.14 190.47,40.14 v1(190.68,40.36)
PCIE_PTX_DRX_P11: length 44.5
  TOP w0.089: v1(165.19,24.41) 164.85,24.41 UC1.CW1
  IN1 w0.081: v1(165.19,24.41) 165.26,24.48 165.43,24.48 165.81,24.1 165.81,22.03 167.78,20.06 177,20.06 177.73,19.33 184.96,19.33 187.59,21.96 189.18,25.8 189.18,36.88 189.48,37.18 190.43,37.18 v1(190.68,36.93)
PCIE_PTX_DRX_P12: length 46.3
  TOP w0.091: v1(164.31,25.62) 164.53,25.62 UC1.CW3
  IN1 w0.081: v1(190.68,34.9) 190.84,34.74 190.98,34.74 191.18,34.55 191.18,33.6 190.64,33.06 190.53,33.06 190.35,32.88 190.35,25.49 188.63,21.34 185.45,18.16 177.25,18.16 176.57,18.84 167.35,18.84 164.64,21.55 164.64,23.5 164.18,23.96 164.18,24.93 164.57,25.32 164.57,25.54 164.49,25.62 v1(164.31,25.62)
PCIE_PTX_DRX_P13: length 55.6
  IN1 w0.081: v5(206.67,15.9) 206.73,15.95 206.73,16.37 206.64,16.45 203.69,16.45 201.97,14.73 174.79,14.73 173.21,16.32 167.29,16.32 164.14,19.47 163.02,19.47 161.82,20.67 161.82,24.97 162.78,25.93 163.07,25.93 v1(163.3,26.16)
  BOTTOM w0.091: v5(206.67,15.9) 206.73,15.85 206.73,15.31 CS24.1
PCIE_PTX_DRX_P14: length 56.4
  IN1 w0.081: v5(210.66,16.34) 210.45,16.12 210.27,16.12 210.02,15.88 209.43,15.88 208.08,17.23 203.36,17.23 201.65,15.52 175.13,15.52 173.54,17.1 167.71,17.1 166.82,17.99 166.82,17.99 163.67,21.14 163.67,23.09 163.02,23.74 163.02,24.33 163.1,24.42 163.22,24.42 163.3,24.34 v1(163.3,24.2)
  BOTTOM w0.091: CS27.1 209.9,15.57 209.9,15.84 210.11,16.05 210.32,16.05 210.42,16.15 210.48,16.15 v5(210.66,16.34)
PCIE_PTX_DRX_P16: length 124.6
  TOP w0.089: UC1.CP2 162.17,24.84 162.59,24.42 162.59,24.07 162.59,24.07 162.59,23.97 162.59,23.97 162.59,23.95
  TOP w0.091: CR1.1 275.68,27.88 275.45,27.88 v5(275.28,28.05) ; 162.59,23.95 162.59,23.45 v1(162.7,23.34)
  IN1 w0.081: v1(162.7,23.34) 162.61,23.25 162.61,20.99 162.74,20.86 162.91,20.86 v2(163.08,21.03)
  IN3 w0.081: v5(275.28,28.05) 274.26,28.05 272.7,26.49 272.7,24.27 267.27,18.83 264.26,18.83 263.12,17.7 226.59,17.7 225.37,18.92 176.6,18.92 174.48,21.03 v2(163.08,21.03)
PCIE_RCOMPN: length 2.5
  TOP w0.081: 171.39,23.95 171.39,23.68 171.55,23.53 RH1.1
  TOP w0.089: 171.39,23.95 UC1.DN1
PCIE_RCOMPP: length 4.4
  TOP w0.089: UC1.DN3 171.74,24.83 171.74,23.98 172.05,23.66 172.05,21.63 171.95,21.52 RH1.2
PCIE_WAKE#: length 45.8
  IN1 w0.064: v2(181.42,54.93) 181.42,55.31 181.27,55.46 v1(181.27,57.02) ; v1(219.59,54.08) 219.23,54.43 219.23,56.6 219.13,56.7 218.59,56.7 217.97,57.33 v2(217.65,57.33) ; v1(204.4,57.25) 204.4,57.01 v2(204.98,56.43)
  IN2 w0.051: v2(181.42,54.93) 181.8,55.31 192.26,55.31 193.38,56.43 v2(204.98,56.43)
  IN3 w0.064: v2(204.98,56.43) 207.41,56.43 208.25,57.26 212.64,57.26 212.95,56.96 214.5,56.96 214.68,56.77 214.87,56.77 215.3,56.34 215.68,56.34 216.67,57.33 v2(217.65,57.33)
PCIE_WAKE#_R: length 3.6
  TOP w0.081: UE1.N13 218.35,54.71 RE481.1 RE185.1
PD_EE_CLK_L: length 24.2
  TOP w0.081: UPD1.38 16.32,24.05 v1(16.32,24.23)
  IN1 w0.064: v1(16.32,24.23) 16.26,24.17 16.03,24.17 14.07,26.13 14.07,27.26 13.41,27.91 11.84,27.91 10.64,26.71 v2(9.81,26.71) 8.47,28.05 8.47,29.3 8.29,29.48 8.29,30.56 8.41,30.68 8.41,31.49 v2(7.84,32.07)
  IN3 w0.064: v2(9.81,26.71) 9.75,26.64 v4(9.37,26.64) ; v2(7.84,32.07) 8.16,32.39 v4(8.16,33.08)
  BOTTOM w0.081: v4(8.16,33.08) 10.87,33.08 JDB1.2 ; UPD3.6 11.63,24.14 9.82,25.95 v3(9.82,26.14) 9.82,26.19 v4(9.37,26.64)
PD_EE_CLK_R: length 75.7
  TOP w0.081: v1(286.54,14.39) 286.4,14.53 286.21,14.53 286.19,14.55 UPD2.38
  IN1 w0.064: v2(285.66,21.63) 286.04,21.25 286.23,21.25 286.54,20.93 286.54,20.23 288.22,18.56 288.22,15.04 287.56,14.39 v1(286.54,14.39)
  IN3 w0.064: v4(285.66,22.01) v2(285.66,21.63) ; v4(254.25,10.1) 254.25,9.97 253.28,9 249.4,9 248.75,9.65 238.47,9.65 238.28,9.46 233.86,9.46 v4(233.4,8.99)
  BOTTOM w0.081: v4(233.4,8.99) 233.4,9.37 233.65,9.63 UPD4.6 ; v4(285.66,22.01) 284.98,21.33 281.24,21.33 v3(281.08,21.18) 280.96,21.06 274.19,21.06 273,22.25 269.55,22.25 266.58,19.28 261.65,19.28 256.73,14.35 JDB2.2 256.73,9.96 256.58,9.82 254.53,9.82 v4(254.25,10.1)
PD_EE_CS#_L: length 29.4
  TOP w0.081: UPD1.39 16.04,24.34 16.04,25.37 16.22,25.56 v1(16.29,25.56)
  IN1 w0.064: v2(16.35,25.18) 16.35,25.5 v1(16.29,25.56) 15.27,25.56 14.45,26.39 14.45,27.34 13.49,28.29 11.67,28.29 11.41,28.04 9.09,28.04 8.81,28.32 8.81,29.42 8.62,29.61 8.62,30.42 8.74,30.55 8.74,32.43 v2(8.5,32.68)
  IN3 w0.064: v2(8.5,32.68) 8.5,33.66 v4(8.29,33.88) ; v2(16.35,25.18) v4(16.35,24.67)
  BOTTOM w0.081: v4(8.29,33.88) 9.12,34.71 JDB1.5 ; v4(16.35,24.67) 18.38,22.64 v3(19.08,22.64) 19.17,22.64 RPD11.2 19.27,21.33 19.27,20.93 18.95,20.6 18.77,20.6 18.08,21.29 UPD3.1
PD_EE_CS#_R: length 75.7
  TOP w0.081: v1(286.32,14.8) 286.17,14.95 UPD2.39
  IN1 w0.064: v1(286.32,14.8) 286.42,14.71 287.62,14.71 288.04,15.12 288.04,18.48 286.16,20.36 v2(286.16,20.67)
  IN3 w0.064: v4(286.16,21.06) v2(286.16,20.67)
  BOTTOM w0.081: v4(286.16,21.06) 285.59,20.48 v3(284.39,20.48) 273.84,20.48 272.64,21.69 270.16,21.69 266.92,18.45 262.17,18.45 258.23,14.51 JDB2.5 258.23,9.88 257.61,9.27 253.99,9.27 252.3,10.97 244.9,10.97 244.68,10.75 244.68,8.21 244.01,7.54 240.56,7.54 240.19,7.91 240.19,11.97 240.38,12.17 UPD4.1 242.98,12.17 RPD59.2
PD_EE_MISO_L: length 35.3
  TOP w0.081: 16.51,23.12 17.11,23.72 v1(17.11,23.91) 17.11,24.23 16.69,24.65 16.69,24.81 RPD181.2
  IN1 w0.064: v2(17.3,23.4) 17.3,23.72 v1(17.11,23.91) 17.05,23.85 15.91,23.85 13.81,25.94 13.81,27.21 13.3,27.72 11.97,27.72 10.57,26.33 9.66,26.33 8.88,27.11 8.88,27.37 8.3,27.95 8.3,29.19 8.12,29.37 8.12,30.63 8.25,30.75 8.25,31.38 8.1,31.53 v2(7.84,31.53)
  IN2 w0.051: v2(17.3,23.4) 18.2,22.51 v2(19.55,22.51)
  IN3 w0.064: v4(20.42,20.23) 19.94,20.71 19.94,22.11 v2(19.55,22.51) ; v2(7.84,31.53) 7.84,31.53 8.84,32.53 v4(8.84,33.76)
  BOTTOM w0.081: JDB1.4 9.29,34.21 v4(8.84,33.76) ; v4(20.42,20.23) v3(19.65,19.47) 19.45,19.27 19.45,19.23 RPD12.2 18.33,19.15 18.33,19.24 UPD3.2
PD_EE_MISO_R: length 75.7
  TOP w0.081: UPD2.36 v1(286.01,13.75) 286.31,13.75 RPD182.2
  IN1 w0.064: v1(286.01,13.75) 285.91,13.85 285.91,14.83 286.16,15.09 286.48,15.09 286.67,14.9 286.74,14.9 286.74,14.89 287.04,14.89 287.05,14.9 287.56,14.9 287.81,15.15 287.81,18.45 285.66,20.61 v2(285.66,20.67)
  IN3 w0.064: v4(285.66,21.06) v2(285.66,20.67)
  BOTTOM w0.081: RPD60.2 243.36,10.9 UPD4.2 240.51,10.9 240.38,10.77 240.38,7.97 240.63,7.72 243.94,7.72 244.5,8.28 244.5,10.83 244.82,11.15 252.37,11.15 254.07,9.45 257.29,9.45 257.73,9.89 JDB2.4 257.73,14.53 261.97,18.77 266.79,18.77 269.9,21.88 272.77,21.88 273.97,20.67 282.61,20.67 v3(282.73,20.8) 282.9,20.97 285.57,20.97 v4(285.66,21.06)
PD_EE_MOSI_L: length 26.3
  TOP w0.081: v1(16.68,24.17) 16.69,24.16 16.69,23.86 UPD1.37
  IN1 w0.064: v1(16.68,24.17) 16.68,24.28 16.47,24.49 16.09,24.49 14.26,26.33 14.26,27.3 13.45,28.1 11.78,28.1 10.89,27.21 v2(9.8,27.21) 9.66,27.21 8.63,28.24 8.63,29.37 8.45,29.55 8.45,30.49 8.58,30.62 8.58,31.91 v2(7.83,32.66)
  IN3 w0.064: v4(9.37,27.09) 9.49,27.21 v2(9.8,27.21) ; v2(7.83,32.66) 7.83,33.36 7.97,33.5 v4(8.22,33.5)
  BOTTOM w0.081: v4(8.22,33.5) 8.28,33.5 8.41,33.38 9.69,33.38 10.02,33.71 JDB1.3 ; v4(9.37,27.09) 8.99,26.71 v3(8.99,24.99) UPD3.5
PD_EE_MOSI_R: length 77.2
  TOP w0.081: v1(286.21,14.25) 286.12,14.15 UPD2.37
  IN1 w0.064: v2(286.16,21.63) 286.74,21.06 286.74,20.29 288.4,18.63 288.4,14.97 287.56,14.13 286.66,14.13 286.65,14.13 286.44,14.13 286.43,14.13 286.33,14.13 v1(286.21,14.25)
  IN3 w0.064: v4(233.27,8.36) 233.01,8.61 233.01,9.05 233.59,9.63 238.21,9.63 238.4,9.81 248.82,9.81 249.47,9.17 253.08,9.17 v4(253.91,10) ; v4(286.16,22.01) v2(286.16,21.63)
  BOTTOM w0.081: v4(286.16,22.01) 286.16,22.01 v3(285.71,21.56) 285.3,21.15 281.49,21.15 281.21,20.86 274.1,20.86 272.9,22.06 269.73,22.06 266.69,19.02 261.79,19.02 257.23,14.47 JDB2.3 257.23,9.96 256.9,9.63 254.27,9.63 v4(253.91,10) ; v4(233.27,8.36) UPD4.5
PD_EE_WP#_L: length 3.1
  BOTTOM w0.081: RPD14.2 17.81,18.05 17.72,18.05 v3(17.39,18.38) 16.28,19.49 UPD3.3
PD_EE_WP#_R: length 2.6
  BOTTOM w0.081: UPD4.3 242.92,9.63 243.34,9.21 RPD62.2
PD_HOLD#_L: length 4.3
  BOTTOM w0.081: UPD3.7 10.5,27.07 RPD13.2 9.8,27.1 9.43,27.47 v3(9.3,27.47)
PD_HOLD#_R: length 2.9
  BOTTOM w0.081: UPD4.7 233.86,10.9 RPD61.2
PD_ID: length 13.7
  TOP w0.081: v1(204.19,58.77) 204.12,58.77 203.8,58.46 RE486.1
  IN1 w0.064: v2(214.15,60.79) 214.3,60.65 v1(214.3,59.56) ; v1(204.19,58.77) 204.19,59.26 v2(204.49,59.57)
  IN2 w0.051: v2(204.49,59.57) 204.53,59.61 207.61,59.61 207.98,59.98 208.48,59.98 209.02,60.52 210.67,60.52 211.02,60.17 213.71,60.17 214.15,60.62 v2(214.15,60.79)
  IN3 w0.064: v4(214.51,60.79) v2(214.15,60.79)
PD_L_DDM_MUX1_EN: length 40.1
  TOP w0.081: v1(16.1,28.23) 16.16,28.17 v3(16.16,27.47) 15.68,27.47 14.92,28.23 12.67,28.23 12.16,27.72 12.16,26.83 12.26,26.73 RPD123.1 ; RM2.1 v5(12,55.47)
  IN1 w0.064: v2(16.42,28.48) 16.16,28.23 v1(16.1,28.23)
  IN2 w0.051: v2(16.42,28.48) 16.42,32.95 17.75,34.28 17.75,37.37 17.34,37.78 17.34,38.56 18.35,39.57 18.35,52.33 16.99,53.69 13.77,53.69 v5(12,55.47)
PD_L_DDM_MUX1_EN_R: length 5.2
  TOP w0.081: RPD191.1 11.7,26.66 11.86,26.5 11.86,26.49 12.22,26.14 12.22,26.14 12.23,26.13 RPD123.2 12.97,25.84 14.67,25.84 15.17,25.35 15.17,25.17 UPD1.42
PD_L_DRAIN1:
  vias: v3(13.3,18.39) v5(12.7,18.41) v5(13.44,17.67) v5(13.62,19.33) v5(14.17,16.94) v5(14.35,18.59) v5(15.09,17.85)
PD_L_DRAIN2:
  vias: v3(11.15,20.29) v5(10.61,20.5) v5(11.37,19.74) v5(11.53,21.41) v5(12.12,18.99) v5(12.28,20.66) v5(13.04,19.9)
PD_L_GPIO2: length 1.9
  TOP w0.081: UPD1.18 16.3,16.4 16.3,15.78 RPD139.2
PD_L_GPIO4: length 9.7
  TOP w0.081: v1(18.29,22.31) 18.29,22.07 UPD1.31
  IN1 w0.064: v1(18.29,22.31) 16.94,22.31 14.65,24.6 v1(10.3,24.6)
PD_L_GPIO16: length 1.7
  TOP w0.081: 10.72,24.19 10.74,24.17 11.36,24.17 UPD1.48
PD_L_GPIO17: length 13.1
  TOP w0.081: v1(16.94,15.13) 16.94,14.62 v3(17.3,14.26) ; UPD1.49 11.27,23.69 v1(11.27,23.72)
  IN1 w0.064: v1(11.27,23.72) 11.78,23.72 16.54,18.96 16.54,16.84 16.61,16.77 16.61,15.47 v1(16.94,15.13)
PD_L_GPIO18: length 2.3
  TOP w0.081: RPD204.1 10.3,24.14 10.74,23.7 10.74,23.65 UPD1.50
PD_L_GPIO19: length 1.9
  TOP w0.081: RPD204.2 10.26,22.44 UPD1.53
PD_L_PROCHOT#: length 2.4
  TOP w0.081: RPD183.1 RPD185.2 15.85,25.78 15.85,24.72 UPD1.40
PD_L_R_PROCHOT#: length 340.7
  TOP w0.081: PR105.1 97.61,9.09 102.56,9.09 v1(105.28,6.37) ; PR105.1 96.69,8.91 95.89,8.91 95.65,9.16 PR104.1 ; PR105.1 98.47,10.69 98.47,12.99 v3(96.37,15.09) v1(95.98,15.09) ; RPD186.1 288.76,15.81 288.76,16.72 288.25,17.23 288.25,17.63 287.88,18.01 v1(287.43,18.01) ; RPD185.1 16.48,26.45 16.48,27.98 16.86,28.36 17.18,28.36 17.81,28.99 v1(18.89,28.99)
  IN1 w0.064: v2(21.11,24.17) 20.86,24.42 20.86,25.56 18.89,27.53 v1(18.89,28.99) ; v2(84.09,16.11) 84.43,16.11 85.57,17.25 87.66,17.25 88.17,16.73 89,16.73 89.62,16.11 92.98,16.11 93.74,15.35 95.72,15.35 v1(95.98,15.09) ; v2(286.67,18.64) 287.31,18.01 v1(287.43,18.01) ; v1(105.28,6.37) 105.28,3.11 v2(105.43,2.96)
  IN2 w0.051: v2(286.67,18.64) 286.16,19.15 285.85,19.15 282.99,22.01 278.61,22.01 275.12,18.52 275.12,17.5 272.53,14.91 272.53,13.55 269.3,10.32 268.17,10.32 263.08,5.23 252.86,5.23 251.25,6.84 249.22,6.84 247.26,4.89 235.17,4.89 234.44,4.16 227.74,4.16 220.69,11.21 215.39,11.21 212.44,14.16 212.44,16.57 211.78,17.23 195.97,17.23 195.23,17.97 177.07,17.97 175.75,16.65 175.75,12.8 179.41,9.14 179.41,5.17 176.89,2.66 153.69,2.66 152.99,3.35 133.36,3.35 132.6,2.59 105.8,2.59 v2(105.43,2.96) ; v2(84.09,16.11) 83.58,15.59 79.8,15.59 78.71,16.68 62.46,16.68 61.57,15.78 33.02,15.78 32.26,16.55 28.73,16.55 28.3,16.98 27.26,16.98 27.16,16.88 25.18,16.88 25.06,17 23.17,17 22.55,17.62 22.55,19.62 22.11,20.06 22.11,21.96 20.83,23.23 20.83,23.88 v2(21.11,24.17)
PD_L_SINK_ARB_MASTER_OUT: length 1.9
  TOP w0.081: UPD1.54 9.85,22.28 RPD174.2
PD_L_SINK_ARB_SLAVE_IN: length 4.8
  TOP w0.081: 10.15,21.42 9.49,22.07 9.49,23.03 RPD189.1 ; RPD189.1 8.88,24.31 RPD172.2 ; RPD189.1 v3(7.91,23.34)
PD_L_SLAVE_IN: length 311.7
  TOP w0.081: v3(7.67,25.22) 8.2,25.22 v1(8.58,24.84)
  IN1 w0.064: v1(280.56,19.18) 280.56,19.2 281.34,19.98 281.66,19.98 v2(282.1,20.42) ; v1(8.58,24.84) v2(8.58,24.08)
  IN2 w0.051: v2(8.58,24.08) 8.58,23.42 6.19,21.03 6.19,17.79 6.93,17.05 10.95,17.05 13.62,14.39 15.15,14.39 16.54,12.99 20.77,12.99 23.12,10.64 29.94,10.64 30.89,9.69 59.62,9.69 60.4,8.91 75.77,8.91 76.94,7.74 76.94,6.23 81.02,2.15 92.86,2.15 93.82,3.12 95.04,3.12 96.18,1.98 132.88,1.98 133.65,2.74 152.74,2.74 153.43,2.05 177.15,2.05 181.01,5.92 184.56,5.92 187.61,2.87 216.36,2.87 218.4,4.91 221.22,4.91 221.52,5.22 223.58,5.22 226.83,1.97 237.38,1.97 238.1,2.69 263.67,2.69 266.67,5.69 266.67,6.07 267.69,7.09 268,7.09 271.62,10.7 273.97,10.7 274.35,11.09 274.35,15.09 276.58,17.31 276.58,18.01 278.54,19.98 281.66,19.98 v2(282.1,20.42)
PD_L_USB_MUX1_EN: length 51.4
  TOP w0.081: v1(19.84,14.13) 19.84,14.26 v3(20.29,14.71) 21.99,16.4 21.99,18.79 21.39,19.38 v1(21.39,19.84) ; v5(17.5,52.61) 18.26,52.61 19.27,53.63 RM1.1
  IN1 w0.064: v1(16.49,14.68) 16.76,14.68 17.3,14.13 v1(19.84,14.13) ; v1(21.39,19.84) 21.19,20.04 20.91,20.04 20.87,20.04 v2(20.84,20.01)
  IN2 w0.051: v2(20.84,20.01) 20.62,20.23 19.72,20.23 16.86,23.09 16.86,24.42 17.12,24.68 17.12,26.58 15.97,27.73 15.97,32.72 17.56,34.31 17.56,37.34 17.19,37.72 17.19,38.62 18.2,39.63 18.2,51.91 v5(17.5,52.61)
PD_L_USB_MUX1_EN_R: length 2.4
  TOP w0.081: UPD1.16 15.39,16.18 15.39,15.79 RPD187.2 RPD190.1
PD_R_DDM_MUX1_EN: length 63.6
  TOP w0.081: RPD157.1 287.81,18.71 v1(288.32,19.21) ; RM18.1 269.42,53.57 272.16,50.83 v3(272.16,50.76) 272.16,50.43 272.05,50.32 272.05,37.3 271.63,36.87 271.63,35.09 v1(271.94,34.77)
  IN1 w0.064: v2(285.91,19.85) v2(282.86,19.85) ; v1(288.32,19.21) 288.13,19.4 v2(288.13,19.53) ; v1(271.94,34.77) 272.38,34.33 272.38,27.81 268.99,24.42 268.99,22.78 268.45,22.25 268.45,19.34 270.99,16.8 274.16,16.8 276.38,19.02 277.72,19.02 278.92,17.82 v2(278.99,17.82)
  IN3 w0.064: v2(278.99,17.82) 281.02,19.85 v2(282.86,19.85) ; v2(285.91,19.85) 287.12,19.85 287.43,19.53 v2(288.13,19.53)
PD_R_DDM_MUX1_EN_R: length 4.6
  TOP w0.081: RPD192.1 RPD157.2 286.47,18.71 285.84,18.07 285.84,17.36 286.02,17.17 286.02,16.28 285.89,16.15 UPD2.42
PD_R_DRAIN1:
  vias: v5(279.31,13.12) v5(279.31,12.08) v5(279.31,11.04) v5(280.61,13.12) v5(280.61,12.08) v5(280.61,11.04) v6(280,12.67)
PD_R_DRAIN2:
  vias: v5(279.31,16.07) v5(279.31,15) v5(279.31,13.94) v5(280.61,16.07) v5(280.61,15) v5(280.61,13.94) v6(279.88,15.66)
PD_R_GPIO2: length 23.2
  TOP w0.081: UPD2.18 v1(280.43,9.31)
  IN1 w0.064: v1(281.77,19.18) 282.75,18.2 283.94,18.2 285.34,16.8 285.34,13.56 285.91,12.99 288.51,12.99 288.96,12.55 288.96,11.39 288.72,11.15 288.32,11.15 288.25,11.23 287.89,11.23 286.99,10.32 281.97,10.32 280.96,9.31 v1(280.43,9.31)
PD_R_GPIO4: length 15.1
  TOP w0.081: v3(288.58,10.96) v1(288.13,10.96) 286.74,10.96 285.94,11.75 UPD2.31
  IN1 w0.064: v1(285.64,18.59) 285.64,13.7 286.1,13.24 288.77,13.24 289.15,12.86 289.15,11.28 288.83,10.96 v1(288.13,10.96)
PD_R_GPIO16: length 6.2
  TOP w0.081: UPD2.48 282.43,18.05 282.15,18.34 282.15,19.43 282.23,19.51 285.31,19.51 RPD147.2
PD_R_GPIO17: length 1.7
  TOP w0.081: RPD144.1 281.77,18.4 282.03,18.14 UPD2.49
PD_R_GPIO18: length 1.7
  TOP w0.081: RPD205.1 281.21,18.21 281.63,17.79 UPD2.50
PD_R_GPIO19: length 2.4
  TOP w0.081: UPD2.53 280.43,17.78 280.89,18.23 280.89,18.86 RPD205.2
PD_R_PROCHOT#: length 5.9
  TOP w0.081: UPD2.40 286.21,15.35 286.74,14.83 287.2,14.83 RPD186.2 v3(288.47,16.1) 288.47,16.73 287.93,17.28 287.93,17.5 287.87,17.56 RPD184.1
PD_R_SINK_ARB_MASTER_OUT: length 1.8
  TOP w0.081: UPD2.54 280.03,18.06 RPD171.2
PD_R_SINK_ARB_SLAVE_IN: length 2.3
  TOP w0.081: RPD173.2 RPD177.1 279.29,18.44 279.63,18.1 UPD2.55
PD_R_SLAVE_IN: length 310.6
  TOP w0.081: RPD174.1 9.44,24.4 v1(9.57,24.52)
  IN1 w0.064: v1(9.57,24.52) v2(9.57,24.04) ; v2(281.53,20.42) 281.39,20.28 281.01,20.28 v1(279.94,19.21)
  IN2 w0.051: v2(281.53,20.42) 281.4,20.29 278.59,20.29 276.38,18.09 276.38,17.39 274.16,15.17 274.16,11.16 273.89,10.9 271.56,10.9 267.95,7.28 267.61,7.28 266.48,6.15 266.48,5.75 264.51,3.78 264.51,3.78 263.57,2.84 238.04,2.84 237.32,2.12 226.9,2.12 223.65,5.37 221.39,5.37 221.11,5.09 218.36,5.09 216.3,3.02 187.68,3.02 184.63,6.07 180.95,6.07 177.08,2.2 153.5,2.2 152.8,2.89 133.58,2.89 132.82,2.13 96.24,2.13 95.1,3.27 93.76,3.27 92.8,2.31 81.08,2.31 77.09,6.29 77.09,7.8 75.84,9.06 60.46,9.06 59.64,9.88 30.96,9.88 30,10.83 23.14,10.83 20.83,13.14 16.64,13.14 15.21,14.58 13.75,14.58 11.12,17.21 7.06,17.21 6.38,17.88 6.38,20.85 v2(9.57,24.04)
PD_R_USB_MUX1_EN: length 66.7
  TOP w0.081: RM17.1 268.89,58.37 268.89,53.85 271.87,50.87 271.87,37.57 271.33,37.03 271.33,34.86 272.05,34.14 272.05,25.5 271.73,25.18 v3(269.21,25.18) 268.19,25.18 266.99,23.98 v1(266.99,22.58)
  IN1 w0.064: v1(276.26,9.56) 276.26,9.88 276.45,10.07 276.45,10.39 276.19,10.64 275.75,10.64 275.18,11.21 275.18,12.36 275.5,12.67 275.69,12.67 276.04,13.02 276.61,13.02 276.89,13.31 276.89,13.94 276.19,14.64 274.86,14.64 274.35,15.15 274.33,15.15 274.3,15.18 272.31,15.18 271.64,14.51 268.76,14.51 267.81,15.47 267.81,16.61 267.37,17.05 267.37,21.18 266.8,21.75 266.8,22.39 v1(266.99,22.58)
PD_R_USB_MUX1_EN_R: length 4.2
  TOP w0.081: RPD188.2 RPD193.1 277.21,8.98 277.23,8.96 277.52,8.96 277.67,9.11 279.3,9.11 279.63,9.44 UPD2.16
PD_TCP0_LS_EN: length 23.4
  TOP w0.081: v3(21.06,20.71) 20.78,20.99 v1(20.77,20.99) 20.48,20.99 RPD126.1 ; RT83.1 18.51,39.85 18.18,39.52 v1(17.07,39.52)
  IN1 w0.064: v2(20.88,21.36) 20.77,21.24 v1(20.77,20.99) ; v2(17.81,33.27) 16.77,34.31 16.77,39.22 v1(17.07,39.52)
  IN3 w0.064: v2(17.81,33.27) 17.41,32.86 17.41,31.87 18.61,30.68 18.61,26.03 20.73,23.91 20.73,21.51 v2(20.88,21.36)
PD_TCP0_LS_EN_R: length 2
  TOP w0.081: UPD1.30 18.8,22.01 19.46,22.01 RPD126.2
PD_TCP2_LS_EN: length 21.9
  TOP w0.081: v5(289.08,24.05) 288.84,24.05 288.4,24.49 288.4,25.04 RT94.1 287.37,25.37 286.93,25.82 286.93,26.39 v3(286.35,26.96) ; RPD134.1 288.12,10.51 v1(288.16,10.55)
  IN1 w0.064: v2(288.64,10.55) v1(288.16,10.55)
  IN2 w0.051: v5(289.08,24.05) 288.08,24.05 287.12,23.09 287.12,19.98 288.64,18.45 v2(288.64,10.55)
PD_TCP2_LS_EN_R: length 2
  TOP w0.081: RPD134.2 286.86,10.51 286.02,11.35 UPD2.30
PE: length 1.9
  TOP w0.203: PR1115.1 PR1111.2 97.79,50.17 97.61,49.99 PU1100.20
PECI_EC: length 132.7
  TOP w0.081: RE153.2 219.88,57.74 219.7,57.91 218.64,57.91 v1(218.6,57.95) ; v1(157.31,23.79) 157.5,23.98 157.5,25.3 157.54,25.34 157.54,25.66 157.22,25.98 UC1.CD5
  IN1 w0.064: v2(208.05,10) 208.05,11.51 207.51,12.04 188.19,12.04 187.61,11.47 173.25,11.47 172.56,12.15 168.87,12.15 167.86,13.16 165.94,13.16 162.82,16.29 161.7,16.29 160.34,17.65 158.74,17.65 156.47,19.91 156.47,21.72 156.66,21.91 156.66,23.27 157.18,23.79 v1(157.31,23.79) ; v1(218.6,57.95) 218.22,58.33 v2(218.22,58.52)
  IN2 w0.051: v5(218.92,41.44) 219.68,42.2 219.68,44.94 220.57,45.83 220.57,54.41 218.22,56.76 v2(218.22,58.52)
  IN3 w0.064: v4(208.39,10) v2(208.05,10)
  BOTTOM w0.081: v5(218.92,41.44) 218.98,41.38 218.98,36.74 219.56,36.16 219.56,35.25 219.74,35.06 219.74,29.02 224.25,24.52 v6(224.25,22.39) 224.25,20.07 223.94,19.76 223.94,15.94 222.1,14.11 215.17,14.11 214.66,13.6 214.66,11.37 213.99,10.7 209.46,10.7 208.75,10 v4(208.39,10)
PECI_EC_R: length 2.9
  TOP w0.081: UE1.K13 217.13,58.76 218.57,57.31 RE153.1
PM_RSMRST_PWRGD_MIPI60: length 82
  TOP w0.081: v1(171.8,17.77) 171.8,18.22 RC247.2 171.46,18.26 RC647.2
  IN1 w0.064: v1(171.8,17.77) v2(172.13,17.77)
  IN2 w0.051: v2(120.3,3.21) 120.37,3.28 122.14,3.28 122.5,2.92 127.17,2.92 128.95,4.7 138.82,4.7 139.44,4.08 142.46,4.08 143,4.61 144.5,4.61 145.21,3.9 153.4,3.9 154.12,3.18 176.75,3.18 178.95,5.38 178.95,8.8 176.12,11.63 172.38,15.36 172.38,17.52 v2(172.13,17.77)
  IN3 w0.064: v2(120.3,3.21) 120.37,3.28 120.37,4.14 v4(120.37,4.14)
  BOTTOM w0.081: v4(120.37,4.14) 120.22,4.28 v3(120.22,4.51) 120,4.72 JMIPI60.42
POWER_SW_IN#: length 69.9
  TOP w0.081: v1(207.49,64.27) 207.72,64.05 207.99,64.05 208.38,63.66 208.38,63.44 208.66,63.16 209.89,63.16 UE1.D5 ; v3(200.76,62.97) 200.76,63.09 201.08,63.41 201.91,63.41 CE104.1 202.23,63.41 202.19,63.45 v1(202.19,63.85) RE184.2
  IN1 w0.064: v1(207.49,64.27) 207.36,64.15 206.6,64.15 v2(206.32,63.87) ; v1(196.89,17.17) 196.68,17.37 196.63,17.37 196.5,17.5 196.5,18.64 196.88,19.02 196.88,25.76 196.09,26.55 196.09,30.45 196.21,30.57 196.21,31.67 196.25,31.7 196.25,31.76 197.01,32.52 197.01,36.42 197,36.43 197,36.44 196.31,37.14 196.31,45.95 196.5,46.14 197.14,46.14 197.45,46.46 197.45,46.84 199.55,48.93 199.57,48.93 199.63,48.98 200.36,48.98 201.21,48.98 201.38,49.14 203.26,49.14 205.46,51.34 205.46,53.88 207.36,55.79 207.36,56.49 207.17,56.68 206.73,56.68 206.47,56.93 v2(206.47,58.71) ; v1(202.19,63.85) 202.35,64.01 v2(202.51,64.01)
  IN3 w0.064: v4(204.69,61) 204.69,60.81 206.47,59.03 v2(206.47,58.71) ; v4(206.32,63.4) v2(206.32,63.87) 205.44,63.87 205.29,64.01 v2(202.51,64.01)
  BOTTOM w0.081: v4(204.69,61) 204.69,62.42 205.67,63.4 v4(206.32,63.4)
PRIM_PWRGD: length 5
  TOP w0.081: RE245.1 RE461.1 212.88,54.11 212.35,54.65 212.35,54.94 212.24,55.05 212.24,57.62 UE1.L7
PROCHOT#_R1: length 2.5
  TOP w0.081: RE158.1 218.54,60.93 217.96,60.36 UE1.H13
PROM_BIOS_R: length 67.6
  TOP w0.081: v1(174.64,16.73) 174.64,14.91 R466.1 174.21,14.02 v3(174.66,13.57)
  IN1 w0.064: v2(174.2,17.26) 174.21,17.26 174.21,17.25 174.64,16.81 v1(174.64,16.73) ; v2(198.55,22.96) 198.55,26.13 199.32,26.9 199.32,30.76 199.96,31.39 199.96,37.3 199.65,37.61 199.65,37.83 v2(199.69,37.87)
  IN2 w0.051: v2(185.97,43.05) 186.47,42.56 187.69,42.56 190.55,39.7 190.65,39.7 192.3,38.05 195.24,38.05 195.43,37.87 v2(199.69,37.87) ; v2(174.2,17.26) 174.13,17.18 173.64,17.18 173.43,17.4 173.43,17.82 174.39,18.78 186.02,18.78 190.48,23.24 192.21,23.24 193.23,22.22 193.23,21.81 193.33,21.72 197.1,21.72 198.34,22.96 v2(198.55,22.96)
  IN3 w0.064: v2(185.97,43.05) 185.77,42.85 v4(185.71,42.85)
  BOTTOM w0.081: v4(185.71,42.85) 185.71,42.16 185.85,42.01 JSPI1.6

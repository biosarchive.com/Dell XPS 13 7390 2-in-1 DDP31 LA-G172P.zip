# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLEEVE_CONN:
  vias: v1(10.16,72.67) v1(10.41,72.67) v1(10.67,72.67) v1(10.92,72.67) v2(10.1,72.28) v2(10.54,72.28) v2(10.98,72.28) v3(11.06,75.59) v4(10,71.92) v4(10,71.66) v4(10.26,71.92) v4(10.26,71.66)
SLP_VCCST_MIPI60_OVRD: length 130.9
  IN1 w0.064: v1(183.47,36.64) 183.38,36.64 181.9,35.15 178.6,35.15 177.09,36.66 176.59,36.66 v2(176.41,36.84)
  IN2 w0.051: v2(105.88,47.99) 106.21,48.32 107.56,48.32 107.6,48.28 115.71,48.28 117.09,49.66 125.3,49.66 125.98,48.98 136.95,48.98 137.49,49.52 139.11,49.52 139.59,50 143.16,50 144.39,48.77 146.5,48.77 147.59,49.87 153.02,49.87 153.99,48.9 156.59,48.9 157,49.31 158.06,49.31 158.64,48.73 158.64,47.94 159.19,47.39 160,47.39 160.38,47.01 160.38,46.61 160.54,46.46 160.54,45.87 161.21,45.2 161.21,44.7 161.86,44.05 161.86,43.67 162.31,43.22 163.96,43.22 165.02,42.16 165.02,41.11 165.21,40.92 165.21,40.33 166.33,39.2 167.36,39.2 167.63,39.47 168.24,39.47 169.85,37.87 173.78,37.87 174.33,37.32 175.92,37.32 v2(176.41,36.84) ; v2(102.97,42.71) 102.44,42.71 101.62,41.89 101.62,40.02 102.62,39.01 102.62,37.65 101.38,36.41 101.38,33.65 100.97,33.25 100.97,30.89 100.48,30.39 100.48,28.8 108.74,20.53 109.42,20.53 110.22,19.73 v2(111.92,19.73)
  IN3 w0.064: v2(111.92,19.73) 112.2,19.73 v4(112.4,19.53) ; v2(102.97,42.71) 102.97,43.41 103.47,43.92 103.47,45.59 v2(105.88,47.99)
  BOTTOM w0.081: v3(111.49,21.3) 111.13,20.95 RC619.2 RC626.1 112.4,19.71 v4(112.4,19.53)
SLP_VCCST_OVRD: length 134.6
  TOP w0.081: v1(109.75,18.58) 109.95,18.37 v3(109.95,14.32) v1(109.95,4.98) ; UC7.4 187.98,29.42 187.75,29.19 187.75,26.76 188.06,26.45 188.63,26.45 191,24.08 v1(191,23.34)
  IN1 w0.064: v2(110.23,20.2) 110.21,20.17 110.21,19.35 109.9,19.05 109.9,18.73 v1(109.75,18.58) ; v2(192.64,22.11) 192.64,22.12 191.8,22.97 191.8,23.32 191.77,23.34 v1(191,23.34) ; v1(109.95,4.98) 109.95,4.17 110.43,3.69 v2(110.43,2.95)
  IN2 w0.051: v2(110.43,2.95) 110.74,2.95 110.94,2.75 127.21,2.75 127.42,2.95 129.01,4.55 138.75,4.55 139.38,3.92 142.53,3.92 143.06,4.46 144.43,4.46 145.14,3.74 153.34,3.74 154.06,3.03 176.82,3.03 179.1,5.31 179.1,8.86 176.18,11.78 176.18,11.78 175.37,12.59 175.37,17.04 176.66,18.32 188.86,18.32 v2(192.64,22.11)
  IN3 w0.064: v2(110.23,20.2) 110.25,20.22 110.47,20.22 v4(110.55,20.29)
  BOTTOM w0.081: UC8.3 109.66,20.09 RC700.1 109.9,20.33 110.51,20.33 v4(110.55,20.29)
SLP_WLAN#_GATE: length 69.6
  TOP w0.081: v1(215.56,53.08) 215.41,53.23 RE476.1 ; 175.66,63.7 175.64,63.7 v1(175.61,63.66) 175.42,63.85 R322.2
  TOP w0.089: Q124.2 175.66,63.7
  IN1 w0.064: v2(176.41,63.37) 176.12,63.66 v1(175.61,63.66) ; v2(215.45,54.14) 215.45,54.14 215.56,54.03 v1(215.56,53.08)
  IN2 w0.051: v2(219.49,64.7) 219.49,64.25 217.46,62.22 217.46,60.16 215.95,58.65 215.95,57.99 215.18,57.22 215.18,56.53 215.37,56.34 215.67,56.34 215.93,56.07 215.93,55.68 215.45,55.19 215.45,54.14 v2(215.45,54.14) ; v2(217.28,65.16) 216.43,66.01 212.38,66.01 212.02,65.66 212.02,65.15 213.69,63.48 213.69,62.75 212.83,61.89 211.24,61.89 210.35,62.77 209.83,62.77 209.18,63.43 208.43,63.43 207.51,62.51 206.54,62.51 206.36,62.34 204.65,62.34 203.2,60.88 201,60.88 200.91,60.8 197.95,60.8 197.16,61.59 193.21,61.59 191.74,63.06 190.25,63.06 189.16,61.97 182.01,61.97 181.43,62.55 178.07,62.55 177.28,63.34 176.44,63.34 v2(176.41,63.37)
  IN3 w0.064: v2(219.49,64.7) 219.03,65.16 v2(217.28,65.16)
SLP_WLAN#_GATE_R: length 5.1
  TOP w0.081: RE476.2 215.28,54.24 215.28,55.37 214.66,55.99 214.66,58.04 214.3,58.4 UE1.K10
SLP_WLAN#_M: length 3
  TOP w0.081: R616.2 175.57,63.22 175.6,63.25 Q124.3 176.66,62.61 RE321.1 176.39,62.18 D23.2
SMB_CLK: length 76.4
  IN1 w0.064: v2(121,5.98) 121.19,5.8 121.19,5.57 121.38,5.37 122.63,5.37 128.35,11.09 132.33,11.09 138.06,16.81 138.06,17.61 139.92,19.47 141.32,19.47 141.72,19.87 149.55,19.87 150.73,21.06 152.38,21.06 154.38,23.05 155.35,23.05 155.73,23.43 155.73,24.83 154.72,25.84 154.72,27.17 156.24,28.68 159.84,28.68 161.87,30.71 166.49,30.71 167.17,31.4 167.17,37.6 168.21,38.64 168.67,38.64 169.2,38.12 169.2,37.99 169.69,37.5 170.05,37.5 170.43,37.12 170.43,36.86 v2(170.35,36.78) 170.24,36.89 v1(170.03,36.89)
  IN3 w0.064: v4(169.77,36.71) 170.28,36.71 v2(170.35,36.78) ; v4(120.94,3.11) 121.16,3.33 121.16,5.82 v2(121,5.98)
SMB_CLK_MIPI60: length 3.5
  BOTTOM w0.081: R210.2 R725.1 121.15,3.91 121.15,4.16 121.64,4.66 121.64,4.86 121.5,5 JMIPI60.48
SMB_DATA: length 76.9
  IN1 w0.064: v2(121.53,5.98) 121.38,5.82 121.38,5.65 121.46,5.56 122.56,5.56 128.27,11.28 132.25,11.28 137.87,16.89 137.87,17.69 139.84,19.66 141.24,19.66 141.64,20.06 149.47,20.06 150.65,21.25 152.31,21.25 154.3,23.24 155.27,23.24 155.54,23.51 155.54,24.75 154.53,25.76 154.53,27.25 156.16,28.87 159.76,28.87 161.79,30.9 166.41,30.9 166.98,31.48 166.98,37.68 168.13,38.84 168.75,38.84 169.39,38.2 169.39,38.07 169.77,37.69 170.13,37.69 171.17,36.64 171.45,36.64 171.98,36.11 v1(171.98,35.97)
  IN3 w0.064: v4(121.57,3.11) 121.35,3.33 121.35,5.8 v2(121.53,5.98)
SMB_DATA_MIPI60: length 3.5
  BOTTOM w0.081: JMIPI60.50 122,5 121.85,4.85 121.85,4.57 121.36,4.08 121.36,3.91 R726.1 R311.2
SMC_ONOFF_MIPI60_N: length 3.9
  BOTTOM w0.081: C285.1 R257.2 R267.1 119.67,4.86 119.5,5.03 JMIPI60.40
SML0_SMBCLK: length 398
  IN1 w0.064: v1(274.76,37.63) 274.76,37.09 274.99,36.87 275.46,36.87 v2(275.65,37.06) ; v1(181.86,35.85) 181.67,36.04 179.99,36.04 v2(179.83,35.88) 179.63,36.07 178.72,36.07 177.33,37.46 176.85,37.46 176.57,37.18 175.44,37.18 174.34,36.08 174.34,35.03 173.96,34.64 172.31,34.64 171.55,35.41 171.55,35.95 171.27,36.23 170.29,36.23 v1(170.03,35.97) 170.03,35.78 170.09,35.72 170.09,35.6 v2(170.02,35.53) 169.96,35.47 169.66,35.47 168.9,34.7 168.83,34.64 ; v1(4.05,47.29) 3.84,47.09 3.59,47.09 3.28,46.79 3.28,45.11 3.57,44.82 4.1,44.82 5.76,43.15 7,43.15 7.65,42.5 7.65,39.55 7.3,39.2 7.3,22.37 5.3,20.36 5.3,20.13 4.62,19.45 4.21,19.45 3.78,19.03 3.78,15.77 5.75,13.8 5.75,12.98 6.94,11.78 9.58,11.78 10.52,10.84 13.57,10.84 15.46,12.74 22.62,12.74 25.23,10.13 27.32,10.13 28.78,8.67 29.96,8.67 30.55,9.27 34.98,9.27 35.16,9.09 40.7,9.09 42.62,11 47.72,11 48.83,9.9 55.24,9.9 59.19,5.95 67.98,5.95 68.53,6.5 71.92,6.5 75.42,3 81.25,3 82.43,4.18 87.91,4.18 89.25,5.52 89.77,5.52 93.1,8.85 102.26,8.85 102.76,8.36 109.06,8.36 110.54,6.88 119.09,6.88 121.15,4.81 122.87,4.81 128.58,10.53 132.56,10.53 135.66,13.63 136.15,13.63 139.14,16.61 140.64,16.61 141.73,17.7 150.62,17.7 151.49,18.57 154.93,18.57 156.11,19.75 156.11,21.88 156.29,22.06 156.29,25.06 155.28,26.07 155.28,26.94 156.47,28.12 160.07,28.12 161.01,29.06 167.88,29.06 168.42,29.59 168.42,34.22 168.5,34.3
  IN1 w0.081: 168.5,34.3 168.83,34.64
  IN2 w0.051: v2(179.83,35.88) 179.99,36.04 182.34,36.04 182.39,36.09 182.39,36.09 182.41,36.12 184.99,36.12 190.16,30.94 190.16,28.28 190.73,27.71 207.61,27.71 208.32,27 209.57,27 210.37,26.2 210.37,20.87 214.43,16.81 214.43,15.18 217.03,12.58 221.22,12.58 228.22,5.59 231.8,5.59 232.12,5.9 234,5.9 235.38,7.29 247.68,7.29 248.74,8.34 251.95,8.34 253.72,6.58 262.22,6.58 263.56,7.91 263.56,9.94 265.28,11.67 268.74,11.67 271.18,14.11 271.18,15.53 273.65,18.01 273.65,19.15 274.67,20.17 274.67,21.69 275.31,22.33 275.31,24.48 275.11,24.67 275.11,26.39 275.93,27.2 275.93,28.69 275.71,28.9 275.71,31.39 276.18,31.85 276.18,32.65 276.37,32.85 276.37,36.58 276.08,36.88 275.83,36.88 v2(275.65,37.06)
  IN3 w0.064: v2(170.02,35.53) 170.09,35.6 170.09,35.65 170.4,35.96 v4(170.4,36.13)
SML0_SMBDATA: length 396
  IN1 w0.064: v1(4.05,46.71) 3.85,46.9 3.66,46.9 3.47,46.71 3.47,45.19 3.65,45.01 4.18,45.01 5.84,43.34 7.08,43.34 7.84,42.58 7.84,39.47 7.49,39.12 7.49,22.29 5.49,20.29 5.49,20.05 4.7,19.26 4.29,19.26 3.97,18.95 3.97,15.85 5.94,13.88 5.94,13.05 7.02,11.97 9.66,11.97 10.6,11.03 13.49,11.03 15.38,12.93 22.7,12.93 25.31,10.32 27.4,10.32 28.86,8.86 29.88,8.86 30.47,9.46 35.06,9.46 35.24,9.28 40.63,9.28 42.54,11.19 47.8,11.19 48.91,10.09 55.32,10.09 59.27,6.14 67.9,6.14 68.45,6.69 72,6.69 75.5,3.19 81.17,3.19 82.35,4.37 87.83,4.37 89.17,5.71 89.69,5.71 93.02,9.04 102.34,9.04 102.84,8.55 109.14,8.55 110.62,7.07 119.16,7.07 121.23,5 122.79,5 128.5,10.72 132.48,10.72 135.58,13.82 136.07,13.82 139.06,16.8 140.56,16.8 141.65,17.89 150.54,17.89 151.41,18.76 154.85,18.76 155.92,19.83 155.92,21.96 156.1,22.14 156.1,24.98 155.09,25.99 155.09,27.01 156.39,28.31 159.99,28.31 160.93,29.25 167.8,29.25 168.23,29.67 168.23,34.33 168.5,34.6 ; 168.69,34.79 168.69,34.79 168.7,34.79 168.75,34.84 168.76,34.84 169.39,35.46 169.39,35.54 169.38,35.54 v1(169.38,35.97) 169.83,36.42 171.35,36.42 171.74,36.03 171.74,35.49 172.39,34.83 173.88,34.83 174.15,35.1 174.15,36.16 175.37,37.37 176.5,37.37 176.77,37.65 177.41,37.65 178.8,36.26 179.68,36.26 v2(179.83,36.41) 180.01,36.23 181.67,36.23 v1(181.86,36.42) ; v1(274.76,35.91) 274.76,36.51 274.92,36.68 275.5,36.68 v2(275.65,36.52)
  IN1 w0.081: 168.5,34.6 168.69,34.79
  IN2 w0.051: v2(275.65,36.52) 275.83,36.7 276,36.7 276.19,36.51 276.19,32.92 276,32.72 276,31.92 275.53,31.46 275.53,28.83 275.75,28.61 275.75,27.28 274.94,26.47 274.94,24.6 275.13,24.41 275.13,22.4 274.49,21.76 274.49,20.24 273.48,19.23 273.48,18.08 271,15.61 271,14.18 268.67,11.85 265.21,11.85 263.38,10.02 263.38,7.99 262.15,6.75 253.79,6.75 252.02,8.52 248.66,8.52 247.61,7.47 235.31,7.47 233.93,6.08 232.05,6.08 231.73,5.76 228.3,5.76 221.3,12.76 217.1,12.76 214.61,15.25 214.61,16.88 210.55,20.94 210.55,26.28 209.65,27.18 208.39,27.18 207.68,27.89 190.8,27.89 190.34,28.35 190.34,31.01 185.06,36.3 182.34,36.3 182.28,36.23 180.01,36.23 v2(179.83,36.41)
SML0B_SMBCLK: length 74
  TOP w0.081: v1(178.84,40.87) 178.77,40.8 176.2,40.8 175.14,39.74 174.87,39.74 UC1.DW33 ; v1(213.27,62.38) 213.14,62.51 213.14,63.12 UE1.D8
  IN1 w0.064: v1(213.27,62.38) 213.37,62.28 213.37,61.82 212.97,61.42 212.85,61.42 212.27,60.84 212.27,58.84 211.93,58.5 211.93,58.24 211.69,58 211.69,55.83 210.85,54.99 210.85,51.98 205.18,46.32 204.78,46.32 204.24,45.78 204.24,29.76 203.92,29.44 203.66,29.44 v2(203.49,29.61) ; v2(179.48,39.59) 179.38,39.59 179.18,39.79 179.18,40.52 v1(178.84,40.87)
  IN2 w0.051: v2(179.48,39.59) 179.41,39.52 179.41,39.05 179.5,38.96 179.62,38.96 180.59,38 181.28,38 181.92,37.35 185.48,37.35 192.71,30.11 202.35,30.11 203.03,29.44 203.32,29.44 v2(203.49,29.61)
SML0B_SMBDATA: length 74.8
  TOP w0.081: UE1.E11 215.1,62.69 214.78,62.37 213.69,62.37 v1(213.69,62.38) ; UC1.DV33 174.36,39.85 174.57,39.63 174.64,39.58 174.79,39.53 175.23,39.53 176.29,40.6 178.47,40.6 v1(178.84,40.23)
  IN1 w0.064: v1(213.69,62.38) 213.56,62.25 213.56,61.74 213.05,61.23 212.93,61.23 212.46,60.76 212.46,58.76 212.12,58.43 212.12,58.16 211.88,57.92 211.88,55.75 211.04,54.91 211.04,51.91 205.26,46.12 204.86,46.12 204.43,45.7 204.43,29.68 203.99,29.25 203.66,29.25 v2(203.49,29.08) ; v2(178.98,39.41) 178.98,40.09 v1(178.84,40.23)
  IN2 w0.051: v2(178.98,39.41) 179.23,39.16 179.23,38.98 179.43,38.78 179.55,38.78 180.51,37.82 181.2,37.82 181.85,37.17 185.41,37.17 192.64,29.94 202.28,29.94 202.96,29.26 203.3,29.26 v2(203.49,29.08)
SML0BALERT#: length 3.9
  TOP w0.081: RC727.1 176.55,40.26 175.65,39.36 174.85,39.36 174.83,39.36 174.76,39.36 174.57,39.43 174.45,39.51 173.98,39.51 173.65,39.85 UC1.DU33
SML1_SMBCLK: length 431
  TOP w0.081: v1(288.58,11.53) 287.72,11.53 RPD105.2
  IN1 w0.064: v1(288.58,11.53) 288.51,11.59 288.12,11.59 287.85,11.86 287.85,12.12 287.62,12.36 285.51,12.36 284.77,13.1 284.77,15.83 284.05,16.55 279.93,16.55 279.37,17.1 279.37,18.07 279.24,18.2 279.1,18.2 277.7,19.59 273.21,19.59 272.77,20.04 272.24,20.04 270.07,22.21 270.07,24.98 272.75,27.66 272.75,33.61 273.45,34.3 273.45,36.32 274.11,36.98 274.11,37.61 275.39,38.9 v2(276.32,38.9)
  IN2 w0.051: v2(172.4,36.07) 173.1,36.07 173.3,36.27 173.61,36.27 173.68,36.19 178.79,36.19 179.62,35.37 182.43,35.37 182.65,35.58 184.76,35.58 189.63,30.71 189.63,28.06 190.51,27.18 207.39,27.18 208.1,26.47 209.35,26.47 209.84,25.98 209.84,20.33 213.28,16.88 213.28,14.48 215.7,12.05 221,12.05 228,5.05 232.02,5.05 232.34,5.37 234.22,5.37 235.6,6.75 247.9,6.75 248.96,7.81 251.7,7.81 253.47,6.04 262.45,6.04 264.13,7.72 264.13,9.76 265.51,11.14 268.97,11.14 271.71,13.89 271.71,15.25 274.2,17.73 274.2,18.94 275.88,20.61 275.88,24.74 275.65,24.97 275.65,26.16 276.51,27.02 276.51,28.93 276.24,29.2 276.24,31.16 276.71,31.63 276.71,32.43 276.95,32.67 276.95,38.1 277.03,38.18 277.03,38.71 276.84,38.9 v2(276.32,38.9) ; v2(122.25,18.41) 122.65,18.41 122.78,18.28 122.78,17.75 121.84,16.82 116.53,16.82 114.04,19.3 112.13,19.3 110.76,17.93 110.31,17.93 108.88,19.36 106.72,19.36 105.85,18.49 105.85,8.91 104.17,7.22 103.68,7.22 99.17,7.22 97.18,5.23 80.56,5.23 78.69,7.1 78.69,8.47 75.77,11.39 31.42,11.39 30.73,12.08 23.59,12.08 18.33,17.33 18.33,18.58 14.15,22.76 14.15,34.48 15.79,36.12 16.03,36.12 v2(16.27,35.88)
  IN3 w0.064: v4(276.79,38.9) 276.6,38.71 276.51,38.71 v2(276.32,38.9) ; v2(122.25,18.41) 122.73,18.41 123.2,17.94 125.08,17.94 125.52,18.39 127.57,18.39 129.79,20.61 133.9,20.61 140.18,26.88 140.18,29.61 142.04,31.47 158.95,31.47 159.76,30.66 166.23,30.66 168.37,32.8 168.37,34.48 168.8,34.9 168.81,34.9 168.86,34.95 168.88,34.95 169.21,35.28 169.47,35.28 169.79,34.96 171.23,34.96 171.41,35.14 171.41,35.22 v4(171.67,35.48) 171.6,35.56 171.6,36.02 171.72,36.14 172.33,36.14 v2(172.4,36.07) ; v2(16.27,35.88) 15.83,36.32 v4(15.56,36.32) 15.46,36.42 15.27,36.42 15.09,36.59 15.09,37.21 15.82,37.94 15.82,40.82 15.28,41.36 10.41,41.36 10.05,41.72 10.05,43.34 9.39,44 9.39,44.99 8.35,46.02 8.35,46.62 8.57,46.84 8.82,46.84 8.95,46.96 v4(8.95,47.09)
  BOTTOM w0.081: v4(15.56,36.32) 15.47,36.41 v7(14.76,36.41) 14.55,36.41 13.85,37.1 13.2,37.1 RPD21.2
SML1_SMBCLK_R: length 3.5
  IN1 w0.089: v1(171.33,35.06) 171.57,35.06 171.76,34.87 171.76,34.61 171.67,34.52 171.35,34.52 171.25,34.61 171.25,34.63 v2(171.26,34.63)
  IN3 w0.064: 171.6,34.51 v4(171.64,34.47)
  IN3 w0.089: 171.6,34.51 171.36,34.51 171.25,34.61 171.25,34.63 v2(171.26,34.63)
  BOTTOM w0.081: CC657.1 RH606.1 RH639.1 171.67,34.51 v4(171.64,34.47)
SML1_SMBDATA: length 430.2
  TOP w0.081: v1(288.58,11.91) 288.4,11.74 287.88,11.74 RPD106.2
  IN1 w0.064: v1(288.58,11.91) 288.45,11.78 288.2,11.78 288.04,11.94 288.04,12.2 287.7,12.55 285.59,12.55 284.96,13.18 284.96,15.91 284.13,16.74 280,16.74 279.56,17.18 279.56,18.15 279.32,18.39 279.18,18.39 277.78,19.79 273.29,19.79 272.84,20.23 272.32,20.23 270.26,22.29 270.26,24.9 272.94,27.58 272.94,33.53 273.64,34.23 273.64,36.24 274.3,36.91 274.3,37.54 275.47,38.71 275.98,38.71 v2(276.32,38.37)
  IN2 w0.051: v2(16.27,36.42) 16.15,36.3 15.72,36.3 13.98,34.56 13.98,22.68 18.16,18.5 18.16,17.26 23.51,11.9 30.66,11.9 31.35,11.21 75.7,11.21 78.52,8.39 78.52,7.02 80.49,5.05 97.25,5.05 99.25,7.05 103.61,7.05 104.24,7.05 106.03,8.83 106.03,18.41 106.79,19.18 108.81,19.18 110.23,17.75 110.84,17.75 112.21,19.12 113.97,19.12 116.45,16.64 121.92,16.64 122.96,17.68 122.96,18.35 122.63,18.68 v2(122.63,18.78) ; v2(172.4,36.61) 172.75,36.25 173.03,36.25 173.22,36.45 173.68,36.45 173.76,36.37 178.86,36.37 179.69,35.55 182.36,35.55 182.57,35.76 184.83,35.76 189.81,30.78 189.81,28.13 190.58,27.35 207.46,27.35 208.17,26.64 209.43,26.64 210.01,26.06 210.01,20.4 213.46,16.96 213.46,14.55 215.78,12.23 221.08,12.23 228.07,5.23 231.95,5.23 232.27,5.55 234.15,5.55 235.53,6.93 247.83,6.93 248.88,7.99 251.78,7.99 253.54,6.22 262.38,6.22 263.95,7.79 263.95,9.83 265.43,11.31 268.89,11.31 271.54,13.96 271.54,15.32 274.02,17.8 274.02,19.01 275.7,20.69 275.7,24.66 275.47,24.89 275.47,26.23 276.33,27.1 276.33,28.86 276.07,29.12 276.07,31.24 276.53,31.7 276.53,32.5 276.77,32.74 276.77,38.17 276.85,38.26 276.85,38.63 276.77,38.72 276.57,38.72 276.32,38.47 v2(276.32,38.37)
  IN3 w0.064: v2(172.4,36.61) 172.4,36.61 172.12,36.33 171.64,36.33 171.41,36.09 171.41,35.85 v4(171.04,35.48) 171.19,35.33 171.19,35.22 171.13,35.15 169.9,35.15 169.56,35.49 169.12,35.49 168.66,35.04 168.18,34.56 168.18,32.88 166.15,30.85 159.84,30.85 159.03,31.66 141.96,31.66 139.99,29.69 139.99,26.96 133.82,20.8 129.71,20.8 127.49,18.58 125.45,18.58 125,18.13 123.28,18.13 v2(122.63,18.78) ; v2(16.27,36.42) 16,36.42 15.91,36.51 15.75,36.51 v4(15.56,36.7) 15.46,36.61 15.35,36.61 15.28,36.67 15.28,37.13 16.02,37.86 16.02,40.9 15.36,41.55 10.48,41.55 10.24,41.8 10.24,43.42 9.58,44.08 9.58,45.07 8.54,46.1 8.54,46.54 8.65,46.65 8.76,46.65 v4(8.95,46.46) ; v2(276.32,38.37) 276.47,38.52 276.6,38.52 v4(276.79,38.33)
  BOTTOM w0.081: RPD22.2 12.9,37.31 v7(13.69,37.31) 13.94,37.31 14.63,36.62 15.47,36.62 v4(15.56,36.7)
SML1_SMBDATA_R: length 2.2
  IN1 w0.089: v2(170.28,34.63) 170.68,35.04 v1(170.68,35.06)
  IN3 w0.064: v4(170.65,34.54) 170.37,34.54 v2(170.28,34.63)
  BOTTOM w0.081: RH638.1 170.97,34.96 170.47,34.96 RH607.1 170.4,34.78 v4(170.65,34.54)
SNDW_RCOMP: length 2.5
  IN1 w0.254: v1(164.25,42.31) 163.85,42.31 v2(163.85,42.31)
  IN3 w0.305: v2(163.85,42.31) 164.31,41.85 v4(164.31,41.54)
  BOTTOM w0.102: v4(164.31,41.54) 165.01,41.54 165.18,41.36 v3(165.32,41.36)
SNUB_CHG1: length 1.5
  BOTTOM w0.508: PR215.2 87.21,32.51 PC236.1
SOC_SVID_ALERT#: length 22.3
  TOP w0.081: v1(112.53,20.04) v3(113.56,20.04)
  IN1 w0.064: v1(129.73,24.2) 129.42,24.2 v2(129.38,24.25) ; v1(112.53,20.04) 112.53,19.97 115.19,17.31 118.9,17.31 123.09,21.5 123.3,21.5 125.4,23.6 v2(125.95,23.6)
  IN3 w0.064: v2(125.95,23.6) 127.92,23.6 128.57,24.25 v2(129.38,24.25)
SOC_SVID_CLK: length 23.1
  IN1 w0.064: v2(129.4,24.85) v1(129.73,24.85) ; v2(125.57,24.04) 125.21,24.04 124.9,23.72 124.77,23.72 124.52,23.96 124.39,23.96 124.3,23.87 124.3,23.74 124.54,23.5 124.54,23.37 124.45,23.27 124.32,23.27 124.07,23.52 123.94,23.52 123.85,23.42 123.85,23.29 124.09,23.05 124.09,22.92 123.12,21.94 122.9,21.94 118.71,17.75 115.51,17.75 v1(112.53,20.74)
  IN3 w0.064: v2(129.4,24.85) 128.55,24.85 127.73,24.04 v2(125.57,24.04)
SOC_SVID_DAT: length 23.2
  IN1 w0.064: v2(129.58,23.75) 129.83,23.75 130.14,24.06 130.14,24.88 129.73,25.3 v1(129.73,25.51) ; v1(112.53,19.34) 115.01,16.86 119.08,16.86 123.27,21.06 123.49,21.06 v2(125.58,23.14)
  IN3 w0.064: v2(125.58,23.14) 128.09,23.14 128.7,23.75 v2(129.58,23.75)
SOC_UART2_MIPI60_RXD: length 3.6
  BOTTOM w0.081: R157.1 125.06,4.2 v3(124.75,4.51) 124.59,4.67 123.91,4.67 123.5,5.07 JMIPI60.56
SOC_UART2_MIPI60_TXD: length 3.5
  BOTTOM w0.081: JMIPI60.54 123,5.02 123.53,4.49 124.17,4.49 124.43,4.23 R249.1
SOLC: length 103.7
  TOP w0.081: JEDP1.21 v1(132.9,83.41)
  IN1 w0.064: v2(207.07,68.3) 207.07,66.12 208.27,64.92 208.27,63.43 207.72,62.88 207.72,62.17 208.31,61.58 208.31,61.01 208.44,60.88 208.44,59.63 208.95,59.12 208.95,59.01 v1(208.7,58.76) ; v1(132.9,83.41) 132.84,83.35 v2(132.84,82.99) 132.84,82.23 133.58,81.49 133.58,81.1 133.9,80.79 133.9,79.74 v1(133.57,79.41)
  IN2 w0.051: v2(132.84,82.99) 132.84,81.72 135.3,79.26 143.68,79.26 144.6,78.34 144.6,75.69 145.91,74.37 149.27,74.37 150.26,74.57 152.16,74.57 154.34,76.76 154.88,76.76 155.69,77.57 162.06,77.57 162.26,77.37 163.88,77.37 164.08,77.57 165.81,77.57 171.6,71.78 173.89,71.78 174.73,70.94 176.53,70.94 179.49,67.98 189.5,67.98 189.71,67.77 195.56,67.77 195.66,67.68 196.16,67.68 196.94,68.45 198.93,68.45 199.02,68.36 205.21,68.36 205.39,68.18 206.12,68.18 206.24,68.3 v2(207.07,68.3)
  IN3 w0.064: v4(133.32,82.14) 133.13,82.14 132.84,82.43 v2(132.84,82.99)
  BOTTOM w0.081: v3(133.32,82.59) v4(133.32,82.14)
SP7_SDWP: length 1.8
  TOP w0.081: QR1.1 279.5,30 279.8,29.69 UCR1.29
SPI0_MOSI_SYS_PWROK_MIPI60: length 4.4
  BOTTOM w0.081: R260.2 R644.2 C220.1 118.17,4.1 118.32,4.1 v3(118.72,4.51) 118.5,4.72 JMIPI60.36
SPI_CLK_VROM0: length 43.9
  TOP w0.081: v1(237.62,10.46) 237.62,10.61 234.67,13.56 UH8.6
  IN1 w0.064: v1(237.62,10.46) 237.62,10.28 236.77,9.43 236.77,7.81 232.85,3.89 227,3.89 224.02,6.87 223.84,6.87 219.26,11.44 v2(219.26,16.32)
  IN3 w0.064: v4(219.26,16.74) v2(219.26,16.32)
  BOTTOM w0.081: v4(219.26,16.74) 219.26,17.15 218.17,18.25 v6(214.79,18.25) 214.23,18.25 213.01,19.47 RH24.1
SPI_IO2_VROM0: length 39.4
  TOP w0.081: v1(225.08,7.01) 225.27,7.2 225.27,8.62 224.79,9.09 224.79,13.31 225.05,13.56 UH8.3
  IN1 w0.064: v2(219.81,16.33) 220.05,16.08 220.05,11.7 220.12,11.63 220.87,11.63 220.95,11.56 220.95,11.45 220.87,11.38 220.48,11.38 220.41,11.3 220.41,11.2 220.48,11.12 222.76,11.12 222.83,11.05 222.83,10.94 222.76,10.87 220.99,10.87 220.92,10.79 220.92,10.69 220.99,10.62 222.76,10.62 222.83,10.54 222.83,10.44 222.76,10.36 221.5,10.36 221.42,10.29 221.42,10.18 221.5,10.11 222.76,10.11 222.83,10.03 222.83,9.93 222.76,9.85 222.01,9.85 221.93,9.78 221.93,9.67 222.01,9.6 222.76,9.6 222.83,9.52 222.83,9.42 222.76,9.35 222.51,9.35 222.45,9.28 222.45,9.15 222.51,9.09 222.76,9.09 222.83,9.02 222.83,8.8 224.04,7.59 224.19,7.59 224.78,7.01 v1(225.08,7.01)
  IN3 w0.064: v4(219.77,16.7) 219.77,16.5 219.81,16.46 v2(219.81,16.33)
  BOTTOM w0.081: v4(219.77,16.7) v6(219.77,17.75) 219.77,18.19 219.22,18.73 214.4,18.73 213.65,19.48 RH26.1
SPI_IO3_VROM0: length 48.5
  TOP w0.081: v1(238.11,10.49) 238.11,10.98 234.26,14.83 UH8.7
  IN1 w0.064: v2(218.78,16) 218.78,11.3 223.65,6.42 223.83,6.42 226.82,3.44 233.03,3.44 237.22,7.63 237.22,9.25 238.11,10.15 v1(238.11,10.49)
  IN3 w0.064: v2(218.78,16) 218.79,16.01 v4(218.79,16.61)
  BOTTOM w0.081: v4(218.79,16.61) 218.79,16.96 218.01,17.74 214.08,17.74 v6(212.94,18.89) 211.98,19.85 211.98,21.39 RH27.1
SPI_SI_VROM0: length 39.9
  TOP w0.081: UH8.5 235.24,12.29 v1(237.12,10.41)
  IN1 w0.064: v2(219.72,15.82) 219.72,11.62 224.02,7.31 224.2,7.31 227.19,4.33 232.66,4.33 236.33,8 236.33,9.62 v1(237.12,10.41)
  IN3 w0.064: v2(219.72,15.82) 219.77,15.77 v4(220.09,15.77)
  BOTTOM w0.081: RH23.1 216.66,19.61 216.74,19.53 219.01,19.53 220.45,18.09 220.45,16.34 v6(220.29,16.18) 220.09,15.98 v4(220.09,15.77)
SPI_SO_VROM0: length 40.3
  TOP w0.081: UH8.2 224.81,14.83 224.59,14.6 224.59,8.91 224.89,8.61 v1(224.89,7.31)
  IN1 w0.064: v2(220.31,16.36) 220.25,16.29 220.25,12.99 220.31,12.93 221.08,12.93 221.14,12.87 221.14,12.7 221.07,12.63 220.32,12.63 220.24,12.56 220.24,12.45 220.32,12.38 222.95,12.38 223.02,12.3 223.02,12.2 222.95,12.12 220.32,12.12 220.24,12.05 220.24,11.94 220.32,11.87 222.95,11.87 223.02,11.79 223.02,11.69 222.95,11.61 221.21,11.61 221.14,11.54 221.14,11.44 221.21,11.36 222.95,11.36 223.02,11.29 223.02,8.88 224,7.9 224.16,7.9 224.75,7.31 v1(224.89,7.31)
  IN3 w0.064: v4(220.17,16.69) 220.31,16.55 v2(220.31,16.36)
  BOTTOM w0.081: v4(220.17,16.69) 220.17,18.07 219.16,19.09 v6(217.52,19.09) 215,19.09 214.92,19.17 RH25.1
SPK_-OUT-L+: length 19.9
  BOTTOM w1.016: 28.34,15.95 28.34,14.82 26.32,12.8 20.59,12.8 20.43,12.64 17.66,12.64 17.05,12.04 v6(14.46,12.04) 13.38,10.96 LA8.1
  vias: v1(26.77,16.43) v1(27.07,16.43) v2(27.4,16.65) v2(27.85,16.65) v4(28.23,16.67) v4(28.48,16.67)
SPK_-OUT-L-: length 19.6
  BOTTOM w1.016: 26.89,15.39 25.57,14.07 20.06,14.07 19.9,13.91 16.89,13.91 16.35,13.37 13.69,13.37 v6(11.61,11.29) LA7.1
  vias: v1(26.77,16.03) v1(27.07,16.03) v2(27.4,16.1) v2(27.85,16.1) v4(26.82,16.1) v4(27.07,16.1)
SPK_-OUT-R+: length 18.3
  BOTTOM w1.016: LA6.1 9.96,11.67 v6(13.05,14.77) 15.93,14.77 16.34,15.18 19.38,15.18 19.54,15.34 23.38,15.34 23.39,15.35 23.75,15.35 23.75,15.34
  vias: v1(25.95,15.21) v1(26.26,15.21) v2(24.94,15.8) v2(25.34,15.8) v4(24.38,15.85) v4(24.61,15.72)
SPK_-OUT-R-: length 20
  BOTTOM w1.016: LA5.1 v6(7.99,11.86) 12.16,16.04 15.4,16.04 15.81,16.45 18.85,16.45 19.01,16.61 22.85,16.61
  vias: v1(25.95,15.66) v1(26.26,15.66) v2(25.89,16.03) v2(26.3,16.03) v4(26,16.36) v4(26.26,16.36)
SPK_DET#: length 204.4
  TOP w0.081: RA65.1 9.69,6.95 9.81,6.83 v1(9.81,6.77) 9.81,6.7 9.81,6.7 JSPK1.5
  TOP w0.089: v1(158.44,46.63) 158.44,46.65 158.3,46.78 158.3,47.68 UC1.CF49
  IN1 w0.064: v2(18.51,11.78) 17.93,12.37 15.62,12.37 13.72,10.48 11.42,10.48 9.81,8.86 v1(9.81,6.77) ; v2(157.7,46.73) 157.8,46.63 v1(158.44,46.63)
  IN2 w0.051: v2(31.97,15.68) 32,15.68 32.66,15.02 78.37,15.02 82.85,10.54 82.85,9.19 84.19,7.85 90.29,7.85 94.5,12.06 94.5,22.12 94.29,22.32 94.29,42.96 95.77,44.44 100.34,44.44 102.15,46.24 103.45,46.24 104.36,47.15 112.28,47.15 115.38,44.06 119.51,44.06 122.54,47.09 125.56,47.09 126.84,48.37 135.66,48.37 136.27,47.76 137.73,47.76 138.02,48.06 143.35,48.06 143.49,47.91 147.8,47.91 148.5,48.62 151.67,48.62 152,48.29 156.15,48.29 v2(157.7,46.73)
  IN3 w0.064: v4(32.35,15.66) 32.33,15.68 v2(31.97,15.68) ; v4(18.89,11.78) v2(18.51,11.78)
  BOTTOM w0.081: v4(32.35,15.66) 31.27,15.66 27.61,12 21.57,12 21.36,11.78 v6(19.39,11.78) v4(18.89,11.78)
SPK_L+:
  vias: v5(13.06,3.98) v5(13.06,3.41) v6(13.56,3.59)
SPK_L-:
  vias: v5(12.19,3.97) v5(12.19,3.39) v6(11.78,4.35)
SPK_R+:
  vias: v5(10.78,3.97) v5(10.78,3.39) v6(10.26,3.28)
SPK_R-:
  vias: v5(9.49,4) v5(9.49,3.43) v6(8.35,3.85)
SPKR: length 189.1
  TOP w0.081: v5(22.58,23.01) 22.7,23.13 23.13,23.13 RA9.1
  IN1 w0.064: v2(159.54,46.01) 159.54,46.38 v1(159.29,46.63)
  IN2 w0.051: v2(159.54,46.01) 159.4,45.87 158.9,45.87 158.38,46.39 157.57,46.39 155.99,47.98 151.7,47.98 151.42,48.25 148.57,48.25 147.91,47.6 143.37,47.6 143.22,47.75 138.15,47.75 137.85,47.45 135.93,47.45 135.32,48.06 126.96,48.06 125.69,46.79 122.67,46.79 119.63,43.75 115.25,43.75 112.15,46.85 104.48,46.85 103.57,45.94 102.27,45.94 100.09,43.75 97.68,43.75 95.6,41.67 95.6,38.39 94.6,37.39 94.6,22.45 94.8,22.24 94.8,11.94 90.41,7.55 84.06,7.55 82.5,9.12 82.5,10.4 78.18,14.72 32.53,14.72 32.23,15.02 26.83,15.02 26.59,15.26 24.87,15.26 24.35,15.78 v2(24.35,16.51)
  IN3 w0.064: v2(159.54,46.01) 159.54,45.91 v4(159.3,45.67) ; v5(22.58,23.01) 22.07,22.5 22.07,18.23 23.79,16.51 v2(24.35,16.51)
  BOTTOM w0.081: v5(22.58,23.01) 22.06,23.54 v6(21.91,23.54) ; RH667.1 159.3,45.65 v4(159.3,45.67)
SRTCRST#: length 10.3
  TOP w0.081: RH572.2 CH46.1 177.91,50.39 176.45,48.93 174.94,48.93 174.42,48.41
  TOP w0.089: v1(173.95,48.27) 174.27,48.27 174.42,48.41
  IN1 w0.064: v1(173.95,48.27) 173.12,48.27 172.75,47.9 172.11,47.9 171.75,47.53 171.15,47.53 v1(169.92,46.31)
SSD_ALERT#: length 15.5
  TOP w0.081: USSD1.W18 207.5,34.2 207.93,34.63 209.15,34.63 v1(209.52,34.26) R724.1
  IN1 w0.064: v1(209.52,34.26) 209.94,33.84 209.94,32.35 210.13,32.16 210.13,27.46 v2(208.74,26.07)
  IN3 w0.064: v2(208.74,26.07) 208.41,25.74 206.65,25.74 v4(206.47,25.56)
SSD_C14: length 76.4
  TOP w0.081: USSD1.C14 204.17,46.2 v1(203.93,46.2) ; R1143.1 199.65,5.62 201.71,5.62 204.49,2.84 214.58,2.84 v1(216.57,4.82)
  IN1 w0.064: v1(203.93,46.2) 203.49,45.76 203.49,44.36 203.87,43.98 203.87,30.9 202.41,29.44 202.41,25.62 203.36,24.67 204.63,24.67 204.95,24.99 205.84,24.99 206.45,24.38 208.84,24.38 209.63,23.59 209.63,23.08 210.18,22.52 210.18,20.96 212.86,18.28 216.02,18.28 216.66,17.64 216.66,15.37 214.2,12.91 214.2,6.2 215.57,4.82 v1(216.57,4.82)
SSD_CLK_T: length 8.8
  TOP w0.081: USSD1.U17 207.36,35.53 v5(209.72,35.53) R444.2 v3(210.24,36.42)
  BOTTOM w0.081: v5(209.72,35.53) 207.7,37.56 JSSD1.12
SSD_D15: length 22
  TOP w0.081: v1(206.47,29.31) 208.38,29.31 209.74,30.67 R1134.2
  IN1 w0.064: v1(205.1,45.27) 205.53,44.85 205.53,41.81 205.13,41.41 205.13,31.68 205.53,31.29 205.53,30.25 v1(206.47,29.31)
SSD_DATA_T: length 6.9
  TOP w0.081: USSD1.U18 207.53,34.9 v5(209.67,34.9) R445.2
  BOTTOM w0.081: v5(209.67,34.9) 209.23,35.34 209.23,35.77 208.44,36.56 JSSD1.13
SSD_F15: length 20.7
  TOP w0.081: R1133.1 210.23,30.08 209.19,29.04 206.23,29.04 v1(205.96,29.31)
  IN1 w0.064: v1(205.1,43.67) 205.36,43.41 205.36,41.88 204.97,41.48 204.97,31.61 205.36,31.22 205.36,29.91 v1(205.96,29.31)
SSD_FORCE_ROM_H: length 14.8
  TOP w0.081: R609.2 211.46,34.26 v3(212.2,34.26) 212.2,32.83 211.79,32.41 209.13,32.41 208.35,31.63 208.35,31.24 207.62,30.52 204.91,30.52 203.93,31.5 203.93,31.98 203.87,32.04 203.11,32.04 202.74,31.67 USSD1.AA12
SSD_FORCE_ROM_H_R: length 12.3
  TOP w0.081: v5(208.95,34.23) 209.55,33.63 R609.1 R681.1
  BOTTOM w0.081: v5(208.95,34.23) 208.48,34.71 207.49,34.71 207.34,34.56 JSSD1.15 205.48,34.56 205,35.04 205,37.72 203.65,39.06 TP85.1
SSD_FORCE_ROM_I: length 27.2
  TOP w0.081: USSD1.B4 196.46,46.71 v5(196.99,46.71) 197.33,46.71 197.59,46.97 197.59,49.9 R678.1
  IN2 w0.051: v5(208.5,35.94) 204.29,40.16 197.53,40.16 197.06,40.63 197.06,46.65 v5(196.99,46.71)
  BOTTOM w0.081: JSSD1.14 208.12,35.56 v5(208.5,35.94) ; v5(196.99,46.71) v3(197.52,46.71)
SSD_FORCE_ROM_T1_S: length 15.9
  TOP w0.081: v3(210.37,40.97) R679.1 209.25,42.01 v5(209.12,41.88)
  IN1 w0.064: v5(209.12,41.88) 207.72,43.28 206.31,43.28 v1(205.9,42.87) 205.86,42.83 205.86,39.86 v2(206.04,39.69)
  IN3 w0.064: v4(206.47,33.56) 206.47,39.26 v2(206.04,39.69)
SSD_FORCE_ROM_T2: length 6.7
  TOP w0.081: USSD1.AB4 195.55,30.12 195.55,27.21 195.17,26.83 R610.2 194.7,26.43 194.33,26.06 v3(194.33,25.27)
SSD_FORCE_ROM_T2_R: length 20.4
  TOP w0.081: R680.1 R610.1 194.62,25.84 v1(194.6,25.82)
  IN1 w0.064: v1(194.6,25.82) 194.6,26.83 193.83,27.6 193.83,29.65 194.51,30.32 v2(194.51,30.95)
  IN3 w0.064: v4(205.23,32.4) 204.73,32.4 202.78,30.44 195.02,30.44 v2(194.51,30.95)
  BOTTOM w0.081: JSSD1.17 205.39,32.56 v4(205.23,32.4) 204.91,32.4 v3(204.82,32.49)
SSD_H14: length 19.1
  TOP w0.081: v1(205.52,29.31) 205.97,28.86 211.03,28.86 R1150.1 ; USSD1.H14 v1(204.82,41.76)
  IN1 w0.064: v1(204.82,41.76) 204.8,41.74 204.8,31.55 205.2,31.15 205.2,29.63 v1(205.52,29.31)
SSD_H14_R: length 1.2
  TOP w0.254: R1135.2 211.66,28.91 R1150.2 212.25,28.91 R1136.1
SSD_JTAG_TCK: length 17.2
  TOP w0.081: USSD1.N17 207.83,39.2 207.83,46.32 v5(209.07,47.56)
  BOTTOM w0.081: v5(209.07,47.56) JSSD1.2 204.73,47.56 TP41.1
SSD_JTAG_TDI: length 17.7
  TOP w0.081: v5(209.06,45.56) 208.2,44.7 208.2,37.97 USSD1.R17
  BOTTOM w0.081: TP43.1 202.79,47.73 204.96,45.56 JSSD1.4 v5(209.06,45.56)
SSD_JTAG_TDO: length 14.5
  TOP w0.081: v5(209.12,44.56) 208.38,43.82 208.38,37.35 USSD1.R18
  BOTTOM w0.081: TP44.1 204.31,45.82 205.57,44.56 JSSD1.5 v5(209.12,44.56)
SSD_JTAG_TMS: length 15.1
  TOP w0.081: USSD1.N18 208.02,38.59 208.02,45.5 v5(209.07,46.56)
  BOTTOM w0.081: TP42.1 204.72,46.56 JSSD1.3 v5(209.07,46.56)
SSD_JTAG_TRST#: length 15.8
  TOP w0.081: USSD1.L18 207.11,40.07 207.11,47.85 207.81,48.55 v5(209.2,48.55)
  BOTTOM w0.081: TP40.1 205.13,48.56 JSSD1.1 209.2,48.56 v5(209.2,48.55)
SSD_PERST#: length 5.9
  TOP w0.081: USSD1.D7 198.39,45.59 198.39,49.5 198.58,49.7 R470.2 R471.2
SSD_PWR1_EN_R: length 3.8
  TOP w0.081: U733.3 205.65,26.77 205.9,26.52 R6185.2 R6166.2 v3(206.31,25)
SSD_PWR2_EN: length 69
  TOP w0.081: v1(207.55,57.5) 207.61,57.57 208.82,57.57 209.23,57.16 UE1.M4
  IN1 w0.064: v5(197.79,16.61) 197.79,18.47 197.23,19.03 197.23,25.96 196.42,26.78 196.42,30.14 197.42,31.14 197.42,36.56 196.69,37.28 196.69,44.64 197.8,45.75 197.8,46.69 199.76,48.65 200.23,48.65 201.35,48.65 201.51,48.81 203.39,48.81 205.81,51.23 205.81,53.69 207.75,55.64 207.75,57.3 v1(207.55,57.5) ; v5(187.78,10.21) 187.78,10.81 188.14,11.17 188.82,11.17 v1(189.01,10.98)
  BOTTOM w0.081: v5(187.78,10.21) 187.68,10.31 187.68,14.78 190.02,17.12 v3(191.87,17.12) 197.28,17.12 v5(197.79,16.61)
SSD_PWR2_EN_P: length 3.5
  TOP w0.254: CE431.1 199.63,6.16 RE490.2 ; CE431.1 198.12,6.89 197.77,6.89 197.66,7.01 PU1500.11 ; CE431.1 198.83,6.14 RE491.1
SSD_PWR2_EN_R: length 2.8
  TOP w0.081: U734.3 188.43,11.57 R6183.2 R6193.2 v3(189.87,11.57)
SSD_PWR2_FB: length 4.6
  TOP w0.254: R1143.2 197.72,4.8 R1142.2 197.58,4.66 R1141.1 196.87,4.72 PR1503.2 196.97,5.33 197.43,5.79 197.43,6.73 197.16,7 PU1500.10
SSD_PWR3_EN: length 13.3
  TOP w0.081: R6164.1 216.68,47.12 v1(216.51,47.29) ; UE1.L9 213.84,57.62 213.84,56.04 214.52,55.36 214.52,55.07 214.71,54.88 v1(215.01,54.88)
  IN1 w0.064: v1(215.01,54.88) 214.92,54.79 214.92,53.83 215.12,53.63 215.12,53.01 214.54,52.43 214.54,51.61 215.92,50.23 215.92,48.77 216.51,48.18 v1(216.51,47.29)
SSD_PWR3_EN_P: length 3.4
  TOP w0.254: PU1400.15 214.69,27.42 213.8,26.53 CE410.1 213.72,26.52 RE402.2 212.22,26.52 RE412.1
SSD_PWR3_EN_R: length 9.5
  TOP w0.081: R6164.2 R6184.2 219.45,46.52 219.68,46.29 219.68,44.49 219.36,44.17 218.92,44.17 218.54,43.79 218.54,42.84 218.28,42.58 216.69,42.58 216.5,42.78 U735.3
SSD_PWR3_FB: length 5.5
  TOP w0.081: 212.26,29.49 v1(212.26,29.49)
  TOP w0.254: PU1400.13 214.53,28.42 214.28,28.17 v1(213.79,28.17) ; R1134.1 211.66,30.09 R1133.2 212.26,30.08 R1000.1 R1136.2
  IN1 w0.254: v1(213.79,28.17) 213.22,28.17 212.26,29.12 v1(212.26,29.49)
SSD_SCP#: length 13.8
  TOP w0.081: R787.1 v1(211.69,52.86) ; v1(212.83,59.98) 210.67,59.98 v1(210.3,60.36)
  IN1 w0.064: v2(210.25,60.03) 210.25,60.31 v1(210.3,60.36) ; v1(212.83,59.98) 212.83,57.88 212.75,57.8 212.75,57.56 212.96,57.36 212.96,56.92 212.25,56.21 212.25,55.6 212.01,55.36 212.01,54.22 211.69,53.9 v1(211.69,52.86)
  IN3 w0.064: v4(210.92,60.21) 210.43,60.21 v2(210.25,60.03)
  BOTTOM w0.081: v4(210.92,60.21) RE48.1 209.61,60.21 v3(209.39,60.43)
SSD_SCP#_R: length 13.2
  TOP w0.081: R787.2 211.03,51.26 v1(210.57,50.8)
  IN1 w0.064: v1(205.1,42.07) 204.8,42.37 204.8,45.55 205.01,45.76 205.53,45.76 v1(210.57,50.8)
SSD_SCP_PWR_EN: length 97.6
  TOP w0.081: RE402.1 212.41,25.61 v5(212.24,25.44) ; v1(215.74,5.08) 213.68,3.02 204.57,3.02 203.26,4.33 203.26,5.54 202.65,6.14 RE490.1 ; UE1.N6 210.76,56.69 v1(210.76,56.72) ; v1(199.75,27.85) 206.34,27.85 207.35,26.84 207.35,26.34 R6166.1 206.89,25.65 v1(207.74,24.8)
  IN1 w0.064: v1(215.74,5.08) 215.69,5.03 215.6,5.03 214.36,6.27 214.36,12.84 216.83,15.3 216.83,17.71 215.6,18.94 212.66,18.94 211.88,19.72 211.88,21.92 211.96,22 211.96,22.77 212.4,23.21 212.4,25.28 v5(212.24,25.44) 211.37,25.44 210.73,24.8 v1(207.74,24.8) ; v1(210.76,56.72) 210.33,56.72 209.86,56.24 209.86,52.57 209.2,51.92 208.41,51.92 207.88,51.38 207.88,50.32 205.08,47.52 202.14,47.52 201.96,47.34 200.57,47.34 200.35,47.13 200.35,46.26 200.53,46.09 200.53,45.3 200.29,45.06 200.29,31.26 199.75,30.71 v1(199.75,27.85)
SSD_SUSCLK: length 50.1
  TOP w0.081: v5(203.75,50.27) R6152.2 204.69,49.85 204.69,45.66 USSD1.D14
  IN2 w0.051: v2(174.63,49.1) 174.66,49.12 174.66,49.28 174.61,49.32 174.61,49.37 174.66,49.42 174.66,50.29 175.15,50.78 180.68,50.78 181.34,50.13 183.38,50.13 183.47,50.04 186.72,50.04 187.78,48.98 190.59,48.98 191.5,49.88 192.6,49.88 193.46,50.74 194.92,50.74 195.33,50.33 199.63,50.33 200.39,51.09 202.93,51.09 v5(203.75,50.27)
  IN3 w0.064: v2(174.63,49.1) 174.66,49.12 174.66,49.66 174.82,49.83 175.41,50.42 175.59,50.42 177.77,52.6 177.77,56.02 178.2,56.45 178.2,56.84 178.34,56.98 v4(178.34,57.76)
  BOTTOM w0.081: v3(178.34,57.31) v4(178.34,57.76) 178.7,58.11 R6155.2
SUS_ON_EC: length 40.3
  TOP w0.081: UE1.D2 207.54,63.56 207.05,64.05 205.83,64.05 205.58,64.3 v1(204.44,64.3) 203.61,64.3 203.4,64.08 RE95.2 ; RE22.1 186.8,48.74 186.72,48.82 v3(186.72,49) 186.72,49.95 187,50.23 v1(187.56,50.23)
  IN1 w0.064: v1(187.56,50.23) 187.56,50.09 v2(187.99,49.67) ; v2(204.88,52.17) 204.88,54.39 204.5,54.78 204.5,56.64 203.91,57.24 203.91,63.26 204.44,63.79 v1(204.44,64.3)
  IN2 w0.051: v2(204.88,52.17) 204.58,51.87 200.06,51.87 199.31,51.12 197.73,51.12 197.14,51.71 194.77,51.71 194.29,51.23 193.22,51.23 192.49,50.49 190.51,50.49 189.68,49.67 v2(187.99,49.67)
SUS_ON_P: length 137.9
  TOP w0.081: UC23.4 172.39,55.75 171.94,55.29 v5(170.21,55.29) ; RE22.2 RE21.1 189.03,49.5 189.12,49.58 UC5.4 190.1,49.58 RC695.2 191.97,49.34 v5(192.13,49.5) ; RC736.1 93.21,65.91 93.38,65.75 v1(93.38,65.48)
  IN1 w0.064: v5(170.21,55.29) 170.35,55.43 170.35,61.5 170.89,62.04 170.89,67 166.53,71.35 165.19,71.35 164.17,72.37 154.32,72.37 153.71,71.75 143.53,71.75 143.28,71.51 136.72,71.51 135.86,70.65 126.08,70.65 125.83,70.9 120.75,70.9 120.18,70.34 118.39,70.34 117.67,71.06 109.88,71.06 104.46,65.64 98.92,65.64 98.33,66.22 95.81,66.22 95.63,66.41 94.63,66.41 93.71,65.48 v1(93.38,65.48)
  BOTTOM w0.081: v5(170.21,55.29) 169.69,54.77 168.5,54.77 168.31,54.58 168.31,52.55 168.81,52.05 174.35,52.05 175.21,52.91 178.19,52.91 180.77,55.48 187.06,55.48 190.4,52.14 190.75,52.14 v3(191.29,51.6) 191.29,50.52 192.13,49.68 v5(192.13,49.5)
SUSCLK: length 20.2
  TOP w0.081: UC1.DF49 v1(168.06,49.5) 168.05,49.5 167.79,49.77 167.62,49.77 CH49.1
  IN1 w0.064: v2(174.45,57.8) 174.18,57.52 174.18,55.25 174.47,54.96 174.47,52.65 172.81,50.99 171.64,50.99 170.32,49.67 168.35,49.67 168.17,49.5 v1(168.06,49.5)
  IN3 w0.064: v2(174.45,57.8) 174.54,57.89 v4(174.85,57.89)
  BOTTOM w0.081: v4(174.85,57.89) 175.04,58.08 v3(175.8,58.08) 177.92,58.08 R6155.1 RW8.2
SUSCLK_R: length 5.9
  TOP w0.081: UWL1.27 v1(182.17,58.37)
  IN1 w0.064: v1(182.17,58.37) 181.93,58.13 v2(181.93,58.04)
  IN3 w0.064: v2(181.93,58.04) 181.9,58.07 v4(181.58,58.07)
  BOTTOM w0.081: v4(181.58,58.07) 180.51,58.07 v3(179.58,59) 179.48,58.9 RW8.1
SVID_ALERT#: length 63.8
  TOP w0.081: v1(102.94,48.79) PR1127.2 ; RC601.1 v1(111.32,20.04)
  IN1 w0.064: v1(102.94,48.79) v2(102.59,48.79) ; v1(111.32,20.04) 111,20.04 v2(110.97,20.06)
  IN3 w0.064: v2(110.97,20.06) 110.97,20.06 110.64,19.74 106.41,19.74 105.74,19.07 92.87,19.07 89.24,22.69 89.24,46.25 90.74,47.75 101.44,47.75 102.49,48.79 v2(102.59,48.79)
SVID_ALERT#_VR: length 1.7
  TOP w0.081: PU1100.14 v1(101.12,48.56)
  IN1 w0.064: v1(102.03,48.79) 101.79,48.56 v1(101.12,48.56)
SVID_CLK: length 67.6
  TOP w0.081: v1(102.94,47.91) PR1129.2 ; RC605.1 v1(111.32,20.74)
  IN1 w0.064: v1(102.94,47.91) v2(102.59,47.91) ; v2(110.9,20.62) 111.02,20.74 v1(111.32,20.74) 111.32,20.48 111.58,20.22 111.58,19.54 111.93,19.19 111.93,18.72 v1(111.94,18.71)
  IN3 w0.064: v2(110.9,20.62) 110.8,20.71 110.04,20.71 109.51,20.18 106.22,20.18 105.57,19.53 93.04,19.53 89.69,22.88 89.69,46.07 90.54,46.92 93.43,46.92 93.52,47.01 93.52,47.21 93.62,47.3 93.75,47.3 93.84,47.21 93.84,46.98 93.93,46.89 94.07,46.89 94.16,46.98 94.16,47.21 94.25,47.3 94.38,47.3 94.48,47.21 94.48,46.98 94.57,46.89 94.7,46.89 94.79,46.98 94.79,47.21 94.89,47.3 95.02,47.3 95.11,47.21 95.11,46.98 95.2,46.89 95.34,46.89 95.43,46.98 95.43,47.21 95.52,47.3 95.65,47.3 95.75,47.21 95.75,46.98 95.84,46.89 95.97,46.89 96.06,46.98 96.06,47.21 96.16,47.3 96.29,47.3 96.38,47.21 96.38,47.01 96.47,46.92 101.6,46.92 v2(102.59,47.91)
SVID_CLK_VR: length 2.9
  TOP w0.081: PU1100.12 v1(101.12,47.76)
  IN1 w0.064: v1(101.12,47.76) 101.25,47.76 101.38,47.89 101.38,48.21 101.43,48.26 101.63,48.26 101.7,48.19 101.7,47.64 101.75,47.58 101.98,47.58 102.03,47.63 v1(102.03,47.91)
SVID_DAT: length 65.4
  TOP w0.081: RC603.1 v1(111.32,19.34) ; PR1128.2 v1(102.94,49.68)
  IN1 w0.064: v2(111,19.4) 111.06,19.34 v1(111.32,19.34) ; v1(102.94,49.68) 102.66,49.68 v2(102.61,49.63)
  IN3 w0.064: v2(111,19.4) 110.88,19.29 106.59,19.29 105.92,18.62 92.68,18.62 88.8,22.51 88.8,46.44 90.99,48.63 96.88,48.63 97.07,48.81 101.62,48.81 102.44,49.63 v2(102.61,49.63)
SVID_DAT_VR: length 2.9
  TOP w0.081: PU1100.13 v1(101.11,48.16)
  IN1 w0.064: v1(101.11,48.16) 100.85,48.43 100.85,48.65 101.88,49.68 v1(102.03,49.68)
SW_TBT_L_USB20_N1: length 13.6
  TOP w0.091: v1(13.11,54.06) 13.22,54.06 13.55,53.74 13.55,52.97 14.07,52.45 14.88,52.45 15.09,52.66 15.09,52.88 15.19,52.98 UM1.2
  IN1 w0.081: v1(13.8,62.27) 13.7,62.27 13.63,62.2 13.63,61.95 14.38,61.2 14.38,60.62 14.26,60.49 14.26,59.37 14.52,59.11 14.52,56.11 14.12,55.72 14.12,54.91 13.39,54.18 13.23,54.18 v1(13.11,54.06)
SW_TBT_L_USB20_N1_R: length 3.5
  TOP w0.091: ML6.2 12.14,62.27 12,62.42 11.8,62.42 D408.2 11.38,62.39 10.48,62.39 10.4,62.32 9.83,62.32 9.69,62.17 JUSBC1.A7
SW_TBT_L_USB20_N2: length 17.5
  TOP w0.091: UM1.4 15.99,52.98 15.89,52.88 15.89,52.75 15.98,52.66 16.52,52.66 17.32,53.46 17.88,53.46 v5(18.26,53.84)
  IN3 w0.081: v4(16.73,62.46) 16.92,62.27 17.17,62.27 17.5,61.95 17.5,57.89 19.43,55.95 19.43,54.97 18.79,54.33 17.89,54.33 17.66,54.09 17.66,53.67 17.75,53.57 18,53.57 v5(18.26,53.84)
  BOTTOM w0.091: ML7.1 15.53,62.52 15.66,62.38 v7(16.23,62.38) 16.66,62.38 v4(16.73,62.46)
SW_TBT_L_USB20_N2_R: length 6.7
  TOP w0.091: JUSBC1.B7 8.49,62.92 v5(8.53,62.97)
  BOTTOM w0.091: ML7.2 13.49,62.52 13.34,62.37 13.12,62.37 D410.2 12.69,62.37 v7(11.97,62.37) 10.33,62.37 10.03,62.67 9.16,62.67 9.05,62.77 8.72,62.77 v5(8.53,62.97)
SW_TBT_L_USB20_P1: length 13.5
  TOP w0.091: v1(13.1,54.47) 13.75,53.82 13.75,53.06 14.15,52.66 14.8,52.66 14.89,52.75 14.89,52.88 14.79,52.98 UM1.1
  IN1 w0.081: v1(13.1,54.47) 13.19,54.38 13.31,54.38 13.92,54.99 13.92,55.8 14.32,56.2 14.32,59.03 14.06,59.29 14.06,60.57 14.19,60.7 14.19,61.12 13.44,61.87 13.44,62.29 13.62,62.46 13.62,62.58 v1(13.8,62.77)
SW_TBT_L_USB20_P1_R: length 3.5
  TOP w0.091: JUSBC1.A6 9.72,62.67 9.87,62.52 10.32,62.52 10.4,62.6 11.34,62.6 D407.1 11.78,62.62 11.95,62.62 12.09,62.77 ML6.3
SW_TBT_L_USB20_P2: length 17.5
  TOP w0.091: UM1.3 15.59,52.98 15.69,52.88 15.69,52.66 15.9,52.45 16.61,52.45 17.4,53.25 v5(18.26,53.25)
  IN3 w0.081: v4(16.73,62.08) 17.09,62.08 17.3,61.87 17.3,57.8 19.23,55.87 19.23,55.05 18.71,54.53 17.81,54.53 17.46,54.17 17.46,53.58 17.67,53.38 18.14,53.38 v5(18.26,53.25)
  BOTTOM w0.091: ML7.4 15.53,62.02 15.69,62.18 16.63,62.18 v4(16.73,62.08)
SW_TBT_L_USB20_P2_R: length 6.7
  TOP w0.091: v5(8.53,62.38) 8.49,62.42 JUSBC1.B6
  BOTTOM w0.091: v5(8.53,62.38) 8.72,62.57 8.97,62.57 9.07,62.46 9.95,62.46 10.25,62.16 v7(10.48,62.16) 12.69,62.16 D409.1 13.12,62.16 13.34,62.16 13.49,62.02 ML7.3
SW_TBT_R_USB20_N1: length 13.3
  TOP w0.091: UM2.2 274.91,56.72 274.96,56.67 274.96,56.61 275.08,56.49 v2(275.17,56.49) ; v1(277.67,64.11) 277.79,64.23 277.79,66.3 277.61,66.49 ML16.1
  IN1 w0.081: v2(277.59,63.73) 277.67,63.8 v1(277.67,64.11)
  IN3 w0.081: v2(275.17,56.49) 275.17,56.43 275.25,56.35 275.42,56.35 275.75,56.68 275.75,57.7 276.11,58.06 276.11,61.24 277.93,63.07 277.93,63.42 277.87,63.49 277.65,63.49 277.59,63.55 v2(277.59,63.73)
SW_TBT_R_USB20_N1_R: length 9.4
  TOP w0.091: JUSBC2.A7 282.64,74.23 arc(282.36,74.17) 282.13,74.01 v7(280.8,72.69) 278.24,70.12 277.89,70.12 277.59,69.82 277.59,69.3 D416.2 277.63,69.14 arc(277.73,69) 277.76,68.84 277.76,68.57 arc(277.72,68.38) ML16.2
SW_TBT_R_USB20_N2: length 21.3
  TOP w0.091: v5(271.37,59.97) 271.75,60.35 v7(272.07,60.35) 274.2,60.35 274.33,60.22 275.41,60.22 275.77,59.86 275.77,58.64 275.17,58.03 275.17,57.47 275.03,57.34 274.96,57.34 274.78,57.52 UM2.4
  IN3 w0.081: v4(276.48,67.95) 276.22,67.95 276.13,67.87 276.13,66.24 274.62,64.73 272.51,64.73 271.23,63.45 271.23,62.08 272.1,61.2 272.1,60.55 271.91,60.35 271.75,60.35 v5(271.37,59.97)
  BOTTOM w0.091: v4(276.48,67.95) 276.48,68.07 276.58,68.17 276.81,68.17 ML17.1
SW_TBT_R_USB20_N2_R: length 9.6
  TOP w0.091: JUSBC2.B7 284.3,73.48 v5(284.25,73.43)
  BOTTOM w0.091: ML17.2 278.09,69.44 278.09,69.73 278.22,69.86 D418.2 278.85,70.1 278.85,70.49 282.04,73.68 284,73.68 v5(284.25,73.43)
SW_TBT_R_USB20_P1: length 13.3
  TOP w0.091: ML16.4 278.11,66.49 278,66.38 278,64.16 v1(278.05,64.11) ; v2(275.17,55.95) 275.17,55.97 274.81,56.32 UM2.1
  IN1 w0.081: v2(278.13,63.73) 278.05,63.81 v1(278.05,64.11)
  IN3 w0.081: v2(278.13,63.73) 278.13,62.98 276.31,61.16 276.31,57.97 275.95,57.62 275.95,56.6 275.5,56.15 275.36,56.15 v2(275.17,55.95)
SW_TBT_R_USB20_P1_R: length 9.4
  TOP w0.091: JUSBC2.A6 282.97,73.73 arc(282.92,73.74) 282.87,73.77 arc(282.83,73.83) 282.82,73.91 arc(282.8,73.96) 282.76,74 arc(282.73,74.01) 282.71,74.01 282.64,74.01 arc(282.43,73.97) 282.25,73.85 v7(278.85,70.44) 278.32,69.92 277.97,69.92 277.8,69.74 277.8,69.61 D415.1 278.1,69.17 arc(278,69.02) 277.96,68.84 277.96,68.57 arc(278,68.38) ML16.3
SW_TBT_R_USB20_P2: length 21.3
  TOP w0.091: v5(271.37,60.55) 274.29,60.55 274.42,60.43 v7(274.86,60.43) 275.5,60.43 275.97,59.95 275.97,58.55 275.37,57.95 275.37,57.39 275.11,57.14 274.45,57.14 274.44,57.12
  IN3 w0.081: v5(271.37,60.55) 271.83,60.55 271.91,60.63 271.91,61.12 271.03,61.99 271.03,63.53 272.43,64.93 274.54,64.93 275.93,66.32 275.93,67.95 v4(276.21,68.22)
  BOTTOM w0.091: v4(276.21,68.22) 276.35,68.22 276.45,68.32 276.45,68.51 ML17.4
SW_TBT_R_USB20_P2_R: length 9.6
  TOP w0.091: JUSBC2.B6 284.29,73.98 v5(284.25,74.01)
  BOTTOM w0.091: v5(284.25,74.01) 284.12,73.89 281.96,73.89 v7(280.68,72.6) 278.62,70.54 278.4,70.54 D417.1 278.16,70.09 277.9,69.82 277.76,69.82 ML17.3
SYNC: length 35.4
  IN1 w0.254: v1(98.01,49.43) 98.01,49.88 98.22,50.09 v2(100.53,50.09) ; v1(101.56,35.53) 101.51,35.53 101,35.03 v2(100.55,35.03) v2(100.55,33.55) ; v1(101.54,26.36) 101.54,25.98 101.09,25.53 v2(100.6,25.53)
  IN3 w0.254: v2(100.6,25.53) 101.01,25.93 101.01,27.71 99.97,28.75 99.97,30.15 100.73,30.91 100.73,33.37 v2(100.55,33.55) ; v2(100.53,50.09) 100.66,50.22 102.63,50.22 103.09,49.76 103.09,47.53 101.25,45.69 101.25,41.63 101.44,41.44 101.44,40.03 100.38,38.96 100.38,37.46 100.81,37.03 100.81,35.28 v2(100.55,35.03)
SYS_PRES#: length 58.9
  TOP w0.081: v1(90.51,3.34) 90.51,4.34 v5(90.84,4.67) 91.33,5.17 PR605.1 91.31,5.46 PU600.5
  IN1 w0.064: v1(42.22,7.55) 43.28,8.61 43.29,8.61 43.29,8.83 43.57,9.1 44.27,9.1 45.72,7.65 53.44,7.65 57.82,3.28 60.68,3.28 62.05,4.65 68.52,4.65 69.07,5.2 71.38,5.2 74.88,1.7 87.78,1.7 89.42,3.34 v1(90.51,3.34)
  BOTTOM w0.081: v5(90.84,4.67) v6(90.22,4.67)
SYS_PWROK: length 246.4
  IN1 w0.064: v1(209.5,61.16) 209.5,59.83 v2(209.71,59.62) ; v2(199.04,51.6) 199.04,51.94 199.72,52.61 200.02,52.61 200.94,53.53 200.94,53.66 200.94,53.67 200.94,53.8 201.15,54.02 201.15,55.38 201.56,55.79 201.56,58.62 v2(201.16,59.02) 201.16,59.02 200.99,59.19 200.99,60.62 v1(201.56,61.19)
  IN2 w0.051: v2(209.71,59.62) 209.65,59.56 208.99,59.56 208,59.56 207.71,59.28 205.04,59.28 204.84,59.08 202.83,59.08 202.59,58.85 201.33,58.85 v2(201.16,59.02) ; v2(190.94,50.82) 192.55,50.82 193.11,51.38 194.23,51.38 194.71,51.87 198.77,51.87 v2(199.04,51.6)
  IN3 w0.064: v4(104.58,7.94) 104.67,8.03 107.95,8.03 110.54,5.44 111.94,5.44 112.46,4.92 113.97,4.92 116.04,2.85 116.7,2.85 116.96,3.11 v4(117.13,3.11) ; v4(190.66,51.6) 190.94,51.32 v2(190.94,50.82) 190.46,50.35 190.46,49.3 190.81,48.95 190.81,48.51 191.54,47.78 191.54,41.99 189.99,40.44 189.99,36.58 189.71,36.3 189.14,36.3 188.78,35.94 188.78,33.72 186.79,31.72 v4(185.71,31.72)
  BOTTOM w0.081: v4(190.66,51.6) 190.48,51.78 190.24,51.78 186.9,55.12 180.92,55.12 177.3,51.5 168.41,51.5 166.51,53.39 163.7,53.39 163.33,53.02 155.57,53.02 155.14,53.45 138.78,53.45 137.35,54.88 122.94,54.88 120.56,57.25 119.92,57.25 119.27,56.6 110.16,56.6 109.56,57.2 108.64,57.2 108.04,56.6 104.66,56.6 103.24,55.18 103.24,47.84 100.01,44.62 95.06,44.62 92.67,42.23 92.67,28.37 94.35,26.69 96.83,26.69 97.9,25.62 103.19,25.62 105.19,23.62 105.19,19.28 104.05,18.14 104.05,8.48 v4(104.58,7.94) ; RH594.2 v3(175.99,30.52) 176.44,30.07 176.44,27.79 177.09,27.14 179.28,27.14 180.94,28.8 182.09,28.8 185.01,31.72 v4(185.71,31.72)
SYS_PWROK_R: length 6
  IN1 w0.064: v1(171.98,33.23) 172.63,33.23 173.6,34.19 v2(175.55,34.19)
  IN3 w0.064: v2(175.55,34.19) 175.76,34.19 v4(175.99,34.43)
  BOTTOM w0.081: v4(175.99,34.43) 175.04,33.48 v6(175.04,33.31)
SYS_RESET#: length 84
  TOP w0.081: v3(185.39,31.47) 185.17,31.47 v1(184.79,31.85) 184.05,32.59 184.05,33.24 v1(184.23,33.42) 184.55,33.42 CC651.1 184.98,32.99 RC244.1 185.35,33.78 185.54,33.97 RC432.1
  IN1 w0.064: v1(184.23,33.42) 184.23,33.71 184.16,33.78 183.57,33.78 183.03,34.33 177.41,34.33 177.18,34.09 176.47,34.09 175.8,33.42 173.14,33.42 172.59,32.87 170.9,32.87 170.54,33.23 v1(170.03,33.23) ; v1(184.79,31.85) v2(185.12,31.85)
  IN3 w0.064: v4(218.09,54.14) 217.47,54.14 216.87,53.54 213.32,53.54 213.2,53.65 206.47,53.65 205.94,53.12 205.94,52.48 204.61,51.16 201.34,51.16 200.79,50.61 198.8,50.61 198.63,50.44 197.77,50.44 196.43,49.1 195.73,49.1 195.04,48.41 195.04,35.79 193.14,33.88 193.14,32.04 193.26,31.91 193.26,31.34 192.69,30.77 191.68,30.77 191.23,30.33 191.23,29.73 191.07,29.56 189.62,29.56 187.84,27.78 185.57,27.78 185.37,27.58 184.95,27.58 184.44,28.09 184.44,28.97 184.02,29.39 184.02,31.08 184.79,31.85 v2(185.12,31.85)
  BOTTOM w0.081: v4(218.09,54.14) 218.09,54.66 218.22,54.79 218.22,56.68 218.13,56.77 JAPS1.13
SYS_RESET#_R: length 1.5
  TOP w0.081: UC29.4 186.47,34.6 RC430.2 RC432.2
SYSPWR_PRES: length 3.8
  TOP w0.081: UE1.B1 205.99,65.16 205.28,65.87 204.77,65.87 RE154.2 RE152.2
TAB_LID#: length 100.5
  TOP w0.081: DE2.1 220.68,62.63 v1(220.46,62.42) 220.46,61.93 220.7,61.7 221.27,61.7 221.52,61.44 221.52,56.39 DE4.1 ; JIO1.39 v1(255.05,6.89)
  IN1 w0.064: v1(220.46,62.42) 220.46,60.76 221.32,59.9 221.32,43.65 220.61,42.94 220.61,27.26 223.73,24.14 223.73,23.32 224.18,22.87 224.18,17.45 228.88,12.74 231.8,12.74 232.24,12.3 238.74,12.3 239.19,11.85 244.85,11.85 247.35,14.36 254.64,14.36 257.46,11.54 257.46,10.66 257.12,10.32 257.12,8.16 256.35,7.38 256.35,7.03 256.22,6.89 v1(255.05,6.89)
TABLE_MODE#: length 63.1
  TOP w0.081: RC680.2 RC679.1 177.93,41.21 v1(177.77,41.05) 175.85,41.05 175.53,40.73 175.49,40.73 175.49,40.72 174.62,40.72 174.61,40.73 174.5,40.77 174.37,40.77 174.28,40.75 174.26,40.72 174.01,40.72 UC1.DU34
  IN1 w0.064: v2(214.79,53.21) 214.85,53.27 v1(214.85,53.53) ; v2(205.99,39.11) 206.88,39.11 209.45,41.68 211.68,41.68 211.7,41.7 211.7,41.7 211.91,41.91 211.91,45.19 211.35,45.76 211.35,49.55 211.68,49.88 v2(211.68,51.05) ; v1(177.77,41.05) v2(178.1,41.05)
  IN2 w0.051: v2(214.79,53.21) 214.6,53.39 213.63,53.39 213.5,53.26 213.5,52.88 v2(211.68,51.05) ; v2(202.69,32.69) 202.15,33.23 192.16,33.23 189.78,35.6 189.34,35.6 186.12,38.82 185.25,38.82 183.5,40.57 180.41,40.57 180.11,40.87 178.28,40.87 v2(178.1,41.05)
  IN3 w0.064: v2(205.99,39.11) 205.76,38.87 205.76,35.76 v2(202.69,32.69)
TABLE_MODE#_EC: length 8
  TOP w0.081: UE1.H8 213.05,60.36 213.43,59.98 v1(213.9,59.98) ; v1(214.08,55.36) 214.19,55.24 214.19,54.99 214.85,54.33 RE431.1
  IN1 w0.064: v1(213.9,59.98) 213.9,59.45 214.16,59.18 214.16,57.66 214.56,57.27 214.56,56.97 214.16,56.58 214.16,55.44 v1(214.08,55.36)
TACH_FAN1: length 198.4
  TOP w0.081: D132.2 65.56,14.64 65.67,14.54 v1(65.67,14.2)
  IN1 w0.064: v2(85.38,8.93) 85.3,8.85 83.8,8.85 82.35,7.4 79.22,7.4 76.67,9.96 74.03,9.96 72.87,11.12 70.85,11.12 67.98,13.99 65.88,13.99 v1(65.67,14.2) ; v2(209.11,62.42) 208.76,62.42 208.7,62.48 v1(208.7,62.76)
  IN2 w0.051: v2(85.38,8.93) 85.64,8.93 86.47,9.76 86.47,9.96 86.94,10.43 86.94,19.9 89.2,22.16 89.2,48.16 90.95,49.9 98.67,49.9 101.58,52.81 107.86,52.81 108.69,53.64 111.28,53.64 111.53,53.88 113.03,53.88 113.91,54.76 114.15,54.76 114.28,54.89 121.9,54.89 122.85,53.94 127.57,53.94 127.89,54.25 128.66,54.25 129.53,55.12 136.65,55.12 137.1,54.66 143.33,54.66 143.67,55 144.78,55 145.08,54.7 145.36,54.7 145.79,55.14 149.25,55.14 150.03,54.35 154.3,54.35 154.87,54.93 155.76,54.93 156.98,53.71 163.19,53.71 165.5,56.02 165.5,58.42 167.04,59.96 169.3,59.96 170.57,61.23 171.25,61.23 172.06,62.04 177.6,62.04 178.28,61.36 189.41,61.36 189.51,61.47 190.69,61.47 190.97,61.19 192.75,61.19 192.96,60.98 196.91,60.98 197.7,60.19 201.47,60.19 201.94,59.71 202.24,59.71 202.8,60.27 204.64,60.27 204.81,60.45 204.81,60.89 205.43,61.51 207.16,61.51 207.46,61.82 208.56,61.82 209.11,62.36 v2(209.11,62.42)

# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BC_INT#_ECE1117: length 91.4
  TOP w0.081: v5(208.31,62.37) 208.27,62.37 207.9,62.75 UE1.E2 ; v1(238.19,15.84) 238.19,15.25 239.53,13.9 239.53,9.28 241.94,6.87 241.94,5.22 242.67,4.49 244.47,4.49 244.85,4.87 JIO1.5
  IN1 w0.064: v1(238.19,15.84) 237.63,16.4 230.36,16.4 227.89,18.87 227.89,21.18 227.96,21.25 227.96,22.47 v2(227.78,22.65)
  IN3 w0.064: v5(208.31,62.37) 208.31,62.37 209.53,61.15 210.98,61.15 211.03,61.19 212.19,61.19 213.07,60.3 213.34,60.3 213.98,60.3 214.2,60.09 214.49,60.09 215.06,60.66 218.54,60.66 219.44,59.76 219.44,48.34 215.72,44.62 215.72,38.48 216.92,37.29 219.53,37.29 221.53,35.29 221.53,33.94 221.53,33.94 221.53,27.71 225.38,23.86 226.57,23.86 v2(227.78,22.65)
  BOTTOM w0.081: v5(208.31,62.37) v3(208.31,62.9)
BEEP: length 252.3
  IN1 w0.064: v2(24.86,16.51) 24.86,16.61 24.62,16.85 23.29,16.85 22.99,17.15 22.99,21.95 v1(22.49,22.45) ; v2(214.67,58.38) 214.67,58.96 215.1,59.39 v1(215.1,60.36)
  IN2 w0.051: v2(24.86,16.51) 24.96,16.42 26.58,16.42 26.77,16.23 26.77,15.53 26.96,15.34 30.89,15.34 31.59,16.04 32.12,16.04 32.83,15.33 69.84,15.33 70.43,15.92 71.99,15.92 72.42,15.48 78.55,15.48 83.16,10.88 83.16,9.54 84.44,8.25 85.61,8.25 86.74,9.39 87.34,9.39 87.44,9.48 88.07,9.48 88.59,10 88.59,16.37 90.11,17.89 90.11,46.75 91.26,47.9 97.56,47.9 97.99,48.32 98.87,48.32 99.33,48.78 100,48.78 102.81,51.59 108.42,51.59 108.86,52.03 110.63,52.03 110.72,51.94 113.03,51.94 114.31,53.22 114.68,53.22 115.03,52.87 128.16,52.87 128.44,53.15 132.84,53.15 133.57,53.88 134.72,53.88 135.45,53.15 144.31,53.15 144.42,53.04 150.42,53.04 150.53,53.15 155.4,53.15 155.91,52.64 163.85,52.64 167.6,56.39 168.96,56.39 169.6,57.03 169.6,57.42 170.42,58.24 172.03,58.24 172.28,58.49 173.53,58.49 174.32,59.28 179.5,59.28 181.48,57.29 187.99,57.29 188.91,56.37 191.08,56.37 192.62,57.92 194.79,57.92 195.46,57.25 204.3,57.25 204.5,57.46 206.02,57.46 206.9,56.58 213.13,56.58 214.67,58.12 v2(214.67,58.38)
BGPO0: length 6.3
  TOP w0.081: UE1.D6 211.49,63.95 211.49,66.98 211.04,67.42 211.04,69.32 TP58.1
BIA_PWM: length 112
  TOP w0.081: C750.1 189.03,41.74 187.88,42.9 D3.1 187.23,43.51 R32.1 187.51,43.82 187.79,44.11 187.84,44.11 187.84,44.11 188.34,44.11 188.35,44.11 188.56,44.11 189.5,45.04 190.08,45.04 190.63,45.59 191.57,45.59 v1(191.85,45.87)
  IN1 w0.064: v1(191.85,45.87) 191.85,46.37 192.02,46.53 192.02,46.97 193.71,48.67 193.71,49.91 194.53,50.73 194.53,51.34 195.13,51.94 195.13,52.77 196.82,54.46 196.82,54.92 198.11,56.21 198.11,59.13 197.53,59.72 197.53,60.29 197.65,60.41 197.65,65.04 197.83,65.22 197.83,67.87 v2(197.64,68.06)
  IN2 w0.051: v2(197.64,68.06) 196.84,67.27 195.64,67.27 195.44,67.47 189.59,67.47 189.37,67.68 179.36,67.68 176.4,70.64 174.6,70.64 173.77,71.47 171.47,71.47 165.68,77.27 164.21,77.27 164,77.06 162.14,77.06 161.93,77.27 155.82,77.27 155.01,76.45 154.47,76.45 152.28,74.26 150.44,74.26 149.44,74.07 145.79,74.07 144.29,75.56 144.29,77.46 142.79,78.95 134.99,78.95 v2(131.8,82.15)
  IN3 w0.064: v2(131.8,82.15) 131.98,81.96 132.81,81.96 133.26,81.51 v4(133.26,81.25)
BIA_PWM_EC: length 33
  TOP w0.081: v1(197.32,47.1) 197.32,47.37 196.39,48.3 193.01,48.3 190.9,46.19 190.39,46.19 189.78,45.59 189.2,45.59 188.28,44.67 187.22,44.67 186.1,43.55 D3.2 186.03,42.85 186.03,42.24 186.54,41.72 v3(186.54,41.15)
  IN1 w0.064: v1(197.32,47.1) 199.4,49.19 200.99,49.19 201.91,50.1 201.91,50.21 202.5,50.8 204.66,50.8 205.26,51.41 205.26,53.95 207.1,55.78 v1(207.1,56.36)
BIA_PWM_R: length 11.2
  TOP w0.081: JEDP1.23 v1(132.1,83.39)
  IN1 w0.064: v2(132.28,83.84) 132.1,83.67 v1(132.1,83.39) 132.09,83.39 131.92,83.22 131.92,82.9 132.16,82.66 132.16,82.05 132.81,81.4 132.81,79.98 v1(132.24,79.41)
  IN3 w0.064: v4(134.02,83.11) 133.28,83.84 v2(132.28,83.84)
  BOTTOM w0.081: v4(134.02,83.11) 133.89,82.98 133.89,81.93 134.11,81.7 LV1.2 134.11,80.45 v6(133.7,80.03)
BL_PWR_MONITOR: length 2.3
  BOTTOM w0.081: v3(122.99,77.1) 123.35,77.46 R627.1 123.35,78.45 123.59,78.69 QV19.2
BOARD_ID: length 3.3
  TOP w0.081: RE194.2 CE75.1 218.41,60.04 218.18,59.82 216.96,59.82 UE1.J13
BST_1.1V: length 5.8
  IN1 w0.508: 94.9,59.73 94.9,60.46 95.5,61.06 97.61,61.06 98.14,61.59 98.14,62.52 98.46,62.84
  vias: v1(94.92,59.21) v1(94.92,58.95) v1(98.9,62.97) v1(99.22,62.97)
BST_5V: length 2.7
  BOTTOM w0.081: v5(21.43,5.78) v6(18.73,5.78)
BST_5VB: length 1.7
  BOTTOM w0.081: v5(271.77,7.29) v6(273.43,7.29)
BT_RADIO_DIS#: length 13.5
  TOP w0.081: UE1.C2 207.51,64.74 205.96,64.74 205.58,65.12 203.51,65.12 RE133.2 202.85,64.74 202.72,64.87 199.71,64.87 198.88,64.04 198.79,64.04 v3(198.72,63.98) 198.64,63.98 196.91,62.25 DZ3.1
BT_RADIO_DIS#_R: length 5.8
  IN1 w0.064: v1(195.21,61.31) 194.96,61.56 194.96,62.91 193.01,64.87 v1(191.62,64.87)
CAM_DET#: length 7
  TOP w0.081: 173.31,38.8 175.04,38.8 175.18,38.66 175.97,38.66 176.56,39.25 177.74,39.25 177.97,39.48 R6208.1 ; 172.94,38.88 172.59,38.88 171.98,39.49 UC1.DP33
  TOP w0.089: 172.94,38.88 173.23,38.88 173.31,38.8
CAM_DET#_R: length 106
  TOP w0.081: R6208.2 178,40.19 v1(178.38,40.19) ; v5(158.19,82.63) 158.19,82.97 158.7,83.48 JUFC1.23
  IN1 w0.064: v5(158.19,82.63) 158.19,82.73 158.8,83.34 161.58,83.34 161.86,83.06 161.86,82.24 161.39,81.77 161.39,80.7 161.68,80.41 161.68,79.77 161.45,79.55 161.45,78.57 v1(162.21,77.82) 162.24,77.82 162.66,78.23 v2(162.92,78.23) ; v1(178.38,40.19) 178.38,40.83 178.75,41.2 179.15,41.2 179.92,40.43 181.76,40.43 182.05,40.13 183.46,40.13 184,40.67 184,41.48 184.2,41.67 184.2,42.18 183.83,42.56 180.52,42.56 180.32,42.76 180.32,43.92 179.34,44.9 179.34,48.27 v2(179.23,48.39) ; v2(192.11,48.75) 192.53,49.17 192.53,50.97 193.11,51.55 193.11,54.46 193.4,54.75 193.76,54.75 195.42,56.41 195.42,57.22 195.65,57.45 195.65,58.44 196.01,58.8 196.01,59.26 195.78,59.5 195.78,61.96 195.97,62.15 195.97,64.87 196.15,65.05 196.15,65.86 195.74,66.27 195.43,66.27 194.99,65.82 191.02,65.82 190.02,66.81 190.02,68.16 190.28,68.41 v2(190.68,68.41)
  IN2 w0.051: v2(192.11,48.75) 191.47,48.12 187.42,48.12 186.36,49.17 183.83,49.17 183.11,49.17 183.09,49.2 182.31,49.2 181.87,49.11 181.84,49.1 179.94,49.1 v2(179.23,48.39) ; v2(162.92,78.23) 162.92,77.99 163.09,77.82 163.69,77.82 163.89,78.03 166,78.03 171.79,72.24 174.08,72.24 174.92,71.4 176.72,71.4 179.67,68.45 190.65,68.45 v2(190.68,68.41)
CBN: length 3.1
  TOP w0.203: UA1.24 33.53,18.43 v3(34.16,19.06) 34.88,19.78 CA21.2
CBP: length 4.5
  TOP w0.203: UA1.23 33.77,18.03 34.77,19.02 36.36,19.02 CA21.1
CD_WAKE#: length 2.2
  TOP w0.081: RR11.2 RR12.2 278.6,30.28 UCR1.32
CFG_RCOM: length 2.7
  TOP w0.081: UC1.AD6 137.78,27.21 v1(137.78,27.23)
  IN1 w0.064: v1(137.78,27.23) 137.94,27.23 v2(138.08,27.09)
  IN3 w0.064: v4(137.38,27.44) 137.74,27.09 v2(138.08,27.09)
  BOTTOM w0.081: v3(137.66,28.36) 137.38,28.08 v4(137.38,27.44)
CHG_ACIN: length 13.5
  TOP w0.203: PU200.19 81.76,14.59 v1(81.81,14.54)
  TOP w0.254: v1(74.9,19.21) 74.89,19.23 PC211.1 ; PC211.1 72.82,19.25 PR201.2 ; PC211.1 72.82,19.2 PR204.1
  IN1 w0.254: v1(81.81,14.54) 81.22,14.54 79.53,16.23 77.88,16.23 75.03,19.08 75.03,19.09 v1(74.9,19.21)
CHG_ADP: length 4.2
  TOP w0.203: 79.34,15.28 79.93,15.87 PU200.16
  TOP w0.254: PC226.1 79.34,14.89 79.34,15.28
  TOP w0.508: PR206.2 78.46,13.54 78.65,13.73 PC226.1
CHG_AMON: length 186.8
  TOP w0.081: PU200.29 85.11,17.47 v1(85.63,17.98)
  IN1 w0.064: v2(220.76,65.45) 220.99,65.69 220.99,67.82 219.94,68.87 219.3,68.87 218.97,69.2 v1(218.97,69.82) ; v1(85.63,17.98) 88.24,17.98 88.45,18.2 89.16,18.2 v2(89.35,18.39)
  IN2 w0.051: v2(89.35,18.39) 89.81,18.85 89.81,46.87 92.23,49.29 98.92,49.29 101.83,52.2 108.11,52.2 109.07,53.16 113.17,53.16 113.84,53.83 114.68,53.83 114.93,53.83 115.28,53.48 127.88,53.48 128.16,53.76 129.03,53.76 129.91,54.64 134.83,54.64 135.71,53.76 144.56,53.76 144.62,53.7 150.22,53.7 150.28,53.76 155.66,53.76 156.16,53.25 163.6,53.25 166.11,55.76 166.11,55.97 167.01,56.87 167.01,58.23 167.64,58.85 171.39,58.85 172.27,59.74 175.85,59.74 176.05,59.94 177.43,59.94 177.63,59.74 179.69,59.74 180.56,58.86 182.01,58.86 183.12,57.75 188.06,57.75 188.18,57.75 189.1,56.83 190.89,56.83 192.78,58.72 192.82,58.72 192.82,58.72 200.14,58.72 201.06,57.79 206.12,57.79 206.89,57.02 209.16,57.02 209.97,57.83 210.64,57.83 210.9,57.57 212.71,57.57 213.15,58.01 213.53,58.01 214.4,58.88 214.4,59.22 214.74,59.56 216.42,59.56 217.15,60.29 217.15,62.34 218.35,63.54 218.35,64.33 219.45,65.44 220.75,65.44 v2(220.76,65.45)
CHG_BGATE: length 14.6
  TOP w0.081: v1(95.15,17.05) v3(95.15,16.05)
  TOP w0.203: PU200.32 84.79,18.67 84.87,18.74 v1(84.87,18.96)
  TOP w0.254: PQ202.4 95.15,18.27 v1(95.15,17.05)
  IN1 w0.254: v1(95.15,17.05) 94.11,18.09 90.42,18.09 89.69,18.82 88.46,18.82 87.89,18.25 87.01,18.25 86.64,18.62 85.21,18.62 v1(84.87,18.96)
CHG_CLK: length 2.1
  TOP w0.203: PU200.22 82.96,14.5 83.85,13.6 PR214.2
CHG_CMIN: length 1.8
  TOP w0.203: PR212.2 82.16,13.62 PU200.20
CHG_COMP: length 5.3
  TOP w0.081: v3(88.26,16.7) 88.26,16.78 87.63,17.41 86.74,17.41 86.34,17.01 PR231.1
  TOP w0.203: PU200.28 86,17.07 86.09,16.98 PR231.1 86.34,16.13 PC241.1
CHG_CSIN: length 4.5
  TOP w0.203: 79.46,16.67 PU200.14
  TOP w0.254: PC213.1 76.74,17.64 PR203.2 77.65,16.93 78.34,16.24 PC210.2 79.04,16.24 79.46,16.67
CHG_CSIP: length 4.2
  TOP w0.203: 79.7,16.27 PU200.15
  TOP w0.254: 79.7,16.27 78.76,15.33 PC210.1 78.41,15.25 PC212.1 77.45,15.27 PR202.2
CHG_CSON: length 5.1
  TOP w0.178: PC239.2 84.14,19.94 84.07,19.94 83.76,19.63 PU200.1
  TOP w0.254: PC239.2 85.85,20.86 v1(86.12,21.14)
  IN1 w0.254: v1(86.12,21.14) v1(87.89,21.14)
CHG_CSOP: length 4
  TOP w0.178: PC239.1 84.16,20.51 83.36,19.71 PU200.2
  TOP w0.254: PC239.1 84.16,21.89 PC238.2 85.22,22.04 PR221.2
CHG_DAT: length 2
  TOP w0.203: PR213.2 83.09,13.75 82.56,14.29 PU200.21
CHG_DCIN:
  vias: v3(82.65,11.47)
CHG_LG1: length 12.2
  IN1 w1.016: 79.6,20.36 79.45,20.51 79.45,23.42 85.4,29.37 86.08,29.37
  vias: v5(79.95,19.58) v5(80.33,19.12) v5(86.96,29.67) v5(86.99,29.08)
CHG_LG2: length 21.5
  IN3 w1.016: 75.79,40.74 75.79,25.12 79.98,20.93
  vias: v5(75.43,41.68) v5(76.04,41.65) v5(80.74,20.5) v5(81.15,20.09)
CHG_LX1: length 13.3
  IN1 w1.016: 78.2,19.91 77.63,20.48 77.63,24.29 83.34,30.01 83.98,30.01
  vias: v5(78.96,19.15) v5(79.41,18.77) v5(84.65,31.27) v5(84.65,30.63)
CHG_LX2: length 19.9
  IN3 w1.016: 81.57,21.75 81.57,23.02 78.52,26.07 78.52,40.36
  vias: v5(78.56,41.53) v5(79.04,41.07) v5(81.27,20.98) v5(81.71,20.57)
CHG_PROCHOT#: length 22.8
  TOP w0.081: PR102.2 96.49,9.46 97.24,10.21 PR105.2 98.08,11.21 98.08,12.36 v3(97.44,12.99) 95.35,15.09 v1(95.22,15.09)
  TOP w0.203: PR217.2 84.61,13.51 83.36,14.77 v1(83.36,15.22)
  IN1 w0.254: v1(95.22,15.09) 93.63,15.09 92.87,15.85 89.52,15.85 88.89,16.47 85.16,16.47 84.35,15.66 83.8,15.66 v1(83.36,15.22)
CHG_PSYS: length 1.8
  TOP w0.203: PR229.1 85.65,18.6 84.91,17.87 PU200.30
CHG_UG1: length 13.2
  IN1 w1.016: 77.76,18.13 76.3,19.59 76.3,24.81 80.42,28.94 80.42,28.99
  vias: v1(78.65,18.32) v1(78.84,18.07) v5(80.18,29.82) v5(80.74,29.82)
CHG_UG2: length 19.8
  IN3 w1.016: 81.76,40.87 83.23,39.39 83.23,21.64
  vias: v5(81.35,41.73) v5(81.93,41.78) v5(82.31,20.41) v5(82.44,20.95)
CHG_VBAT1: length 3.1
  TOP w0.203: PU200.31 84.88,18.27 85.25,18.63 85.25,18.83 85.78,19.36 PR236.1 PC245.1
CHG_VDDP: length 3.3
  TOP w0.203: PU200.8 80.96,19.57
  TOP w0.254: PC228.1 80.49,21.28 ; 80.49,21.28 80.49,20.99 80.23,20.74 v3(80.23,20.33) 80.23,20.29 80.96,19.57 ; 80.49,21.28 PR207.1
CLK_BIASREF: length 8.3
  TOP w0.081: 175.6,26.81 176.83,26.81 177.65,27.63 177.65,28.4 177.74,28.49 179.06,28.49 RH475.1 179.38,27.82 179.48,27.72 v3(179.48,27.21)
  TOP w0.089: 175.6,26.81 175,26.81 174.88,26.93 173.65,26.93 UC1.DU6
CLK_CNV_PRX_DTX_N: length 37.7
  TOP w0.066: v5(190.46,58.91) 190.27,58.72 190.02,58.72 UWL1.A33
  IN1 w0.061: v1(170.03,45.12) v2(170.27,44.89)
  IN3 w0.061: v2(170.27,44.89) 170.11,45.05 170.11,45.62 170.86,46.37 171.98,46.37 172.31,46.04 173.15,46.04 174.09,46.98 174.09,47.26 173.67,47.68 173.67,47.84 174.01,48.18 174.12,48.18 174.56,47.74 174.85,47.74 176.17,49.06 176.17,49.93 178.6,52.35 178.6,55.89 179.25,56.54 179.73,56.54 179.73,56.54 180.24,56.54 180.43,56.72 180.62,56.72 180.82,56.92 180.82,57.09 180.95,57.22 181.28,57.22 181.35,57.16 181.35,56.92 181.55,56.72 182.14,56.72 182.34,56.92 182.34,57.15 182.42,57.22 182.84,57.22 182.92,57.15 182.92,56.92 183.12,56.72 183.72,56.72 183.92,56.92 183.92,57.15 184,57.22 184.42,57.22 184.5,57.15 184.5,56.92 184.7,56.72 185.29,56.72 185.49,56.92 185.49,57.15 185.57,57.22 185.99,57.22 186.07,57.15 186.07,56.92 186.27,56.72 186.87,56.72 187.07,56.92 187.07,57.15 187.14,57.22 187.5,57.22 187.57,57.15 187.57,56.87 187.77,56.67 188.37,56.67 188.57,56.87 188.57,57.15 188.65,57.22 190.73,57.22 191.31,57.8 191.31,58.42 191.11,58.62 190.95,58.62 190.85,58.72 190.65,58.72 v5(190.46,58.91)
CLK_CNV_PRX_DTX_P: length 37.7
  TOP w0.066: v5(190.46,58.32) 190.27,58.51 190.02,58.51 UWL1.A32
  IN1 w0.061: v2(169.62,44.89) v1(169.38,45.12)
  IN3 w0.061: v2(169.62,44.89) 169.66,44.84 169.82,44.84 169.9,44.92 169.9,45.7 170.77,46.57 172.07,46.57 172.39,46.24 173.07,46.24 173.88,47.06 173.88,47.18 173.47,47.59 173.47,47.92 173.93,48.38 174.21,48.38 174.65,47.94 174.76,47.94 175.97,49.15 175.97,50.02 178.39,52.44 178.39,55.97 179.17,56.74 179.81,56.74 179.82,56.74 180.16,56.74 180.34,56.93 180.54,56.93 180.62,57.01 180.62,57.18 180.87,57.43 181.37,57.43 181.55,57.25 181.55,57 181.63,56.92 182.06,56.92 182.14,57 182.14,57.23 182.34,57.43 182.93,57.43 183.12,57.23 183.12,57 183.21,56.92 183.63,56.92 183.71,57 183.71,57.23 183.91,57.43 184.5,57.43 184.7,57.23 184.7,57 184.78,56.92 185.21,56.92 185.29,57 185.29,57.23 185.49,57.43 186.08,57.43 186.27,57.23 186.27,57 186.36,56.92 186.78,56.92 186.86,57 186.86,57.23 187.06,57.43 187.58,57.43 187.78,57.23 187.78,56.96 187.86,56.88 188.28,56.88 188.37,56.96 188.37,57.23 188.56,57.43 190.65,57.43 191.1,57.89 191.1,58.33 191.02,58.42 190.87,58.42 190.77,58.51 190.53,58.51 190.46,58.44 v5(190.46,58.32)
CLK_CNV_PTX_DRX_N: length 24.7
  IN1 w0.061: v1(182.17,60.87) 182.17,60.98 182.06,61.1 182,61.16 179.75,61.16 177.57,58.98 177.57,55.84 177.86,55.55 177.86,51.19 174.04,47.37 173.35,47.37 173.24,47.27 172.54,47.27 170.78,45.52 170.78,44.68 170.43,44.32 170.43,44.28 170.5,44.21 v1(170.68,44.21)
CLK_CNV_PTX_DRX_P: length 24.8
  IN1 w0.061: v1(170.03,44.21) 170.12,44.21 170.22,44.31 170.22,44.41 170.58,44.76 170.58,45.6 172.45,47.47 173.16,47.47 173.27,47.58 173.96,47.58 177.65,51.27 177.65,55.47 177.36,55.76 177.36,59.06 179.67,61.37 v1(182.17,61.37)
CLK_PCIE_N0: length 47.3
  TOP w0.089: v1(159.35,25.82) 159.38,25.82 UC1.CJ3
  TOP w0.091: RW7.1 182.66,52.42 L26.1 182.85,51.92 183,51.77 183,51.58 v5(182.81,51.39)
  IN1 w0.081: v2(159.46,26.33) 159.54,26.24 159.54,26.01 v1(159.35,25.82)
  IN3 w0.081: v2(159.46,26.33) 159.61,26.48 159.61,27.15 160.83,28.38 166.23,28.38 170.28,32.43 178.13,32.43 183.61,37.91 183.61,43.62 183.66,43.67 183.66,44.3 185.74,46.37 185.74,47.54 182.9,50.38 182.9,51.29 182.85,51.35 v5(182.81,51.39)
CLK_PCIE_N0_R: length 4.2
  TOP w0.091: v1(182.85,53.48) 182.77,53.48 RW7.2
  IN1 w0.081: v1(183.27,57.02) 183.48,56.81 183.48,54.79 182.97,54.28 182.97,53.6 v1(182.85,53.48)
CLK_PCIE_N1: length 53
  IN1 w0.081: v2(204.45,16.09) 204.29,15.92 203.85,15.92 202.17,14.25 174.59,14.25 173,15.83 167.09,15.83 163.94,18.98 162.82,18.98 161.32,20.48 161.32,24.39 161.09,24.61 160.93,24.61 160.82,24.72 v1(160.82,24.85)
  IN3 w0.081: v2(204.45,16.09) 204.52,16.09 205.23,16.09 205.65,15.66 205.65,15.37 v4(205.77,15.25)
CLK_PCIE_N1_R: length 2
  BOTTOM w0.091: RS207.2 205.56,14.45 205.56,13.79 205.64,13.7 JNGFF1.45
CLK_PCIE_N2: length 54
  TOP w0.089: UC1.CL3 160.82,25.63 161.02,25.83 161.02,25.95 161.11,26.04 161.11,26.27 160.85,26.53 160.85,27.67 v1(161.03,27.85)
  IN1 w0.081: v1(189.88,43.83) 189.54,44.17 189.26,44.17 188.73,43.63 188.73,41.37 186.16,38.8 186.16,26.41 185.02,23.67 183.71,22.35 178.98,22.35 178.22,23.12 170.11,23.12 169.4,23.82 169.4,24.05 168.34,25.11 167.98,25.11 165.38,27.71 165.38,28.53 165.27,28.65 161.23,28.65 160.85,28.26 160.85,28.03 v1(161.03,27.85)
CLK_PCIE_N2_R: length 7.1
  TOP w0.076: USSD1.D5 196.94,45.11 196.94,44.97 196.73,44.76 194.69,44.76 194.58,44.87 193.29,44.87 193.28,44.86 193.26,44.86
  TOP w0.091: 193.26,44.86 192.78,44.86 192,44.08 191.05,44.08 R1096.2
CLK_PCIE_N4: length 127.1
  TOP w0.091: v5(274.14,25.87) 274.39,26.12 274.56,26.12 274.64,26.04 275.02,26.04 275.17,25.9 R6090.1
  IN1 w0.081: v2(160.09,20.62) 160.14,20.67 160.5,20.67 160.71,20.89 160.71,22.87 160.37,23.21 160.37,24.39 160.32,24.45 160.32,24.54 160.12,24.74 159.81,24.74 v1(159.7,24.85)
  IN3 w0.081: v5(274.14,25.87) 273.84,25.87 273.59,25.62 273.59,23.9 267.62,17.94 264.66,17.94 263.54,16.82 226.22,16.82 225,18.04 176.23,18.04 174.12,20.15 166.47,20.15 166.2,19.88 162.07,19.88 161.32,20.62 v2(160.09,20.62)
CLK_PCIE_N4_R: length 2.1
  TOP w0.091: UCR1.6 277.39,26.04 277.29,26.14 277.08,26.14 277.03,26.19 276.9,26.19 276.75,26.04 276.24,26.04 R6090.2
CLK_PCIE_P0: length 47.3
  TOP w0.089: UC1.CJ5 159.69,26.12 v1(159.89,25.82)
  TOP w0.091: RW6.1 183.35,52.25 L26.4 183.35,51.91 183.2,51.76 183.2,51.58 v5(183.39,51.39)
  IN1 w0.081: v2(159.99,26.33) 159.74,26.08 159.74,25.97 v1(159.89,25.82)
  IN3 w0.081: v2(159.99,26.33) 159.81,26.51 159.81,27.07 160.92,28.18 166.31,28.18 170.36,32.23 178.21,32.23 183.81,37.83 183.81,43.53 183.86,43.59 183.86,44.22 185.94,46.29 185.94,47.62 183.1,50.46 183.1,51.12 183.37,51.39 v5(183.39,51.39)
CLK_PCIE_P0_R: length 4.1
  TOP w0.091: RW6.2 183.38,53.48 v1(183.35,53.48)
  IN1 w0.081: v1(183.77,57.02) 183.67,56.92 183.67,54.71 183.17,54.2 183.17,53.66 v1(183.35,53.48)
CLK_PCIE_P1: length 53
  IN1 w0.081: v2(204.45,15.55) 204.29,15.72 203.93,15.72 202.26,14.05 174.51,14.05 172.92,15.63 167,15.63 163.85,18.78 162.74,18.78 161.12,20.4 161.12,24.3 161.01,24.41 160.9,24.41 160.82,24.34 v1(160.82,24.2)
  IN3 w0.081: v2(204.45,15.55) 204.79,15.89 205.15,15.89 205.46,15.58 205.46,15.39 205.32,15.25 v4(205.14,15.25)
CLK_PCIE_P1_R: length 2
  BOTTOM w0.091: RS208.2 205.35,14.45 205.35,13.91 205.14,13.7 JNGFF1.47
CLK_PCIE_P2: length 53.9
  TOP w0.089: UC1.CL5 160.82,26.08 160.71,25.97 160.59,25.97 160.49,26.06 160.49,26.29 160.65,26.44 v1(160.65,27.85)
  IN1 w0.081: v1(160.65,27.85) 160.65,28.35 161.15,28.84 165.35,28.84 165.58,28.61 165.58,27.79 168.07,25.31 168.42,25.31 169.6,24.13 169.6,23.9 170.19,23.31 178.31,23.31 179.07,22.55 183.63,22.55 184.85,23.78 185.96,26.45 185.96,38.88 188.53,41.45 188.53,43.72 189.18,44.37 189.66,44.37 v1(189.88,44.59)
CLK_PCIE_P2_R: length 7.1
  TOP w0.076: 193.26,45.07 193.28,45.07 193.29,45.06 194.66,45.06 194.77,44.95 196.65,44.95 196.75,45.05 196.75,45.2 196.68,45.27 USSD1.D4
  TOP w0.091: 193.26,45.07 192.7,45.07 191.92,44.29 191.1,44.29 R1095.2
CLK_PCIE_P4: length 127.1
  TOP w0.091: R6089.1 275.17,26.68 275.02,26.54 274.69,26.54 274.48,26.32 274.27,26.32 v5(274.14,26.46)
  IN1 w0.081: v2(160.09,21.16) 160.38,20.87 160.41,20.87 160.51,20.97 160.51,22.79 160.17,23.13 160.17,24.31 160.12,24.36 160.12,24.46 160.04,24.54 159.86,24.54 159.7,24.37 v1(159.7,24.2)
  IN3 w0.081: v5(274.14,26.46) 273.39,25.7 273.39,23.98 267.54,18.13 264.57,18.13 263.45,17.01 226.31,17.01 225.09,18.23 176.31,18.23 174.2,20.34 166.39,20.34 166.12,20.07 162.15,20.07 161.4,20.82 160.43,20.82 v2(160.09,21.16)
CLK_PCIE_P4_R: length 2.1
  TOP w0.091: UCR1.5 277.39,26.44 277.29,26.34 277.16,26.34 277.11,26.39 276.9,26.39 276.75,26.54 276.25,26.54 R6089.2
CLK_SMB: length 5.7
  TOP w0.081: JT101.3 43.66,8.59 43.22,9.03 40.75,9.03 v6(40.61,9.17) 40.61,9.32 41.17,9.87 PR106.1
CLK_TP_SIO_I2C_DAT: length 5.6
  TOP w0.081: RE467.2 218.75,64.5 218.38,64.13 218.38,63.54 217.99,63.14 215,63.14 214.62,62.76 UE1.E10
CLKIN_XTAL: length 77
  TOP w0.081: v5(194.91,54.09) 194.37,54.64 194.37,62.48 196.16,64.27 RW34.2 RW15.1
  TOP w0.089: v5(161.68,25.66) UC1.CP5
  IN3 w0.064: v5(161.68,25.66) 161.53,25.51 159.18,25.51 158.71,25.98 158.71,27.06 160.61,28.96 166.02,28.96 170.06,33 175.59,33 177.34,34.75 179.59,34.75 180.75,35.91 180.76,35.91 182.97,38.13 182.97,38.13 183,38.16 183,42.68 179.88,45.8 179.88,49.7 182.62,52.44 191.3,52.44 192.79,53.94 194.77,53.94 194.91,54.08 v5(194.91,54.09)
  BOTTOM w0.081: v5(194.91,54.09) 194.34,53.52 v3(194.34,53.44)
CLKIN_XTAL_R: length 6.3
  IN1 w0.064: v1(189.87,64.37) 190.22,64.37 191.23,65.38 195.26,65.38 v1(195.57,65.7)
CLKREQ_CNV#: length 47
  TOP w0.081: v1(195.59,59.03) RH728.1
  IN1 w0.064: v2(195.28,59.6) 195.28,59.36 195.59,59.05 v1(195.59,59.03) ; v2(175.64,60.94) 175.27,60.56 175.03,60.56 174.3,59.84 174.3,59.14 174.79,58.65 174.79,57.5 174.35,57.05 174.35,55.32 174.63,55.03 174.63,52.58 172.88,50.83 171.71,50.83 170.39,49.51 169.15,49.51 168.67,49.03 167.13,49.03 166.97,48.87 165.91,48.87 164.71,47.67 164.71,47.57 164.42,47.28 164.35,47.28 163.87,46.8 163.22,46.8 v1(163.06,46.63)
  IN2 w0.051: v2(175.64,60.94) 175.64,60.94 176.03,60.55 177.68,60.55 177.88,60.35 179.94,60.35 180.81,59.47 182.09,59.47 183.2,58.36 188.24,58.36 189.25,57.35 190.76,57.35 193.01,59.6 v2(195.28,59.6)
CLKREQ_CNV#_R: length 10
  TOP w0.081: v1(191.62,62.87) 191.52,62.97 191.1,62.97 190.2,63.87 UWL1.A43
  IN1 w0.064: v1(195,59.03) 194.41,59.62 194.41,62.7 193.25,63.85 192.14,63.85 191.62,63.34 v1(191.62,62.87)
CLKREQ_PCIE#0: length 44.8
  IN1 w0.064: v1(170.03,39.63) 170.32,39.91 170.73,39.91 171.16,39.48 171.41,39.48 ; v1(181.77,57.02) 181.76,57 181.76,54.09 182.21,53.63 182.21,51.97 181.42,51.17 181.42,50.05 179.51,48.14 179.51,44.97 181.57,42.91 183.97,42.91 184.53,42.35 184.53,41.54 184.33,41.34 184.33,40.19 183.92,39.77 183.92,38.92 182.8,37.8 182.28,37.8 181.95,37.47 181.45,37.47 181.13,37.15 180.83,37.15 180.06,37.93 179.45,37.93 179.14,38.24 178.63,38.24 177.86,39.01 v2(177.63,39.01) 177.06,39.01 176.72,39.35 175.13,39.35 174.72,38.94
  IN1 w0.081: 174.72,38.94 174.59,38.81 173.12,38.81 172.84,39.1 171.79,39.1 171.41,39.48
  IN3 w0.064: v2(177.63,39.01) 177.9,39.28 178.28,39.28 179.12,40.11 179.12,40.12 179.32,40.32 181.2,40.32 v4(181.41,40.11)
  BOTTOM w0.081: v3(180.56,39.85) 180.82,40.11 v4(181.41,40.11)
CLKREQ_PCIE#1: length 85.7
  IN1 w0.064: v2(215.04,15.85) 215.04,15.3 212.73,12.99 212.73,11.57 212.15,10.98 212.15,5.71 v2(212.3,5.56)
  IN1 w0.089: v2(171.29,39.85) 171.33,39.89 v1(171.33,40.55)
  IN2 w0.051: v2(215.04,15.85) 215.04,16.95 210.9,21.09 210.9,26.42 209.8,27.53 208.54,27.53 207.83,28.24 190.95,28.24 190.7,28.5 190.7,31.16 185.21,36.65 180.69,36.65 180.6,36.74 178.89,36.74 176.41,39.22 175.78,39.22 175.43,39.56 171.58,39.56 v2(171.29,39.85)
  IN3 w0.064: v2(171.29,39.85) 171.56,40.12 173.95,40.12 174.53,40.7 174.53,41.44 174.21,41.76 174.09,41.76 v4(173.84,42) ; v2(212.3,5.56) 206.2,5.56 v4(205.89,5.25)
  BOTTOM w0.081: v4(173.84,42) 173.84,42.91 v3(174.34,43.41) RH727.2
CLKREQ_PCIE#2: length 55
  TOP w0.081: UE10.4 200.38,50.65 200.27,50.54 200.1,50.54 199.87,50.77 199.87,51.31 199.68,51.5 v1(199.49,51.5)
  IN1 w0.064: 174.72,39.51 176.79,39.51 177.02,39.28 177.41,39.28 v2(177.65,39.52) ; v2(200.26,50.09) 199.93,49.76 199.3,49.76 199.1,49.95 199.1,50.77 199.49,51.15 v1(199.49,51.5)
  IN1 w0.081: v1(171.98,40.55) 172.49,40.55 173.37,39.66 174.51,39.66 174.65,39.51 174.72,39.51
  IN3 w0.064: v2(177.65,39.52) 178.29,39.52 178.95,40.18 178.95,40.19 179.25,40.49 181.16,40.49 v4(181.41,40.74) ; v2(200.26,50.09) 199,48.83 v4(195.99,48.83)
  BOTTOM w0.081: v4(181.41,40.74) 179.6,40.74 179.23,41.11 179.23,41.75 178.12,42.86 178.12,46.04 v3(178.28,46.2) 177.37,47.11 177.37,48.8 182.34,53.78 185.43,53.78 187.48,51.72 187.48,50.78 189.43,48.83 190.66,48.83 191.23,48.26 195.42,48.26 v4(195.99,48.83)
CLKREQ_PCIE#2_R: length 12.3
  TOP w0.081: UE10.2 200.88,52.11 200.63,52.36 199.77,52.36 R456.1 199.24,52.08 199.11,51.94 199.11,51.26 RE451.1 199.99,50.37 199.99,50.01 200.27,49.73 v1(200.5,49.73) 200.67,49.73 v3(200.88,49.95)
  IN1 w0.064: v1(199.5,45.27) 199.7,45.27 v2(199.87,45.44) ; v1(200.5,49.73) 200.5,49.83 v2(200.76,50.09)
  IN3 w0.064: v2(200.76,50.09) 199.36,48.68 199.36,45.95 v2(199.87,45.44)
CLKREQ_PCIE#4: length 142.8
  TOP w0.081: v1(277.27,27.85) 277.48,27.64 UCR1.2 ; UC1.DN40 171.33,42.92 171.64,42.61 171.64,42.29 v1(172.02,41.91)
  IN1 w0.064: v2(276.83,23.85) 276.62,24.06 276.62,24.91 277.27,25.56 v1(277.27,27.85)
  IN1 w0.089: v2(172.31,42.07) 172.18,42.07 v1(172.02,41.91)
  IN2 w0.051: v2(172.31,42.07) 172.46,42.23 174.37,42.23 174.5,42.09 178.51,42.09 178.71,41.9 180.61,41.9 181.02,41.49 v2(181.12,41.49) 181.43,41.79 181.85,41.79 182.03,41.61 183.39,41.61 185.52,39.48 186.41,39.48 188.92,36.97 189.67,36.97 191.86,34.78 192.79,34.78 193.84,33.73 202.79,33.73 205.49,31.04 209.59,31.04 214.11,26.52 214.11,22.17 214.94,21.35 214.94,20.83 215.17,20.6 215.17,20.02 217.7,17.5 217.7,15.78 219.11,14.36 222.72,14.36 229.74,7.34 231.08,7.34 231.39,7.66 232.05,7.66 234.43,10.03 243.4,10.03 244.29,9.14 247.49,9.14 248.5,10.15 248.5,10.73 249.88,12.11 261.95,12.11 263.99,14.16 265.73,14.16 267.46,15.88 267.46,20.62 v2(269.7,22.87)
  IN3 w0.064: v2(276.83,23.85) 276.58,23.85 v4(276.45,23.98) ; v4(271.5,24.29) 271.43,24.29 271.02,23.88 270.36,23.88 269.74,23.26 269.74,22.91 v2(269.7,22.87) ; v2(181.12,41.49) 181.12,41.72 v4(181.41,42.01)
  BOTTOM w0.081: v4(276.45,23.98) 276.13,23.66 274.16,23.66 273.53,24.29 v3(272,24.29) v4(271.5,24.29)
CNV_BRI_PRX_DTX: length 41
  IN1 w0.064: v1(170.68,37.8) 170.68,38.03 v2(170.85,38.2)
  IN3 w0.064: v2(170.85,38.2) 170.85,38.62 171.27,39.04 171.38,39.04 171.66,38.77 171.76,38.77 171.84,38.84 171.84,38.95 171.56,39.22 171.56,39.33 171.63,39.4 171.74,39.4 172.02,39.13 172.12,39.13 172.2,39.2 172.2,39.31 171.92,39.58 171.92,39.69 172.02,39.79 172.11,39.79 172.37,39.53 172.53,39.53 172.8,39.81 174.08,39.81 174.85,40.58 174.85,41.73 174.58,42 174.58,44.25 176.71,46.39 178.01,46.39 178.49,46.87 178.49,48.7 178.93,49.14 178.93,50.07 183,54.14 190.59,54.14 192.32,55.87 192.84,55.87 193.79,56.83 193.79,58.39 193.85,58.46 194,58.46 194.06,58.39 v4(194.06,57.5)
  BOTTOM w0.081: v4(194.06,57.5) RW28.2
CNV_BRI_PRX_R_DTX: length 6.2
  TOP w0.081: v5(190.92,61.76) 190.81,61.87 UWL1.A39
  BOTTOM w0.081: v5(190.92,61.76) v3(192.15,60.52) 192.27,60.4 192.27,59.13 192.69,58.71 RW35.1 RW28.1
CNV_BRI_PRX_R_DTX_R: length 7.7
  IN1 w0.064: v2(192.37,60.86) 192.37,60.87 v1(191.62,60.87)
  IN3 w0.064: v2(192.37,60.86) 192.75,60.49 v4(192.76,60.49)
  BOTTOM w0.081: v4(192.76,60.49) 192.63,60.36 192.63,59.22 v3(192.69,59.15) 192.77,59.07 193.7,59.07 RW35.2 194.6,58.71 194.85,58.96 195.46,58.96 195.61,59.11 QW2.5 ; 195.61,59.98 195.61,60.59 RW43.1
  BOTTOM w0.089: 195.61,59.98 QW2.5
CNV_BRI_PTX_DRX: length 40.4
  IN1 w0.064: v2(170.32,38.31) 170.32,38.36 v1(170.68,38.72)
  IN3 w0.064: v2(170.32,38.31) 170.32,38.31 171.97,39.96 174.01,39.96 174.7,40.64 174.7,41.5 174.2,42 174.2,44.27 177.37,47.44 177.37,47.85 178.74,49.22 178.74,50.15 182.99,54.4 190.48,54.4 192.21,56.13 192.83,56.13 193.6,56.91 193.6,61.49 v4(194.06,61.95)
CNV_BRI_PTX_R_DRX: length 9
  TOP w0.081: v1(189.87,61.37) 190.6,61.37 191.17,60.8 191.17,60.45 191.25,60.37 UWL1.54
  IN1 w0.064: v2(189.72,60.98) 189.87,61.14 v1(189.87,61.37)
  IN3 w0.064: v4(189.94,61.76) 189.72,61.54 v2(189.72,60.98)
  BOTTOM w0.081: v4(189.94,61.76) 189.94,61.8 v3(190.22,62.08) 190.6,62.46 192.5,62.46 193.01,61.95 RC504.2 RW33.1 RW32.1
CNV_DET#_EC: length 4
  TOP w0.081: RE471.2 218.73,56.62 217.01,58.33 216.25,58.33 215.9,57.98 UE1.L12
CNV_PRX_DTX_N0: length 37.3
  TOP w0.066: v5(190.94,59.91) 190.82,59.79 190.32,59.79 190.25,59.87 UWL1.A35
  IN1 w0.061: v1(171.98,45.12) 171.94,45.08 v2(171.94,44.65)
  IN3 w0.061: v2(171.94,44.65) 171.78,44.81 171.78,45 171.96,45.18 173.12,45.18 177,49.06 177,49.38 176.78,49.59 176.78,49.7 177.09,50.01 177.48,50.01 177.68,50.21 177.68,50.63 179.18,52.13 179.18,55.64 179.49,55.95 179.57,55.95 180.51,55.95 180.69,56.13 182.52,56.13 183.02,55.63 183.4,55.63 183.6,55.83 183.6,56.05 183.68,56.13 184.02,56.13 184.1,56.05 184.1,55.83 184.3,55.63 184.85,55.63 185.05,55.83 185.05,56.05 185.13,56.13 185.49,56.13 185.57,56.05 185.57,55.83 185.77,55.63 186.36,55.63 186.57,55.83 186.57,56.05 186.64,56.13 187.07,56.13 187.14,56.05 187.14,55.83 187.34,55.63 188.56,55.63 188.76,55.83 188.76,56.23 188.86,56.33 189.16,56.33 189.26,56.23 189.26,55.83 189.46,55.63 189.97,55.63 190.25,55.92 190.25,56.54 190.33,56.62 190.96,56.62 191.89,57.56 191.89,59.54 191.52,59.91 190.94,59.91 v5(190.94,59.91)
CNV_PRX_DTX_N1: length 38
  TOP w0.066: v5(190.47,60.93) 190.41,60.87 UWL1.A37
  IN1 w0.061: v1(168.73,44.21) 168.87,44.34 v2(169.03,44.34)
  IN3 w0.061: v2(169.03,44.34) 169.04,44.33 170.62,44.33 171.26,43.7 172.46,43.7 178.27,49.5 178.27,50.41 179.77,51.91 179.77,54.92 180.21,55.37 180.75,55.37 180.93,55.55 182.28,55.55 182.8,55.03 190.19,55.03 192.48,57.32 192.48,59.82 191.36,60.94 190.48,60.94 v5(190.47,60.93)
CNV_PRX_DTX_P0: length 37.2
  TOP w0.066: UWL1.A34 190.25,59.37 190.47,59.59 190.67,59.59 v5(190.94,59.32)
  IN1 w0.061: v2(171.41,44.65) 171.41,45.05 v1(171.33,45.12)
  IN3 w0.061: v2(171.41,44.65) 171.57,44.82 171.57,45.09 171.87,45.38 173.03,45.38 176.8,49.15 176.8,49.29 176.58,49.51 176.58,49.79 177.01,50.21 177.4,50.21 177.48,50.3 177.48,50.72 178.98,52.22 178.98,55.73 179.41,56.16 179.57,56.16 180.42,56.16 180.6,56.34 182.61,56.34 183.11,55.84 183.31,55.84 183.4,55.92 183.4,56.13 183.59,56.33 184.11,56.33 184.3,56.13 184.3,55.92 184.39,55.84 184.77,55.84 184.85,55.92 184.85,56.14 185.05,56.34 185.58,56.34 185.77,56.14 185.77,55.92 185.85,55.84 186.28,55.84 186.36,55.92 186.36,56.14 186.56,56.34 187.15,56.34 187.35,56.14 187.35,55.92 187.43,55.84 188.48,55.84 188.56,55.92 188.56,56.32 188.77,56.53 189.24,56.53 189.47,56.31 189.47,55.92 189.55,55.84 189.88,55.84 190.05,56 190.05,56.63 190.25,56.83 190.87,56.83 191.69,57.64 191.69,59.46 191.44,59.71 191.32,59.71 v5(190.94,59.32)
CNV_PRX_DTX_P1: length 37.9
  TOP w0.066: v5(190.47,60.35) 190.46,60.37 UWL1.A36
  IN1 w0.061: v2(168.99,44.87) 169.03,44.92 169.03,45.03 168.94,45.12 v1(168.73,45.12)
  IN3 w0.061: v2(168.99,44.87) 169.21,44.87 169.3,44.79 169.3,44.66 169.42,44.54 170.71,44.54 171.35,43.9 172.37,43.9 178.06,49.59 178.06,50.5 179.56,52 179.56,55.01 180.13,55.57 180.67,55.57 180.84,55.75 182.37,55.75 182.89,55.23 190.1,55.23 192.27,57.4 192.27,59.74 191.28,60.73 190.84,60.73 190.47,60.37 v5(190.47,60.35)
CNV_PTX_DRX_N0: length 23.8
  IN1 w0.061: v1(182.17,59.87) 182.02,60.02 181.82,60.02 181.62,60.21 181.62,60.5 181.54,60.58 181.18,60.58 181.1,60.5 181.1,59.96 180.9,59.76 180.36,59.76 180.16,59.96 180.16,60.42 180.08,60.5 179.93,60.5 179.3,59.87 179.3,59.76 179.62,59.44 179.62,58.98 179.42,58.77 179.01,58.77 178.78,59.01 178.52,59.01 178.15,58.64 178.15,56.08 178.44,55.79 178.44,50.95 178.25,50.76 178.25,50.53 177.77,50.05 177.54,50.05 177.21,49.72 177.21,49.49 176.73,49.01 176.5,49.01 176.17,48.67 176.17,48.45 175.68,47.96 175.46,47.96 175.12,47.63 175.12,47.4 174.51,46.79 173.79,46.79 173.64,46.64 173.64,46.01 173.72,45.93 174.05,45.93 v1(174.13,46.01)
CNV_PTX_DRX_N1: length 23.6
  IN1 w0.061: v1(182.17,58.87) 182.17,59.03 182.11,59.1 182.06,59.1 181.99,59.17 181.69,59.17 181.62,59.1 181.62,58.52 181.43,58.32 180.97,58.32 180.77,58.52 180.77,59.09 180.66,59.2 180.32,59.2 180.21,59.09 180.21,58.36 180.01,58.16 179,58.16 178.72,57.88 178.72,56.94 179.15,56.5 179.15,55.84 179.02,55.71 179.02,55.08 179.15,54.95 179.15,54.3 179.02,54.18 179.02,53.86 179.15,53.73 179.15,53.06 179.02,52.93 179.02,52.54 179.15,52.41 179.15,51.79 179.02,51.66 179.02,51.3 179.15,51.17 179.15,50.6 174.72,46.17 174.72,46.05 175.08,45.69 175.08,45.28 174.81,45.02 174.41,45.02 174.18,45.24 173.98,45.24 173.83,45.1 173.83,45.06 173.57,44.8 173.45,44.8 173.37,44.88 173.37,45 v1(173.47,45.1)
CNV_PTX_DRX_P0: length 23.9
  IN1 w0.061: v1(182.17,60.37) 182.17,60.37 182.01,60.2 181.92,60.2 181.83,60.3 181.83,60.58 181.63,60.78 181.09,60.78 180.89,60.58 180.89,60.05 180.81,59.97 180.44,59.97 180.36,60.05 180.36,60.51 180.16,60.71 179.85,60.71 179.1,59.96 179.1,59.67 179.42,59.35 179.42,59.06 179.34,58.98 179.1,58.98 178.86,59.21 178.44,59.21 177.95,58.72 177.95,56 178.24,55.71 178.24,51.03 178.05,50.84 178.05,50.62 177.69,50.25 177.46,50.25 177.01,49.8 177.01,49.57 176.64,49.21 176.42,49.21 175.96,48.76 175.96,48.53 175.6,48.17 175.37,48.17 174.92,47.71 174.92,47.49 174.43,46.99 173.7,46.99 173.44,46.73 173.44,45.93 173.53,45.83 v1(173.53,45.75)
CNV_PTX_DRX_P1: length 23.6
  IN1 w0.061: v1(182.17,59.37) 182.17,59.37 181.6,59.37 181.42,59.19 181.42,58.6 181.34,58.53 181.05,58.53 180.97,58.6 180.97,59.17 180.75,59.4 180.23,59.4 180,59.17 180,58.45 179.93,58.37 178.92,58.37 178.52,57.97 178.52,56.85 178.95,56.42 178.95,55.92 178.82,55.79 178.82,55 178.95,54.87 178.95,54.39 178.82,54.26 178.82,53.78 178.95,53.65 178.95,53.14 178.82,53.02 178.82,52.46 178.95,52.33 178.95,51.87 178.82,51.75 178.82,51.21 178.95,51.08 178.95,50.69 174.52,46.26 174.52,45.96 174.87,45.61 174.87,45.36 174.73,45.22 174.49,45.22 174.27,45.44 173.48,45.44 173.14,45.1 v1(172.82,45.1)
CNV_RF_RESET#: length 49
  TOP w0.081: v1(195.13,56.49) RW13.1 194.86,57.39 194.86,58.24 195.04,58.41 QW1.2
  IN1 w0.064: v2(164.91,48.48) 164.9,48.48 164.69,48.27 164.61,48.27 163.87,47.53 163.68,47.53 163.43,47.29 v1(163.06,47.29) ; v1(191.62,62.37) 191.88,62.63 191.88,63.24 192.34,63.69 193.18,63.69 193.71,63.16 193.71,55.63 v2(193.77,55.57) 194.21,55.57 v1(195.13,56.49)
  IN2 w0.051: v2(164.91,48.48) 164.96,48.48 164.97,48.5 166.15,48.5 167.59,49.93 171.79,49.93 175.96,54.11 180.56,54.11 180.58,54.13 190.87,54.13 191,54.27 191.19,54.45 192.27,54.45 193.39,55.57 v2(193.77,55.57)
CNV_RF_RESET#_R: length 12.5
  TOP w0.081: RW13.2 195.71,57.36 195.54,57.53 v1(195.25,57.53)
  IN1 w0.064: v1(195.25,57.53) 195.47,57.76 195.47,58.49 195.85,58.87 195.85,59.19 195.61,59.42 195.61,60.2 194.79,61.02 194.79,62.86 193.58,64.07 190.58,64.07 v1(189.87,63.37)
CNV_RF_RST: length 28.9
  TOP w0.081: v1(195.94,58.19) 196.46,58.19 RW46.1 196.98,57.67 196.98,56.75 196.76,56.53 RW19.1
  IN1 w0.064: v1(195.94,58.19) 196.34,58.19 v2(196.39,58.14) ; v2(217.59,57.85) 217.89,57.85 218.87,56.87 219.34,56.87 v1(219.59,56.62)
  IN3 w0.064: v2(196.39,58.14) 197.72,58.14 198.42,57.44 200.18,57.44 200.7,57.95 205.12,57.95 206.35,56.73 207.48,56.73 208.18,57.43 212.71,57.43 213.02,57.12 214.62,57.12 214.71,57.04 215.2,57.04 215.37,57.2 215.65,57.2 215.96,57.5 217.24,57.5 v2(217.59,57.85)
CNV_RGI_PRX_DTX: length 35.2
  IN1 w0.064: v1(171.33,37.8) 171.4,37.8 171.8,38.2 v2(171.8,38.2)
  IN3 w0.064: v2(171.8,38.2) 171.94,38.43 171.91,38.55 171.9,38.6 171.9,38.69 172.86,39.65 173.73,39.65 174.14,39.65 175.04,40.55 175.04,41.9 174.93,42 174.93,44.34 176.79,46.19 178.09,46.19 178.68,46.79 178.68,48.62 179.12,49.07 179.12,50 183.08,53.95 190.67,53.95 192.4,55.68 192.91,55.68 193.47,56.23 v4(194.06,56.23)
  BOTTOM w0.081: RW31.2 v4(194.06,56.23)
CNV_RGI_PRX_R_DTX: length 10.5
  TOP w0.081: UWL1.A41 190.53,62.87 191.53,61.87 v1(191.62,61.87)
  IN1 w0.064: v1(191.62,61.87) 191.23,62.26 v2(191.23,62.58)
  IN3 w0.064: v4(193.06,57.18) 193.06,61.67 192.79,61.94 191.56,61.94 191.23,62.27 v2(191.23,62.58)
  BOTTOM w0.081: v4(193.06,57.18) 193.37,56.87 RW31.1
CNV_RGI_PTX_DRX: length 41.2
  IN1 w0.064: v2(172.38,38.34) 172.16,38.34 171.98,38.53 v1(171.98,38.72)
  IN3 w0.064: v2(172.38,38.34) 172.15,38.48 172.1,38.67 172.93,39.5 173.82,39.5 174.27,39.5 175.23,40.46 175.23,42.09 175.1,42.22 175.1,44.23 176.87,46 178.16,46 178.87,46.71 178.87,48.54 179.31,48.99 179.31,49.92 183.16,53.76 190.75,53.76 192.48,55.49 192.99,55.49 193.48,55.97 194.17,55.97 194.47,56.27 194.47,58.46 193.79,59.14 193.79,60.47 193.86,60.55 194.27,60.55 194.34,60.62 194.34,60.73 194.27,60.8 193.86,60.8 193.79,60.88 193.79,61.04 v4(194.06,61.31)
CNV_RGI_PTX_R_DRX: length 6
  IN1 w0.064: v1(189.87,62.37) 190.37,61.87 v2(190.39,61.87)
  IN3 w0.064: v2(190.39,61.87) 190.39,61.87 v4(190.66,62.14)
  BOTTOM w0.081: v4(190.66,62.14) 190.68,62.16 v3(191.93,62.16) 192.29,62.16 193.14,61.31 RC503.2 RW29.1 RW30.1 RW37.1
CNV_RGI_PTX_R_DRX_R: length 7.2
  IN1 w0.064: v1(191.62,61.37) 191.9,61.37 v2(192.06,61.52)
  IN3 w0.064: v2(192.06,61.52) 192.14,61.44 v4(192.5,61.44)
  BOTTOM w0.081: RW36.2 195.4,61.06 195.4,60.48 v3(195.07,60.15) 194.9,59.98 ; 194.72,59.81 194.52,59.6 RW37.2 193.74,59.28 193.15,59.28 193.07,59.36 193.07,60.87 v4(192.5,61.44)
  BOTTOM w0.089: 194.72,59.81 194.9,59.98
CNV_WT_RCOMP: length 2.8
  IN1 w0.064: v2(171.95,45.82) 172.8,45.82 v1(172.88,45.75)
  IN3 w0.081: v2(171.95,45.82) 172.08,45.69 v4(172.65,45.69)
  BOTTOM w0.102: v4(172.65,45.69) 172.39,45.69 v3(171.81,46.27)
CNVI_EN#: length 32.1
  TOP w0.081: v1(196.04,59.78) 196.04,59.55 196.17,59.42 197.06,59.42 197.19,59.29 197.19,58.74 RW46.2
  IN1 w0.064: v2(196.15,60.27) 196.04,60.17 v1(196.04,59.78)
  IN2 w0.051: v2(196.15,60.27) 193.04,60.27 190.57,57.81 189.45,57.81 188.08,59.18 v2(187.33,59.18)
  IN3 w0.064: v4(187.75,59.18) v2(187.33,59.18)
  BOTTOM w0.081: Q350.2 177.25,63.38 RH729.2 R529.1 178.12,64.93 v3(178.12,66.55) 178.12,66.76 178.4,67.04 181.76,67.04 187.98,60.82 187.98,59.41 v4(187.75,59.18)
CNVI_EN#_R: length 46.7
  IN1 w0.081: v2(156.93,45.64) 156.79,45.78 v1(156.79,45.98)
  IN3 w0.064: v4(166.83,50.31) 167.06,50.31 168,51.26 168.19,51.26 168.81,51.88 172.66,51.88 v4(173.27,52.49)
  IN3 w0.081: v4(156.88,45.97) 156.93,45.93 v2(156.93,45.64)
  BOTTOM w0.081: v4(173.27,52.49) 173.27,52.49 173.87,53.1 177.31,53.1 181.44,57.22 182.26,57.22 182.34,57.31 182.34,60.09 181.94,60.49 179.36,60.49 177.77,62.08 RH729.1 ; v4(156.88,45.97) 155.89,45.97 155.47,46.4 v3(155.47,50.64) 155.47,50.87 156.06,51.46 165.69,51.46 v4(166.83,50.31)
CODEC_MUTE#: length 6.2
  TOP w0.081: RA57.2 RA21.1 CA55.1 29.14,11.7 28.14,12.69 UA1.2 ; RA57.2 29.56,9.78 v3(29.56,9.31) ; RA57.2 28.79,9.84 RA66.1 28.4,9.92 DA10.2
CORE_VID0: length 92.6
  TOP w0.081: v5(183.23,28.97) 183.23,29.52 184.21,30.49 184.21,31 183.31,31.9 183.31,32.84 182.84,33.31 182.84,34.91 183.34,35.42 184.32,35.42 184.5,35.6 184.5,35.72 185.2,36.42 185.2,36.99 184.94,37.25 184.31,37.25 184.05,37.51 184.05,39.61 183.8,39.86 183.73,39.86 182.8,40.79 UC6.1 182.36,40.79 181.52,41.63 181.52,42.24 181.28,42.47 179.67,42.47 RC690.2 ; RC611.2 RC609.2 138.45,4.4 138.53,4.48 139.92,4.48 v1(141.13,5.69) ; PU900.6 141.66,7.81 141.12,7.26 v1(141.12,7.05)
  IN1 w0.064: v2(141.45,5.56) 141.26,5.56 v1(141.13,5.69) 141.12,5.71 v1(141.12,7.05)
  IN2 w0.051: v5(183.23,28.97) 182.95,28.97 182.41,28.43 181.44,28.43 179.65,26.64 179.65,23.4 178.41,22.16 172.73,22.16 170.02,19.45 170.02,15.29 171.57,13.74 171.57,6.92 170.47,5.82 144.91,5.82 143.68,7.04 142.33,7.04 141.45,6.16 v2(141.45,5.56)
  BOTTOM w0.081: v5(183.23,28.97) 183.17,29.03 v3(183.17,29.45)
CORE_VID0_R: length 19.3
  TOP w0.081: RC690.1 178.66,42.14 v1(178.34,42.45)
  TOP w0.089: UC1.CL38 v1(161.07,42.71)
  IN1 w0.064: v1(178.34,42.45) 178.14,42.25 173.46,42.25 173.33,42.38 171.26,42.38 170.72,41.85 167.28,41.85 166.58,42.55 164.79,42.55 164.61,42.73 163.23,42.73 163.12,42.84 162.36,42.84 162.23,42.71 v1(161.07,42.71)
CORE_VID1: length 116.6
  TOP w0.081: v5(183.66,29.39) 183.66,29.67 v3(184.5,30.52) 184.5,31.02 183.49,32.03 183.49,32.92 183.02,33.39 183.02,34.84 183.42,35.23 184.39,35.23 184.68,35.52 184.68,35.64 185.38,36.34 185.38,37.07 185.02,37.43 184.39,37.43 184.23,37.59 184.23,39.46 184.23,39.46 184.23,39.68 183.87,40.04 183.8,40.04 183.23,40.62 183.23,41.03 182.82,41.44 UC6.2 182.22,41.44 181.95,41.71 v1(181.95,42.09) ; v1(140.53,5.56) 139.64,4.67 138.02,4.67 137.86,4.52 RC610.2 RC612.2 ; PU900.5 141.26,7.82 140.53,7.09 v1(140.53,7.05)
  IN1 w0.064: v1(140.53,7.05) v2(140.53,6.01) v1(140.53,5.56) ; v1(181.95,42.09) 173.15,42.09 172.59,41.52 172.08,41.52 171.61,42 v2(171.6,42)
  IN2 w0.051: v2(140.53,6.01) 141.72,7.2 143.75,7.2 144.97,5.97 170.4,5.97 171.42,6.98 171.42,13.68 169.87,15.22 169.87,19.52 172.67,22.32 178.34,22.32 179.5,23.47 179.5,26.58 179.5,26.71 181.38,28.59 182.35,28.59 183.16,29.39 v5(183.66,29.39)
  IN3 w0.064: v4(159.94,42.33) 162.04,42.33 162.91,43.19 162.91,44.11 163.1,44.3 163.67,44.3 163.86,44.11 163.86,43.28 164.94,42.2 166.19,42.2 166.99,41.4 167.28,41.4 168.14,40.55 169.9,40.55 170.28,40.93 170.28,41.36 170.76,41.85 171.2,41.85 171.35,42 v2(171.6,42)
CORE_VID1_R: length 2.3
  TOP w0.089: UC1.CJ38 159.31,42.31 158.97,42.65 v5(158.86,42.65)
  BOTTOM w0.081: RC689.1 159.04,42.65 v5(158.86,42.65) v3(158.15,42.65)
CPU_B+: length 7.5
  TOP w0.254: PR1104.1 v1(94.33,43.98)
  IN1 w0.254: v1(94.01,37.88) 94.01,42.37 94.49,42.85 94.49,43.83 v1(94.33,43.98)
  BOTTOM w0.081: v5(95.09,28.5) v6(94.53,28.5)
  vias: v5(95.14,35.2) v5(95.14,34.62) v5(95.14,34.03) v5(95.21,25.85) v5(95.51,25.35) v5(95.73,34.62) v5(95.73,34.03) v5(95.68,28.5) v5(95.7,27.94) v5(95.79,25.85) v5(96.07,25.35) v5(96.29,34.62) v5(96.29,34.03) v5(96.29,28.5) v5(96.29,27.91) v5(96.36,25.85) v5(96.63,25.35) v5(97.23,24.05) v5(97.23,23.47) v5(100.22,27.66) v5(100.3,36.75) v5(104.54,36.19) v5(104.46,27.09)
CPU_C10_GATE#: length 56.8
  TOP w0.081: v5(151.67,17.36) 151.4,17.36 151.15,17.1 UC10.1 151.15,16.34 150.73,15.92 150.73,15.67 150.62,15.56 RC631.2 RC226.1 ; RH280.2 177.36,43.83 v5(177.09,44.11)
  IN2 w0.051: v2(155.2,23.66) 155.56,23.66 156.43,22.79 156.43,21.46 155.2,20.23 154.54,20.23 v5(151.67,17.36)
  IN3 w0.064: v2(155.2,23.66) 155.62,23.66 155.62,23.66 v4(155.67,23.66)
  BOTTOM w0.081: v5(177.09,44.11) 174.5,41.52 172.17,41.52 171.83,41.18 169.27,41.18 168.46,40.37 167.03,40.37 166.66,40.74 164.97,40.74 164.88,40.65 164.88,40.41 165.12,40.17 165.64,40.17 166.5,39.31 166.6,39.31 167.28,38.62 167.28,38.17 167.06,37.94 167.06,32.23 166.85,32.02 v3(166.85,31.15) 167.53,30.47 167.53,28.28 166.47,27.21 166.47,26.36 164.42,24.32 156.71,24.32 156.05,23.66 v4(155.67,23.66)
CPU_C10_GATE#_R: length 3.4
  TOP w0.081: UC1.DU40 174.04,43.12 174.32,42.84 175.42,42.84 176.06,43.47 RH280.1
CPU_EOPIO_RCOMP: length 2.2
  TOP w0.254: UC1.B14 126.69,30.7 126.65,30.67 126.65,30.64 126.5,30.49 v5(126.5,30.45)
  BOTTOM w0.102: v3(126.13,30.08) v5(126.5,30.45)
  BOTTOM w0.305: v5(126.5,30.45) 126.5,30.58 126.97,31.06 RH7.1
CPU_ID_0: length 8.3
  TOP w0.081: UC1.DT40 173.23,43.12 173.82,42.53 173.82,42.36 173.98,42.2 175.17,42.2 176.07,43.1 179.4,43.1 179.76,43.47 RH745.2 180.27,43.47 RH747.2
CPU_ID_1: length 7.6
  TOP w0.081: UC1.DW40 174.57,43.12 175.92,44.48 177.24,44.48 177.52,44.2 177.52,44.04 177.64,43.92 177.83,43.92 177.98,43.76 RH746.2 178.49,43.98 178.72,43.98 v3(179.36,44.61) 179.36,45.15 RH748.2
CPU_POPI_RCOMP: length 1.6
  IN1 w0.254: v2(159.86,43.89) 159.67,43.7 v1(159.67,43.61)
  IN3 w0.254: v4(159.99,43.57) 159.99,43.76 v2(159.86,43.89)
  BOTTOM w0.102: v4(159.99,43.57) v3(159.07,43.57)
CPU_RC_ID: length 8.2
  TOP w0.081: UE1.F2 207.49,62.37 207.49,62.97 207.23,63.22 205.96,63.22 205.33,63.85 v1(204.9,63.85) ; RE525.2 205.19,67.23 205.46,66.97 v1(205.46,66.27)
  IN1 w0.064: v1(205.46,66.27) 204.9,65.71 v1(204.9,63.85)
CPU_TCP0_HPD: length 1
  IN1 w0.081: v2(164.9,42.96) v1(164.25,42.96)
  IN3 w0.064: v2(164.9,42.96) 165.05,42.96 v4(165.2,42.81)
CPUPWRGD: length 5.2
  TOP w0.081: RH595.1 CC650.1 158.06,20.8 v3(158.35,21.09) UC1.CF1
CPUPWRGD_R: length 1.1
  TOP w0.081: RH595.2 TP70.1
CPVEE: length 3.8
  TOP w0.102: v3(31.78,22.33) 32.16,21.94 32.58,21.94 CA18.1
  TOP w0.305: 32.46,19.81 32.89,20.13 CA18.1
CS1: length 13
  IN1 w0.254: v2(101.89,34.52) 102.36,34.99 v1(102.36,35.53) ; v1(95.88,41.81) 95.68,42.01 v2(95.47,42.01)
  IN3 w0.254: v2(101.89,34.52) 101.81,34.59 99.89,34.59 96.24,38.25 96.24,41.25 v2(95.47,42.01)
CS2: length 25.6
  TOP w0.254: v1(94.58,41.94) 94.43,41.94 93.91,42.45 PR1110.1
  IN1 w0.254: v1(94.58,41.94) 94.83,41.69 v2(94.97,41.69) ; v1(102.34,26.36) 102.34,25.63 101.75,25.04 v2(101.75,24.59)
  IN3 w0.254: v2(101.75,24.59) 98.24,24.59 96.77,26.06 96.77,37.06 95.88,37.95 95.88,40.97 95.15,41.69 v2(94.97,41.69)
CSI_RCOMP: length 6.6
  TOP w0.081: RC8.1 124.69,23.87 125.32,24.5 125.32,25.25 125.7,25.63
  TOP w0.089: UC1.B4 126.25,25.63 125.7,25.63
  TOP w0.127: v3(121.89,22.96) 122.12,22.96 122.93,23.77 RC8.1
CSSUM: length 6.9
  TOP w0.254: PR1108.1 v1(96.57,42.69)
  IN1 w0.254: v1(96.57,42.69) 98.21,42.69 100.45,44.93 100.45,46.15 v1(100.46,46.16)
DAT_SMB: length 7.6
  TOP w0.081: JT101.5 43.66,4.03 44.56,4.93 44.56,8.53 45.33,9.29 v6(45.33,9.53) 44.86,9.53 44.51,9.87 PR108.1
DAT_TP_SIO_I2C_CLK: length 3.6
  TOP w0.081: UE1.C12 216.24,64.02 217.12,64.02 217.46,64.36 218.1,64.36 RE468.2
DBC_EN: length 150.9
  TOP w0.081: v1(176.11,35.54) 175.97,35.54 175.6,35.91 174.77,35.91 UC1.DW24
  IN1 w0.064: v5(198.56,64.49) 198.32,64.25 198.32,60.55 200.23,58.64 200.23,54.48 199.3,53.56 197.61,51.86 197.61,51.27 198.17,50.7 198.17,49.77 193.94,45.53 193.94,34.38 194.47,33.85 194.47,31.49 194.08,31.1 194.08,30.23 193.67,29.82 193.67,27.47 194.22,26.93 194.22,26.68 v2(193.85,26.31) ; v2(176.37,35.84) 176.37,35.79 176.12,35.54 v1(176.11,35.54)
  IN2 w0.051: v2(176.37,35.84) 176.55,35.65 178.83,35.65 179.47,35.01 182.58,35.01 182.79,35.23 184.61,35.23 189.28,30.56 189.28,27.91 190.88,26.3 193.84,26.3 v2(193.85,26.31)
  IN3 w0.064: v5(198.56,64.49) 198.2,64.49 198.12,64.41 173.45,64.41 172.48,65.38 172.48,70.61 169.27,73.83 169.27,77.29 166.65,79.91 159.93,79.91 158.56,78.54 156.92,78.54 156.91,78.54 156.64,78.54 153.91,75.81 153.91,74.8 153.96,74.75 153.96,72.94 153.04,72.03 145.24,72.03 141.64,75.63 141.64,76.1 v4(141.19,76.54)
  BOTTOM w0.081: v4(141.19,76.54) 141.19,78.59 142.84,80.24 RH622.1 ; v5(198.56,64.49) 198.56,64.65 v3(197.96,65.25)
DBC_EN_R: length 8.9
  TOP w0.081: v5(142.08,82.12) 142.08,82.46 140.9,83.64 JEDP1.1
  IN1 w0.064: v1(141.01,78.73) 142.33,78.73 142.9,79.3 142.9,81.3 v5(142.08,82.12)
  BOTTOM w0.081: RH622.2 v5(142.08,82.12) 141.88,82.32 v3(141.88,82.62)
DBG_PMODE: length 116.2
  TOP w0.081: v1(109.6,4.99) v3(109.6,7.28) 109.6,17.55 v1(109.51,17.63)
  IN1 w0.064: v2(109.89,17.63) 109.89,17.63 v1(109.51,17.63) ; v1(109.6,4.99) 109.6,4 109.93,3.67 v2(109.93,2.97)
  IN1 w0.081: v1(170.68,31.4) 170.68,31.07 v2(170.6,30.98)
  IN2 w0.051: v2(170.6,30.98) 170.6,30.98 173.68,27.89 175.58,27.89 176.07,27.4 176.07,23.5 175.04,22.47 172.6,22.47 169.72,19.58 169.72,15.16 171.26,13.61 171.26,7.04 170.34,6.12 145.04,6.12 143.81,7.35 141.41,7.35 138.91,4.85 128.88,4.85 127.11,3.07 122.56,3.07 122.01,3.63 120.19,3.63 119.46,2.9 111,2.9 110.63,3.28 110.23,3.28 v2(109.93,2.97)
  IN3 w0.064: v4(109.29,17.27) 109.34,17.27 109.75,17.68 109.84,17.68 v2(109.89,17.63)
  BOTTOM w0.081: v4(109.29,17.27) 109.19,17.17 109.19,16.14 109.18,16.13 109.18,16.13 108.87,15.82 R270.1 R6143.1 R545.2
DBG_PMODE_MIPI60_RST#: length 4.5
  BOTTOM w0.081: R544.1 R545.1 109.51,14.28 109.59,14.2 110.4,14.2 111.5,13.09 JMIPI60.7
DDR_A_CA0: length 35.3
  IN1 w0.081: v1(164.01,63.81) 164.04,63.81 164.36,63.56 v2(164.36,63.53) ; v2(164.35,59.58) 164.02,59.26 v1(164.01,59.26)
  IN1 w0.099: v1(149.28,47.29) 149.18,47.29 148.87,47.6 148.87,47.6 148.8,47.67 148.8,48.14 149.11,48.45 149.18,48.45 149.28,48.56 149.28,50.57 153.91,55.19 153.91,56.89 154.31,57.3 154.31,58.13 154.55,58.36 154.82,58.36 156.24,59.78 156.24,60.2 156.38,60.35 156.93,60.35 157.03,60.45 157.72,60.45 157.94,60.68 158.22,60.68 158.33,60.78 158.73,60.78 158.98,60.53 159.14,60.53 159.26,60.65 159.26,60.81 159.06,61.01 159.06,61.17 159.06,61.68 159.6,62.22 159.92,62.22 160.25,62.55 161.91,62.55 162.35,62.1 162.84,62.1 162.95,62.21 163.35,62.21 163.45,62.11 164.16,62.11 164.47,61.8 164.47,61.27 164.61,61.14 165.11,61.14 165.36,61.39 v2(165.36,61.58)
  IN3 w0.099: v2(164.35,59.58) 164.89,59.58 165.34,60.03 165.34,61.56 v2(165.36,61.58) 165.36,61.83 165.3,61.9 165.3,63.23 165,63.53 v2(164.36,63.53)
DDR_A_CA1: length 34
  IN1 w0.081: v1(164.01,63.16) 164.03,63.18 164.29,63.21 164.39,63.13 v2(164.4,63.02)
  IN1 w0.099: v1(164.01,59.91) v2(164.41,60.23) ; v1(148.04,46.63) 147.86,46.82 147.86,48.58 148.26,48.98 148.26,48.98 148.28,49 148.28,50.99 152.43,55.14 152.43,59.56 154.64,61.78 155.5,61.78 155.59,61.86 156.59,61.86 156.65,61.8 157.36,61.8 157.47,61.91 158.94,61.91 159.5,62.46 159.79,62.46 160.14,62.81 162.48,62.81 162.78,62.51 163.44,62.51 163.87,62.79 164.1,62.79 164.27,62.61 v2(164.76,62.04)
  IN3 w0.099: v2(164.41,60.23) 164.52,60.92 164.52,61.6 164.67,61.95 v2(164.76,62.04) 164.76,62.14 164.63,62.27 164.28,62.27 164.21,62.34 164.21,62.6 164.27,62.66 164.56,62.66 164.62,62.72 164.62,62.84 164.44,63.02 v2(164.4,63.02)
DDR_A_CA2: length 33.1
  IN1 w0.081: v2(158.03,63.51) 158.11,63.5 158.4,63.72 v1(158.41,63.81)
  IN1 w0.099: v1(158.41,59.26) v2(158.01,59.62) ; v2(158.64,61.44) 158.62,61.46 158.6,61.46 158.5,61.57 156.36,61.57 156.32,61.6 155.74,61.6 155.66,61.52 154.75,61.52 152.68,59.46 152.68,55.04 148.53,50.89 148.53,48.89 148.51,48.88 148.51,48.87 148.51,48.87 148.1,48.45 148.1,47.15 148.3,46.95 148.3,46.53 148.15,46.38 147,46.38 146.88,46.25 146.88,46.02 146.98,45.92 147.09,45.92 147.21,45.81 147.21,45.66 147.09,45.55 146.78,45.55 146.66,45.43 146.66,45.27 146.78,45.15 147.09,45.15 147.21,45.04 147.21,45.01 147.31,44.91 147.47,44.91 147.6,45.03 147.6,45.81 147.72,45.92 147.98,45.92 v1(148.04,45.98)
  IN3 w0.099: v2(158.01,59.62) 158.05,59.59 158.32,59.59 158.41,59.67 158.41,60.6 158.64,60.83 v2(158.64,61.44) 158.38,61.71 158.38,63.16 v2(158.03,63.51)
DDR_A_CA3: length 34.5
  IN1 w0.081: v1(157.61,59.26) 157.61,59.14 157.84,58.92 v2(157.92,58.92)
  IN1 w0.099: v2(157.67,61.21) 157.83,61.05 157.83,60.91 157.61,60.69 157.22,60.69 157.03,60.88 156.7,60.88 156.46,60.64 156.37,60.64 156.06,60.94 155.9,60.94 155.78,60.83 155.78,60.66 156,60.44 156,60.26 155.86,60.11 155.72,60.11 155.34,60.49 155.25,60.49 155.02,60.26 155.02,60.15 155.56,59.6 155.56,59.46 155.42,59.32 155.26,59.32 154.43,60.15 154.23,60.15 154.11,60.03 154.11,59.88 154.96,59.03 154.96,58.86 154.84,58.74 154.7,58.74 154.33,59.11 154.17,59.11 154.05,58.99 154.05,58.83 154.2,58.67 154.2,58.58 153.94,58.32 153.34,58.32 153.22,58.21 153.22,58.04 153.34,57.93 153.94,57.93 154.01,57.86 154.01,57.5 153.93,57.43 153.79,57.43 153.74,57.38 153.74,57.09 153.65,57 153.65,55.3 149.03,50.68 149.03,48.7 148.56,48.23 148.56,47.5 149.11,46.95 149.26,46.95 149.36,46.85 149.36,46.71 v1(149.28,46.63) ; v2(157.25,64.14) 157.28,64.14 v1(157.61,63.81)
  IN3 w0.099: v2(157.92,58.92) 158.09,58.92 158.19,59.01 158.19,59.18 158.09,59.28 157.72,59.28 157.6,59.4 157.6,60.38 157.91,60.69 157.91,60.97 v2(157.67,61.21) 157.76,61.3 157.76,62.6 157.63,62.73 157.63,63.76 v2(157.25,64.14)

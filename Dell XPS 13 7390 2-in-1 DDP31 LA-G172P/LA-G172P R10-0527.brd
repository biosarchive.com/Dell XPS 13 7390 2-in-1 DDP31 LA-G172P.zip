# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TACH_FAN2: length 94.4
  TOP w0.081: v5(226.39,23.5) 225.93,23.5 223.9,21.47 223.9,7.33 224.67,6.55 225.5,6.55 227.48,8.54 229.4,8.54 229.83,8.11 231.99,8.11 232.13,7.97 232.13,6.64 235.06,3.71 D12.2 235.06,2.36 234.7,2.01 R40.1
  IN1 w0.064: v1(207.1,63.56) 207.26,63.56 207.5,63.81 207.54,63.81 v2(207.55,63.81)
  IN3 w0.064: v2(207.55,63.81) 207.55,62.62 208.29,61.88 208.56,61.88 209.46,60.98 211.05,60.98 211.09,61.03 212.12,61.03 213.01,60.14 213.27,60.14 213.91,60.14 214.14,59.9 214.54,59.9 215.13,60.49 218.47,60.49 219.27,59.69 219.27,48.41 215.55,44.69 215.55,38.42 216.85,37.12 219.46,37.12 221.36,35.22 221.36,33.87 221.37,33.87 221.37,27.64 225.51,23.5 v5(226.39,23.5)
  BOTTOM w0.081: v5(226.39,23.5) v3(226.39,24.02)
TAP_FW_RDY#: length 96.2
  TOP w0.081: RE493.1 220.76,50.35 220.25,49.85 218.23,49.85 217.91,49.53 217.05,49.53 216.54,49.02 216.54,48.33 215.74,47.53 214.66,47.53 214.48,47.72 v3(214.47,47.72) 213.92,48.27 v1(212.5,48.27)
  IN1 w0.064: v2(246.85,10.24) 247.28,9.82 250.35,9.82 250.55,9.62 v1(250.55,8.93) ; v1(212.5,48.27) v2(212.5,49.06) 212.45,49.11 212.45,49.71 212.65,49.91 212.65,52.74 213.37,53.46 213.37,55.14 213.74,55.51 213.74,56.38 214.3,56.95 v1(214.3,57.16)
  IN2 w0.051: v2(246.85,10.24) 245.94,11.15 231.32,11.15 222.55,19.92 222.55,22.96 222.11,23.4 222.11,24.57 221.3,25.38 220.71,25.38 220.24,25.85 220.24,26.92 221.24,27.92 221.24,37.22 220.49,37.97 220.49,39.7 219.46,40.74 218.61,40.74 218.19,41.16 218.19,43.83 218.56,44.19 218.56,45.96 219.3,46.7 219.3,49.58 218.85,50.02 214.14,50.02 213.18,49.06 v2(212.5,49.06)
TAP_RESET#: length 113.1
  TOP w0.081: v1(216.21,57.57) 215.79,57.57 215.38,57.16 UE1.M11 ; v5(252.06,9.76) 252.35,9.48 JIO1.30 ; v3(263.51,12.84) v1(263.51,13.24)
  IN1 w0.064: v1(263.51,13.24) 263.23,13.52 v2(263.23,15.33) ; v2(216.47,50.54) 216.47,51.22 215.8,51.88 215.8,52.67 216.02,52.89 216.02,55.04 215.91,55.15 215.91,55.6 216.03,55.73 216.03,57.39 v1(216.21,57.57)
  IN2 w0.051: v2(216.47,50.54) 217,51.08 219.09,51.08 219.6,50.57 219.6,46.57 218.87,45.83 218.87,44.07 218.5,43.7 218.5,41.29 218.74,41.04 219.58,41.04 220.8,39.83 220.8,38.09 221.54,37.35 221.54,27.79 220.55,26.8 220.55,25.98 220.84,25.69 221.44,25.69 222.41,24.72 222.41,23.53 222.85,23.09 222.85,20.04 230,12.9 249.24,12.9 249.38,13.04 261.47,13.04 263.23,14.79 v2(263.23,15.33)
  IN3 w0.064: v4(263.7,15.48) 263.54,15.33 v2(263.23,15.33)
  BOTTOM w0.081: v4(263.7,15.48) 263.7,10.56 262.88,9.75 258.49,9.75 257.82,9.08 253.86,9.08 253.18,9.76 v5(252.06,9.76)
TAP_SMBCLK: length 127.1
  TOP w0.081: 252.12,11.17 252.23,11.29 RE523.2 ; 252.09,11.15 v1(252,11.06)
  TOP w0.102: 252.12,11.17 252.09,11.15
  IN1 w0.064: v2(212.21,63.41) 212.2,63.41 212.05,63.56 v1(211.9,63.56) 211.68,63.34 211.68,62.91 211.41,62.64 211.41,62.59 211.34,62.52 211.34,62.36 211.34,62.36 211.34,61.48 211.26,61.41 211.26,58.94 210.96,58.64 210.96,57.71 211.13,57.54 211.13,56.08 210.28,55.23 210.28,52.2 205.23,47.15 202.38,47.15 201.96,46.74 201.96,38.09 201.65,37.77 201.65,34.95 202.13,34.46 202.13,31.9 200.11,29.89 200.11,26.51 199.27,25.67 199.27,21.38 200.44,20.21 200.44,19.52 201.16,18.79 210.72,18.79 211.96,17.56 214.29,17.56 215.81,16.04 215.81,15.54 213.43,13.16 213.43,5.94 215.38,3.99 219.48,3.99 221.21,5.71 223.76,5.71 226.59,2.88 233.26,2.88 238.04,7.66 244.54,7.66 246.45,9.57 246.45,10.62 246.66,10.83 249.92,10.83 250.24,11.15 250.94,11.15 251.18,11.39 251.18,11.47 251.24,11.53 251.53,11.53 v1(252,11.06)
  IN3 w0.064: v2(212.21,63.41) 212.2,63.41 211.93,63.68 v4(211.93,63.69)
TAP_SMBCLK_R: length 3.7
  TOP w0.081: v1(250.82,10.39) 251,10.21 251,9.94 251.31,9.63 251.31,9.53 251.15,9.37 JIO1.26
  IN1 w0.064: v1(250.82,10.39) 251.14,10.7 v1(252.67,10.7)
TAP_SMBDAT: length 127.1
  TOP w0.081: v1(250.8,12.07) 251.21,12.48 RE524.2
  IN1 w0.064: v1(211.9,62.76) 212.14,62.76 v2(212.26,62.87) ; v1(250.8,12.07) 250.98,11.89 250.98,11.47 250.86,11.34 250.16,11.34 249.84,11.02 246.59,11.02 246.26,10.7 246.26,9.65 244.46,7.85 237.96,7.85 233.18,3.07 226.67,3.07 223.84,5.9 221.13,5.9 219.41,4.18 215.46,4.18 213.62,6.02 213.62,13.09 216,15.46 216,16.11 214.36,17.75 212.04,17.75 210.8,18.98 201.24,18.98 200.63,19.59 200.63,20.29 199.46,21.46 199.46,25.59 200.31,26.43 200.31,29.81 202.32,31.82 202.32,34.54 201.84,35.03 201.84,37.69 202.15,38.01 202.15,46.66 202.46,46.96 205.31,46.96 210.47,52.13 210.47,55.15 211.32,56.01 211.32,57.62 211.15,57.79 211.15,58.56 211.45,58.86 211.45,61.33 211.53,61.4 211.53,62.44 211.6,62.52
  IN1 w0.076: 211.6,62.52 211.85,62.76 v1(211.9,62.76)
  IN3 w0.064: v4(212.57,63.69) 212.57,63.19 v2(212.26,62.87)
TAP_SMBDAT_R: length 4.9
  TOP w0.081: RE524.1 252.5,12.07 251.46,12.07 251.26,11.87 251.26,10.61 251.45,10.43 D477.2 251.21,10.14 251.21,10.02 251.52,9.71 251.52,9.6 251.75,9.37 JIO1.28
TBT_0_DP_AUXN: length 160.4
  TOP w0.091: RT113.1 14.28,40.87 arc(14.35,40.76) 14.38,40.63 arc(14.35,40.48) 14.26,40.34 v5(14.19,40.27)
  IN1 w0.081: v2(145.38,26.33) 145.6,26.33 v1(145.69,26.23)
  IN3 w0.081: v2(145.38,26.33) 145.37,26.33 144.21,26.33 143.96,26.08 143.96,24.19 134.36,14.59 131.34,14.59 128.75,14.13 124,14.97 123.69,14.97 119.03,14.15 118.76,14.15 114.72,14.86 110.15,14.05 104.89,14.98 99.99,14.11 95.34,14.93 90.58,14.09 85.67,14.96 80.92,14.12 76.13,14.96 71.39,14.13 66.62,14.97 61.77,14.11 56.99,14.95 52.21,14.11 47.43,14.95 42.73,14.12 37.95,14.97 33.14,14.12 28.82,14.88 26.58,14.49 24,14.49 13.84,24.64 13.84,26.58 13.41,29.04 14.1,33.02 13.83,34.58 13.83,37.26 arc(13.9,37.6) 14.08,37.88 arc(14.09,37.9) 14.1,37.91 14.1,37.91 arc(14.31,38.22) 14.38,38.58 14.38,39.81 arc(14.33,40.06) v5(14.19,40.27)
TBT_0_DP_AUXN_R: length 7.5
  IN1 w0.081: v1(14.19,41.54) 14.19,40.99 14.39,40.8 14.82,40.8 15.21,41.18 15.21,42.96 15.38,43.14 15.38,44.63 14.28,45.73 v1(14.28,46.31)
TBT_0_DP_AUXP: length 160.4
  TOP w0.091: v5(14.77,40.27) 14.6,40.44 arc(14.58,40.47) 14.57,40.51 14.57,40.62 arc(14.6,40.75) 14.68,40.87 RT112.1
  IN1 w0.081: v1(145.69,26.88) 145.47,26.88 v2(145.37,26.98)
  IN3 w0.081: v2(145.37,26.98) 145.37,26.76 145.28,26.67 145.22,26.67 145.09,26.53 144.13,26.53 143.76,26.16 143.76,24.27 134.27,14.78 131.32,14.78 128.75,14.33 124.01,15.16 123.67,15.16 119.01,14.34 118.78,14.34 114.72,15.06 110.15,14.25 104.89,15.18 99.99,14.31 95.34,15.13 90.58,14.29 85.67,15.16 80.92,14.32 76.13,15.16 71.39,14.33 66.62,15.17 61.77,14.31 56.99,15.16 52.21,14.31 47.43,15.16 42.73,14.33 37.95,15.17 33.14,14.32 28.82,15.08 26.56,14.68 24.08,14.68 14.04,24.73 14.04,26.6 13.82,27.82 13.61,29.04 14.3,33.02 14.03,34.59 14.03,37.26 arc(14.08,37.52) 14.22,37.75 14.24,37.77 arc(14.49,38.14) 14.58,38.58 14.58,39.81 arc(14.63,40.06) v5(14.77,40.27)
TBT_0_DP_AUXP_R: length 7.4
  IN1 w0.081: v1(14.76,41.54) 14.68,41.62 14.54,41.62 14.46,41.54 14.46,41.43 14.39,41.36 14.39,41.08 14.47,40.99 14.74,40.99 15.01,41.26 15.01,43.04 15.18,43.22 15.18,44.55 14.09,45.65 14.09,45.87 14.01,45.95 13.91,45.95 13.82,46.03 v1(13.82,46.31)
TBT_0_LSX_RX: length 242.8
  IN1 w0.064: v2(96.06,3.03) 94.99,4.1 94.99,7.75 v2(95.17,7.92)
  IN1 w0.081: v2(178.3,33.99) 177.81,33.5 177.36,33.5 177.14,33.72 176.64,33.72 175.98,33.06 173.27,33.06 172.27,32.07 171.46,32.07 170.91,32.61 170.33,32.61 v1(170.03,32.31) 169.84,32.12 169.84,31.21 v2(169.58,30.95)
  IN2 w0.051: v2(169.58,30.95) 170.1,30.43 170.72,30.43 173.56,27.59 175.45,27.59 175.76,27.27 175.76,23.63 174.91,22.77 172.48,22.77 169.41,19.71 169.41,15.03 170.96,13.49 170.96,7.17 170.21,6.42 145.16,6.42 143.94,7.65 141.28,7.65 138.78,5.15 128.72,5.15 126.94,3.38 122.69,3.38 122.1,3.96 120.05,3.96 119.3,3.21 111.17,3.21 110.79,3.58 109.86,3.58 109.31,3.03 106.96,3.03 106.54,3.45 104.5,3.45 103.71,2.67 102.58,2.67 101.71,3.54 96.37,3.54 96.06,3.22 v2(96.06,3.03) ; v2(17.5,45.69) 17.09,45.69 16.97,45.58 16.97,45.05 17.83,44.19 17.83,39.47 17.04,38.68 17.04,37.65 17.41,37.28 17.41,34.37 15.78,32.74 15.78,27.66 16.89,26.55 16.89,24.87 16.57,24.55 16.57,23.11 20.04,19.64 20.31,19.37 20.31,18.03 24.46,13.88 31.53,13.88 32.06,13.35 77.35,13.35 80.02,10.67 80.02,10.2 81.27,8.96 81.27,8.18 82.87,6.58 91.89,6.58 93.23,7.92 v2(95.17,7.92)
  IN3 w0.064: v4(17.15,45.69) v2(17.5,45.69) ; v2(178.3,33.99) 178.19,33.88 v4(177.93,33.88)
  BOTTOM w0.081: R6172.2 v4(177.93,33.88)
TBT_0_LSX_RX_R: length 5
  TOP w0.076: v1(15.45,46.08) 14.92,46.08 14.46,45.62 14.11,45.62 13.89,45.85 13.83,45.85 URT1.L7
  IN1 w0.064: v1(15.45,46.08) 15.84,45.69 v2(16.08,45.69)
  IN3 w0.064: v4(16.57,45.69) v2(16.08,45.69)
  BOTTOM w0.081: v3(16.86,44.04) 16.57,44.33 RT2.2 v4(16.57,45.69)
TBT_0_LSX_TX: length 232.2
  IN1 w0.064: v2(96.62,3.21) 95.74,4.09 95.74,6.88 95.73,6.89 95.73,7.1 95.74,7.11 v2(95.74,7.92)
  IN1 w0.081: v1(170.68,32.31) 170.15,31.78 170.15,31.02 v2(170.09,30.96)
  IN2 w0.051: v2(95.74,7.92) 95.41,7.59 93.19,7.59 92.03,6.43 82.81,6.43 81.12,8.12 81.12,8.25 81.12,8.89 79.87,10.14 79.87,10.61 77.29,13.19 32,13.19 31.46,13.73 24.4,13.73 20.16,17.97 20.16,19.31 19.89,19.57 16.42,23.05 16.42,24.61 16.73,24.93 16.73,26.45 15.59,27.6 15.59,32.77 17.26,34.44 17.26,37.19 16.89,37.56 16.89,38.75 17.68,39.54 17.68,44.13 16.82,44.98 16.82,45.65 v2(17.5,46.33) ; v2(96.62,3.21) 101.82,3.21 102.52,2.51 103.78,2.51 104.56,3.3 106.48,3.3 106.9,2.88 109.37,2.88 109.92,3.43 110.69,3.43 111.07,3.05 119.4,3.05 120.13,3.78 122.07,3.78 122.63,3.22 127.04,3.22 128.82,5 138.85,5 141.34,7.5 143.87,7.5 145.1,6.27 170.28,6.27 171.11,7.11 171.11,13.55 169.56,15.1 169.56,19.64 172.54,22.62 174.98,22.62 175.92,23.56 175.92,27.34 175.51,27.74 173.62,27.74 170.78,30.58 170.38,30.58 170.09,30.87 v2(170.09,30.96)
  IN3 w0.064: v4(17.15,46.33) v2(17.5,46.33)
TBT_0_LSX_TX_R: length 4.7
  TOP w0.076: v1(15.75,46.27) 15.75,46.3 15.67,46.37 15.47,46.37 15.42,46.33 15.35,46.33 15.26,46.24 14.86,46.24 14.7,46.07 14.36,46.07 14.28,46 URT1.M7
  IN1 w0.064: v2(16.07,46.33) 16.07,46.21 16.01,46.14 15.81,46.14 15.75,46.21 v1(15.75,46.27)
  IN3 w0.064: v4(16.57,46.33) 16.57,46.46 16.52,46.5 16.24,46.5 v2(16.07,46.33)
  BOTTOM w0.081: v3(15.65,46.96) RT1.2 v4(16.57,46.33)
TBT_0_SBU1: length 27.9
  TOP w0.076: URT1.M10 14.6,47.23 v1(14.65,47.28)
  TOP w0.081: v1(18.55,61.31) v3(17.11,61.31) 13.41,61.31 13.25,61.16 CT206.1 RT118.1 11.93,61.16 11.88,61.11 D412.2 11.49,61.11 10.93,61.67 JUSBC1.A8
  IN1 w0.064: v1(14.65,47.28) 14.89,47.28 14.97,47.36 15.77,47.36 16.57,48.16 18.65,48.16 19.11,48.62 19.11,53 19.21,53.1 19.21,55.79 18.55,56.45 v1(18.55,61.31)
TBT_0_SBU2: length 35.9
  TOP w0.081: v1(18.32,64.32) 18.22,64.43 16.44,64.43 v3(15.03,65.84) CT207.1 RT119.1 v1(12.59,66.99)
  IN1 w0.064: v1(13.82,47.23) 14.11,46.94 14.78,46.94 15.04,47.19 15.95,47.19 16.75,47.99 18.72,47.99 19.27,48.55 19.27,52.93 19.37,53.03 19.37,55.86 18.89,56.34 18.89,61.86 18.32,62.43 v1(18.32,64.32) ; v1(7.69,63.42) v2(8.03,63.42)
  IN1 w0.203: v1(12.59,66.99) v2(12.16,66.99)
  IN2 w0.102: v2(12.16,66.99) 12.01,66.84 12.01,66.5 8.94,63.42 v2(8.03,63.42)
TBT_0_TRX_C_RD_DTX_N0: length 2.2
  TOP w0.076: 12.08,42.34 12.08,42.66 arc(12.1,42.74) 12.15,42.81 12.16,42.83 arc(12.2,42.89) 12.21,42.96 12.21,43.22 12.17,43.37 12.13,43.41 12,43.55 URT1.G2
  TOP w0.091: CT4.2 12.05,41.72 12.05,42.22 12.08,42.26 12.08,42.34
TBT_0_TRX_C_RD_DTX_N1: length 2.4
  TOP w0.076: 10.96,42.34 10.96,42.65 arc(10.94,42.75) 10.89,42.83 arc(10.85,42.89) 10.83,42.96 10.83,43.22 10.88,43.37 10.88,43.37 10.91,43.41 11.05,43.55 URT1.E2
  TOP w0.091: 10.96,42.34 10.96,42.34 10.96,42.27 10.57,41.88 10.57,41.73 CT8.2
TBT_0_TRX_C_RD_DTX_P0: length 2.2
  TOP w0.076: 11.88,42.34 11.88,42.68 arc(11.87,42.75) 11.83,42.81 11.81,42.82 arc(11.77,42.89) 11.76,42.96 11.76,43.18 arc(11.87,43.29) 11.98,43.18 URT1.G1
  TOP w0.091: CT3.2 11.84,41.73 11.84,42.31 11.88,42.34
TBT_0_TRX_C_RD_DTX_P1: length 2.4
  TOP w0.076: URT1.E1 11.06,43.18 arc(11.18,43.3) 11.29,43.18 11.29,42.96 arc(11.28,42.89) 11.24,42.82 11.22,42.81 arc(11.18,42.75) 11.17,42.68 11.17,42.34
  TOP w0.091: 11.17,42.34 11.17,42.19 10.78,41.8 10.78,41.72 CT7.2
TBT_0_TRX_DTX_N0: length 165.4
  TOP w0.091: v5(12.23,40.27) 12.1,40.41 arc(12.05,40.47) 12.04,40.54 12.04,40.61 arc(12.07,40.76) 12.15,40.88 CT4.1
  IN1 w0.081: v2(149.15,25.15) v1(149.44,24.85)
  IN3 w0.081: v2(149.15,25.15) 148.97,24.97 148.83,24.97 148.56,25.25 146.68,25.25 134.8,13.37 131.69,13.37 128.95,12.88 123.94,13.77 119.04,12.9 114.83,13.65 109.84,12.77 104.63,13.68 100.08,12.88 95.52,13.69 90.7,12.84 85.57,13.74 80.82,12.9 76.07,13.74 71.26,12.89 66.52,13.72 61.49,12.84 56.68,13.69 51.88,12.84 47.23,13.66 42.84,12.88 38.06,13.73 33.3,12.89 28.83,13.67 26.67,13.3 23.53,13.3 12.67,24.16 12.67,26.48 12.21,29.04 12.91,33.02 12.63,34.67 12.63,36.54 arc(12.49,37.2) 12.12,37.76 12.11,37.77 arc(12.06,37.84) 12.04,37.92 12.04,39.81 arc(12.09,40.06) v5(12.23,40.27)
TBT_0_TRX_DTX_N1: length 166.3
  TOP w0.091: CT8.1 10.45,40.88 arc(10.54,40.76) 10.57,40.61 10.57,39.17 arc(10.56,39.08) 10.54,38.99 arc(10.48,38.84) v5(10.38,38.71)
  IN1 w0.081: v2(148.38,23.88) 148.47,23.88 v1(148.79,24.2)
  IN3 w0.081: v2(148.38,23.88) 148.38,23.9 148.11,24.16 146.84,24.16 135.17,12.49 131.79,12.49 128.95,11.98 123.93,12.87 119.04,12.01 114.83,12.75 112.31,12.3 109.71,11.84 104.51,12.76 100.07,11.98 95.61,12.76 90.75,11.91 85.62,12.81 80.91,11.98 76.09,12.83 71.18,11.96 66.41,12.81 61.49,11.94 56.68,12.79 54.32,12.37 51.88,11.94 47.23,12.76 42.84,11.98 38.11,12.82 33.34,11.98 28.91,12.76 26.93,12.41 23.16,12.41 11.78,23.79 11.78,26.4 11.31,29.04 12.01,33.02 11.74,34.62 11.74,36.22 arc(11.64,36.7) 11.37,37.11 10.74,37.73 arc(10.61,37.93) 10.57,38.15 10.57,38.45 arc(10.56,38.51) 10.53,38.56 v5(10.38,38.71)
TBT_0_TRX_DTX_P0: length 165.8
  TOP w0.091: v5(11.65,40.27) 11.78,40.41 arc(11.82,40.47) 11.84,40.54 11.84,40.61 arc(11.81,40.76) 11.72,40.88 CT3.1
  IN1 w0.081: v1(149.44,24.2) 149.15,24.5 v2(149.14,24.5)
  IN3 w0.081: v2(149.14,24.5) 148.85,24.79 148.74,24.79 148.48,25.05 146.76,25.05 134.88,13.17 131.71,13.17 128.95,12.68 123.94,13.57 119.04,12.7 114.83,13.44 109.84,12.56 104.63,13.48 100.08,12.68 95.52,13.48 90.7,12.63 85.57,13.54 80.82,12.7 76.07,13.54 71.26,12.69 66.52,13.52 61.49,12.64 56.68,13.48 51.88,12.64 47.23,13.46 42.84,12.68 38.06,13.52 33.3,12.69 28.83,13.47 26.69,13.1 23.44,13.1 12.47,24.08 12.47,26.46 12.01,29.04 12.71,33.02 12.43,34.65 12.43,36.54 arc(12.31,37.13) 11.98,37.62 11.98,37.62 arc(11.88,37.76) 11.84,37.92 11.84,40 arc(11.82,40.07) 11.78,40.14 v5(11.65,40.27)
TBT_0_TRX_DTX_P1: length 165.9
  TOP w0.091: CT7.1 10.88,40.88 arc(10.8,40.76) 10.77,40.61 10.77,39.17 arc(10.77,39.1) 10.78,39.04 arc(10.85,38.86) v5(10.96,38.71)
  IN1 w0.081: v2(148.38,24.53) 148.47,24.53 v1(148.79,24.85)
  IN3 w0.081: v2(148.38,24.53) 148.2,24.36 146.76,24.36 135.08,12.68 131.77,12.68 128.95,12.18 123.93,13.07 119.04,12.21 114.83,12.95 109.71,12.04 104.51,12.96 100.07,12.18 95.61,12.96 90.75,12.11 85.62,13.01 80.91,12.18 76.09,13.03 71.18,12.17 66.41,13.01 61.49,12.14 56.68,12.99 51.88,12.14 47.23,12.96 42.84,12.19 38.11,13.02 33.34,12.18 28.91,12.96 26.91,12.61 23.24,12.61 11.98,23.87 11.98,26.42 11.52,29.04 12.21,33.02 11.93,34.64 11.93,36.22 arc(11.82,36.78) 11.51,37.25 10.88,37.87 arc(10.88,37.88) 10.88,37.88 arc(10.8,38.01) 10.77,38.15 10.77,38.29 arc(10.81,38.5) 10.93,38.67 v5(10.96,38.71)
TBT_0_TRX_RT_DTX_N0: length 30.1
  TOP w0.066: 12.73,48.41 12.74,48.42
  TOP w0.076: URT1.J11 12.72,47.87 arc(12.71,47.88) 12.7,47.9 arc(12.68,47.95) 12.68,48.01 12.68,48.28 arc(12.69,48.35) 12.73,48.41 ; 12.74,48.42 arc(12.78,48.48) 12.8,48.55
  TOP w0.091: v1(12.69,49.08) 12.74,49.03 arc(12.78,48.97) 12.8,48.89 12.8,48.55 ; JUSBC1.B10 8.49,64.42 arc(8.51,64.43) v5(8.53,64.44)
  IN1 w0.081: v2(16.28,65.33) arc(16.29,65.37) 16.31,65.4 16.56,65.65 arc(16.58,65.66) 16.6,65.67 arc(16.61,65.67) 16.62,65.68 arc(16.62,65.68) 16.62,65.68 16.8,65.68 arc(16.98,65.64) 17.14,65.53 17.2,65.47 arc(17.28,65.35) 17.31,65.2 17.31,57.61 arc(16.64,54.24) 14.74,51.39 13.96,50.61 arc(13.89,50.56) 13.8,50.55 arc(13.47,50.47) 13.22,50.25 13.11,50.08 12.92,49.8 arc(12.91,49.79) 12.91,49.78 arc(12.9,49.76) 12.89,49.74 arc(12.88,49.67) 12.86,49.6 12.86,49.22 arc(12.86,49.21) 12.85,49.19 12.77,49.11 arc(12.73,49.09) v1(12.69,49.08)
  IN3 w0.081: v4(15.75,65.39) 15.8,65.44 arc(15.84,65.47) 15.9,65.48 16.06,65.48 arc(16.12,65.47) 16.18,65.43 v2(16.28,65.33)
  BOTTOM w0.091: v4(15.75,65.39) arc(15.67,65.46) 15.57,65.48 15.48,65.48 arc(15.45,65.47) 15.42,65.45 14.69,64.72 arc(14.59,64.66) 14.48,64.64 14.36,64.64 arc(14.32,64.63) 14.27,64.63 arc(14.17,64.59) 14.09,64.52 D81.1 arc(13.69,64.51) 13.42,64.57 12.01,64.57 arc(11.94,64.58) 11.88,64.6 arc(11.83,64.64) 11.76,64.65 9.04,64.65 arc(8.77,64.6) v5(8.53,64.44)
TBT_0_TRX_RT_DTX_N1: length 16.3
  TOP w0.076: URT1.C11 10.15,47.69 10.3,47.85 arc(10.36,47.92) 10.37,48.01 10.37,48.28 arc(10.36,48.35) 10.32,48.41
  TOP w0.091: JUSBC1.A10 9.35,60.67 10.07,60.67 10.22,60.67 10.52,60.67 arc(10.61,60.66) 10.69,60.64 arc(10.79,60.59) 10.87,60.53 12.42,58.97 12.7,58.7 arc(12.77,58.59) 12.8,58.46 12.8,58.22 arc(12.82,58.1) 12.89,57.99 D82.2 arc(12.75,57.72) 12.7,57.44 12.7,57.13 arc(12.7,57.13) 12.7,57.12 12.7,56.89 arc(12.72,56.81) v1(12.76,56.74) ; 10.32,48.41 arc(10.27,48.48) 10.25,48.57 10.25,48.87 arc(10.28,48.98) v1(10.34,49.08)
  IN1 w0.081: v1(12.76,56.74) 12.74,56.71 12.74,55.68 arc(12.73,55.51) 12.72,55.34 arc(12.49,54.64) 12.06,54.04 11.3,53.27 arc(10.41,51.95) 10.1,50.38 10.1,50.38 arc(10.12,50.29) 10.17,50.22 10.17,50.22 arc(10.18,50.21) 10.18,50.2 arc(10.24,50.11) 10.26,50 10.26,49.29 arc(10.28,49.18) v1(10.34,49.08)
TBT_0_TRX_RT_DTX_P0: length 30.1
  TOP w0.066: 12.99,48.55 13,48.55
  TOP w0.076: URT1.J12 12.9,48.07 arc(12.91,48.04) 12.92,48.02 arc(13.05,47.96) 13.13,48.07 13.13,48.27 arc(13.12,48.35) 13.08,48.41 13.08,48.41 arc(13.03,48.47) 12.99,48.55
  TOP w0.091: 13,48.55 13,48.84 arc(13.02,48.96) v1(13.09,49.06) ; JUSBC1.B11 8.28,64.92 arc(8.42,64.95) v5(8.53,65.03)
  IN1 w0.081: v2(16.28,65.86) arc(16.42,65.87) 16.55,65.87 16.8,65.87 arc(17.06,65.82) 17.28,65.67 17.34,65.61 arc(17.47,65.42) 17.51,65.2 17.51,57.61 arc(16.83,54.17) 14.88,51.25 14.1,50.47 arc(13.96,50.38) 13.8,50.35 arc(13.56,50.29) 13.38,50.13 13.38,50.13 13.09,49.69 13.08,49.68 arc(13.07,49.63) 13.06,49.57 arc(13.06,49.53) 13.05,49.49 13.05,49.48 13.05,49.15 arc(13.06,49.1) v1(13.09,49.06)
  IN3 w0.081: v2(16.28,65.86) 16.25,65.83 arc(16.09,65.72) 15.9,65.69 15.9,65.69 arc(15.84,65.7) 15.8,65.73 v4(15.75,65.77)
  BOTTOM w0.091: v4(15.75,65.77) arc(15.67,65.71) 15.57,65.68 15.48,65.68 arc(15.37,65.66) 15.27,65.6 14.55,64.87 arc(14.52,64.85) 14.48,64.84 14.14,64.84 arc(14.07,64.85) 14.01,64.89 D79.1 13.83,64.88 arc(13.7,64.8) 13.56,64.77 12.02,64.77 arc(11.97,64.79) 11.92,64.82 arc(11.87,64.85) 11.82,64.86 8.95,64.86 arc(8.72,64.9) v5(8.53,65.03)
TBT_0_TRX_RT_DTX_P1: length 16.3
  TOP w0.066: 9.97,48.41 9.99,48.43
  TOP w0.076: URT1.C12 10.14,48.05 arc(10.03,47.94) 9.92,48.05 9.92,48.27 arc(9.93,48.35) 9.97,48.41
  TOP w0.091: JUSBC1.A11 9.92,60.17 arc(10,60.19) 10.07,60.23 arc(10.09,60.27) 10.1,60.31 arc(10.1,60.34) 10.11,60.37 10.12,60.41 arc(10.16,60.45) 10.22,60.47 10.52,60.47 arc(10.57,60.46) 10.62,60.45 arc(10.68,60.42) 10.72,60.38 11.04,60.07 12.28,58.83 12.51,58.59 arc(12.57,58.51) 12.59,58.4 arc(12.57,58.29) 12.51,58.2 D80.2 arc(12.44,57.72) 12.49,57.44 12.49,57.01 arc(12.46,56.86) v1(12.38,56.74) ; v1(9.96,49.08) arc(10.03,48.98) 10.05,48.87 10.05,48.57 arc(10.03,48.49) 9.99,48.43
  IN1 w0.081: v1(12.38,56.74) 12.49,56.63 arc(12.52,56.59) 12.53,56.55 arc(12.54,56.53) 12.54,56.5 12.54,55.68 arc(12.54,55.53) 12.52,55.37 arc(12.31,54.73) 11.92,54.18 11.16,53.42 arc(10.23,52.02) 9.9,50.38 9.9,50.38 arc(9.93,50.22) 10.03,50.08 arc(10.03,50.08) 10.03,50.07 arc(10.03,50.07) 10.03,50.07 10.03,50.07 arc(10.05,50.04) 10.06,50 10.06,49.32 arc(10.03,49.19) v1(9.96,49.08)
TBT_0_TTX_C_DRX_N0: length 23.5
  TOP w0.091: JUSBC1.A3 9.65,64.17 arc(9.76,64.2) 9.84,64.26 9.86,64.27 arc(9.95,64.33) 10.05,64.35 10.22,64.35 arc(10.33,64.37) 10.43,64.44 10.71,64.72 arc(11.08,64.97) 11.51,65.05 12.42,65.05 arc(12.58,65.02) 12.72,64.93 D77.1 13.03,65.09 arc(13.13,65.15) 13.24,65.17 13.69,65.17 arc(13.71,65.17) 13.73,65.17 arc(13.86,65.13) 13.98,65.05 v1(14.01,65.02) ; CT31.2 12.01,50.33 arc(12.02,50.34) 12.02,50.35 12.02,50.44 arc(12.01,50.5) v1(11.97,50.56)
  IN1 w0.081: v1(14.01,65.02) 14.01,65.03 14.14,65.16 arc(14.14,65.16) 14.15,65.17 arc(14.19,65.19) 14.23,65.2 arc(14.24,65.2) 14.25,65.2 14.37,65.2 arc(14.55,65.19) 14.72,65.13 arc(14.85,65.05) 14.97,64.96 16.15,63.78 arc(16.27,63.6) 16.31,63.4 16.31,56.75 arc(15.91,54.75) 14.77,53.05 13.32,51.59 arc(13.21,51.52) 13.07,51.49 arc(12.59,51.35) 12.25,50.98 12.19,50.84 12.19,50.84 arc(12.19,50.82) 12.18,50.8 arc(12.16,50.76) 12.13,50.72 v1(11.97,50.56)
TBT_0_TTX_C_DRX_N1: length 20.4
  TOP w0.091: CT33.2 11.13,50.21 arc(11.09,50.26) 11.08,50.33 arc(11.1,50.42) 11.15,50.49 v1(11.21,50.56) ; JUSBC1.B3 8.02,60.92 arc(8.16,60.91) 8.29,60.87 arc(8.42,60.8) v5(8.53,60.71)
  IN1 w0.081: v1(11.21,50.56) 11.14,50.63 arc(11.1,50.69) 11.09,50.77 arc(11.09,50.82) 11.1,50.87 arc(11.11,50.92) 11.14,50.96 11.15,50.98 11.88,51.7 12.32,52.07 arc(12.52,52.18) 12.74,52.22 arc(12.94,52.26) 13.12,52.37 13.33,52.58 13.89,53.15 arc(15.24,55.17) 15.72,57.55 15.72,59.69 arc(15.7,59.79) 15.63,59.88 15.57,59.95 arc(15.47,60.02) 15.35,60.04 arc(15.2,60.06) v2(15.06,60.12)
  IN3 w0.081: v2(15.06,60.12) 14.98,60.04 arc(14.9,59.99) 14.81,59.97 14.74,59.97 arc(14.65,59.99) v4(14.57,60.04)
  BOTTOM w0.091: v4(14.57,60.04) arc(14.47,59.97) 14.36,59.94 13.43,59.94 arc(13.16,60) 12.93,60.15 D78.2 arc(12.7,60.03) 12.45,59.98 11.81,59.98 arc(11.78,59.99) 11.76,60 11.55,60.21 arc(11.28,60.39) 10.95,60.46 9.15,60.46 arc(8.82,60.52) v5(8.53,60.71)
TBT_0_TTX_C_DRX_P0: length 23.5
  TOP w0.091: v1(12.35,50.56) 12.29,50.5 arc(12.24,50.42) 12.22,50.33 arc(12.24,50.26) 12.28,50.2 CT30.2 ; JUSBC1.A2 9.74,64.67 arc(9.81,64.66) 9.87,64.62 9.88,64.61 arc(9.94,64.57) 10.02,64.55 10.22,64.55 arc(10.25,64.56) 10.28,64.58 10.57,64.87 arc(11,65.16) 11.51,65.26 12.42,65.26 arc(12.57,65.29) 12.7,65.37 D75.1 arc(12.9,65.4) 13.02,65.38 13.95,65.38 arc(13.98,65.38) v1(14.01,65.4)
  IN1 w0.081: v1(14.01,65.4) 14.01,65.4 14.37,65.4 arc(14.59,65.38) 14.8,65.31 arc(14.96,65.22) 15.11,65.1 16.29,63.92 arc(16.45,63.68) 16.5,63.4 16.5,56.75 arc(16.09,54.67) 14.91,52.91 13.46,51.45 arc(13.28,51.34) 13.07,51.29 arc(12.7,51.19) 12.43,50.9 12.38,50.78 arc(12.38,50.77) 12.37,50.75 arc(12.36,50.67) 12.35,50.59 v1(12.35,50.56)
TBT_0_TTX_C_DRX_P1: length 20.3
  TOP w0.091: v5(8.53,60.13) 8.44,60.22 arc(8.21,60.37) 7.95,60.42 JUSBC1.B2 ; CT32.2 10.84,50.3 arc(10.87,50.34) 10.88,50.39 10.88,50.44 arc(10.87,50.5) v1(10.83,50.56)
  IN1 w0.081: v1(10.83,50.56) arc(10.87,50.62) 10.89,50.7 10.89,50.77 arc(10.89,50.83) 10.9,50.89 arc(10.93,51) 11,51.1 11,51.1 11.74,51.85 12.2,52.22 arc(12.45,52.37) 12.74,52.42 arc(12.87,52.44) 12.98,52.51 13.19,52.73 13.75,53.29 arc(15.06,55.25) 15.52,57.55 15.52,59.69 arc(15.51,59.72) 15.49,59.74 15.43,59.81 arc(15.39,59.84) 15.35,59.84 15.3,59.84 arc(15.26,59.84) 15.23,59.81 15.1,59.68 arc(15.07,59.64) v2(15.06,59.59)
  IN3 w0.081: v4(14.57,59.66) 14.61,59.7 arc(14.81,59.79) 15.01,59.7 arc(15.05,59.65) v2(15.06,59.59)
  BOTTOM w0.091: v4(14.57,59.66) arc(14.47,59.72) 14.36,59.74 13.43,59.74 arc(13.16,59.69) 12.93,59.53 D76.2 12.91,59.6 arc(12.83,59.76) 12.65,59.8 arc(12.55,59.78) 12.45,59.78 11.81,59.78 arc(11.7,59.8) 11.62,59.86 11.41,60.07 arc(11.2,60.21) 10.95,60.25 8.84,60.25 arc(8.67,60.22) v5(8.53,60.13)
TBT_0_TTX_C_RD_DRX_N0: length 2.3
  TOP w0.076: URT1.J2 12.92,43.55 13.05,43.41 13.09,43.37 13.13,43.22 13.13,42.96 arc(13.12,42.89) 13.08,42.83 13.07,42.81 arc(13.02,42.74) 13,42.66 13,42.34
  TOP w0.091: 13,42.34 13.32,42.03 13.32,41.72 CT2.2
TBT_0_TTX_C_RD_DRX_N1: length 2.7
  TOP w0.076: 10.04,42.34 10.04,42.65 arc(10.02,42.75) 9.97,42.83 arc(9.93,42.89) 9.91,42.96 9.91,43.22 9.96,43.37 9.96,43.37 9.99,43.41 10.13,43.55 URT1.C2
  TOP w0.091: CT6.2 9.3,41.72 9.3,41.94 9.51,42.15 9.85,42.15 10.04,42.34
TBT_0_TTX_C_RD_DRX_P0: length 2.3
  TOP w0.076: URT1.J1 12.9,43.18 arc(12.79,43.29) 12.68,43.18 12.68,42.96 arc(12.69,42.89) 12.73,42.82 12.75,42.81 arc(12.79,42.75) 12.8,42.68 12.8,42.34
  TOP w0.091: CT1.2 13.11,41.73 13.11,41.95 12.8,42.26 12.8,42.34
TBT_0_TTX_C_RD_DRX_P1: length 2.7
  TOP w0.076: URT1.C1 10.14,43.18 arc(10.26,43.3) 10.37,43.18 10.37,42.96 arc(10.36,42.89) 10.32,42.82 10.3,42.81 arc(10.26,42.75) 10.25,42.68 10.25,42.34
  TOP w0.091: CT5.2 9.5,41.72 9.5,41.85 9.59,41.95 9.93,41.95 10.25,42.26 10.25,42.34
TBT_0_TTX_CD_DRX_N0: length 2
  TOP w0.066: 11.88,48.57 11.88,48.57
  TOP w0.076: URT1.G11 11.82,47.85 arc(11.77,47.92) 11.76,48.01 11.76,48.28 arc(11.77,48.35) 11.81,48.41 11.82,48.42 arc(11.87,48.49) 11.88,48.57
  TOP w0.091: CT31.1 11.8,49.52 arc(11.91,49.35) 11.95,49.15 11.95,49.03 arc(11.94,48.98) 11.91,48.93 arc(11.91,48.91) 11.9,48.88 arc(11.9,48.86) 11.89,48.84 arc(11.88,48.76) 11.88,48.68 11.88,48.57
TBT_0_TTX_CD_DRX_N1: length 2.1
  TOP w0.076: 11.16,48.74 11.16,48.59 11.17,48.57 arc(11.19,48.48) 11.24,48.41 arc(11.28,48.35) 11.29,48.28 11.29,48.01 arc(11.28,47.92) 11.23,47.85 11.06,47.69 URT1.E11
  TOP w0.091: CT33.1 11.13,49.43 arc(11.06,49.32) 11.03,49.2 11.03,49.18 arc(11.04,49.13) 11.06,49.08 11.08,49.04 arc(11.14,48.89) 11.16,48.74
TBT_0_TTX_CD_DRX_P0: length 2
  TOP w0.066: 12.14,48.42 12.16,48.41
  TOP w0.076: URT1.G12 11.98,48.06 arc(12.1,47.95) 12.21,48.06 12.21,48.27 arc(12.2,48.35) 12.16,48.41 ; 12.08,48.56 arc(12.1,48.49) 12.14,48.42
  TOP w0.091: 12.08,48.56 12.08,48.68 arc(12.09,48.74) 12.09,48.8 arc(12.1,48.82) 12.1,48.84 arc(12.14,48.92) 12.16,49.01 12.16,49.08 12.16,49.13 12.18,49.25 arc(12.2,49.34) 12.25,49.41 CT30.1
TBT_0_TTX_CD_DRX_P1: length 2.1
  TOP w0.076: URT1.E12 11.06,48.05 arc(10.95,47.94) 10.84,48.05 10.84,48.27 arc(10.85,48.35) 10.89,48.41 10.91,48.43 arc(10.94,48.48) 10.95,48.54 10.95,48.74
  TOP w0.091: CT32.1 10.81,49.37 arc(10.82,49.35) 10.83,49.33 10.83,49.18 arc(10.84,49.08) 10.88,48.98 10.9,48.94 arc(10.94,48.84) 10.95,48.74
TBT_0_TTX_DRX_N0: length 161.9
  TOP w0.091: CT2.1 13.35,40.82 arc(13.29,40.72) 13.27,40.61 13.27,39.34 arc(13.31,39.16) 13.41,39 v5(13.45,38.96)
  IN1 w0.081: v2(146.3,26.54) v1(146.61,26.23)
  IN3 w0.081: v2(146.3,26.54) 146.53,26.32 146.53,26.07 134.54,14.08 131.44,14.08 128.81,13.61 123.92,14.47 119,13.61 114.74,14.36 109.91,13.51 104.77,14.41 100.09,13.59 95.5,14.4 90.75,13.56 85.67,14.46 80.9,13.62 76.14,14.46 71.25,13.59 66.47,14.44 61.77,13.61 56.99,14.45 52.21,13.61 47.43,14.45 42.69,13.61 37.95,14.45 33.19,13.61 31,13.99 28.82,14.37 26.63,14 23.8,14 13.35,24.44 13.35,26.54 12.91,29.04 13.61,33.02 13.34,34.53 13.34,36.73 13.34,37.35 arc(13.34,37.39) 13.33,37.43 13.31,37.49 13.31,37.5 arc(13.27,37.66) 13.26,37.82 13.26,38.48 arc(13.31,38.74) v5(13.45,38.96)
TBT_0_TTX_DRX_N1: length 172.1
  TOP w0.091: v5(9.15,40.27) 9.23,40.36 arc(9.31,40.47) 9.34,40.61 arc(9.32,40.72) 9.26,40.81 CT6.1
  IN1 w0.081: v2(147.29,23.1) 147.13,23.26 145.87,23.26 144.16,24.97 144.16,26.45 144.36,26.65 144.55,26.65 v1(144.78,26.88)
  IN3 w0.081: v5(9.15,40.27) 9.28,40.14 arc(9.33,40.07) 9.34,40 9.34,38.47 arc(9.34,38.45) 9.34,38.44 9.37,38.2 arc(9.46,37.93) 9.62,37.7 10.55,36.77 arc(10.91,36.23) 11.04,35.6 11.04,34.65 11.32,33.03 10.62,29.04 11.1,26.34 11.1,23.51 22.88,11.73 26.98,11.73 28.89,12.06 33.54,11.24 38.31,12.09 42.84,11.29 47.23,12.06 51.88,11.24 56.68,12.09 61.49,11.24 66.27,12.09 71.07,11.24 76.08,12.12 80.96,11.26 85.64,12.09 90.69,11.2 95.61,12.06 100.12,11.27 104.55,12.05 109.72,11.14 114.77,12.03 118.95,11.29 123.9,12.17 128.94,11.28 131.88,11.8 135.45,11.8 146.92,23.27 147.12,23.27 v2(147.29,23.1)
TBT_0_TTX_DRX_P0: length 162.5
  TOP w0.091: v5(12.87,38.96) 12.93,39.01 arc(13.03,39.17) 13.07,39.35 13.07,40.61 arc(13.03,40.8) 12.93,40.95 CT1.1
  IN1 w0.081: v1(146.61,26.88) 146.61,26.87 v2(146.9,26.58)
  IN3 w0.081: v2(146.9,26.58) 146.72,26.4 146.72,25.98 134.62,13.88 131.46,13.88 128.81,13.41 123.92,14.27 121.5,13.85 121.5,13.85 119,13.41 114.74,14.16 109.91,13.31 104.77,14.21 100.09,13.39 95.5,14.2 90.75,13.36 85.67,14.26 83.32,13.84 80.9,13.42 76.14,14.25 71.25,13.39 66.47,14.23 61.77,13.4 56.99,14.25 52.21,13.4 47.43,14.25 42.69,13.41 37.95,14.25 33.19,13.41 28.82,14.17 26.65,13.8 23.72,13.8 13.15,24.36 13.15,26.52 12.71,29.04 13.41,33.02 13.15,34.52 13.15,36.73 13.15,37.35 arc(13.15,37.36) 13.14,37.36 13.14,37.37 13.12,37.43 arc(13.07,37.62) 13.06,37.82 13.06,38.5 arc(13.01,38.75) v5(12.87,38.96)
TBT_0_TTX_DRX_P1: length 171
  TOP w0.091: v5(9.73,40.27) 9.65,40.36 arc(9.57,40.47) 9.54,40.61 arc(9.58,40.8) CT5.1
  IN1 w0.081: v2(147.29,23.64) 147.12,23.46 145.95,23.46 144.36,25.05 144.36,26.37 144.45,26.45 144.56,26.45 v1(144.78,26.23)
  IN3 w0.081: v2(147.29,23.64) 147.12,23.47 146.84,23.47 135.37,12 131.86,12 128.94,11.48 123.9,12.37 118.95,11.49 114.77,12.23 109.72,11.34 104.55,12.25 100.12,11.47 95.61,12.27 90.69,11.4 85.64,12.29 80.96,11.46 76.08,12.32 71.07,11.44 66.27,12.29 61.49,11.44 56.68,12.29 51.88,11.45 47.23,12.27 42.84,11.49 38.31,12.29 33.54,11.44 28.9,12.26 26.97,11.92 22.96,11.92 11.29,23.59 11.29,26.36 10.82,29.04 11.52,33.02 11.23,34.66 11.23,35.6 arc(11.09,36.31) 10.69,36.91 9.77,37.84 arc(9.64,38.02) 9.57,38.23 9.54,38.47 arc(9.54,38.47) 9.54,38.47 9.54,39.86 arc(9.58,40.06) 9.7,40.24 v5(9.73,40.27)
TBT_1_LSX_RX: length 9.1
  IN1 w0.081: v1(171.98,32.31) 172.28,32.31 173.21,33.24 175.87,33.24 176.54,33.92 177.43,33.92 v2(177.5,33.84)
  IN3 w0.081: v2(177.5,33.84) 177.5,33.65 177.91,33.25 v4(177.93,33.25)
  BOTTOM w0.081: R6173.2 v3(178.62,31.88)
  BOTTOM w0.091: v4(177.93,33.25) R6173.2
TBT_2_DP_AUXN: length 172.8
  IN1 w0.081: v1(284.23,38.96) 284.46,38.73 286.14,38.73 286.31,38.56 287.07,38.56 287.29,38.78 288.45,38.78 289.02,38.21 289.02,35.22 285.41,31.61 282.84,31.61 282.55,31.32 281.91,31.32 280.56,29.97 277.6,29.97 277.13,30.44 276.8,30.44 v2(276.64,30.28) ; v2(149.79,26.74) 149.71,26.66 149.58,26.66 v1(149.36,26.88)
  IN3 w0.081: v2(149.79,26.74) 149.96,26.57 150.08,26.57 150.67,27.16 151.68,27.16 153.58,25.26 153.58,21.9 157.83,17.65 158.66,17.65 160.01,17.4 163.78,18.06 166.09,17.65 168.6,17.65 171.87,14.37 173.49,14.37 175.94,13.94 180.72,14.78 185.49,13.94 190.27,14.78 195.05,13.94 199.83,14.78 205.05,13.86 209.83,14.71 214.16,13.94 218.94,14.78 223.71,13.94 228.49,14.78 233.27,13.94 238.05,14.78 238.08,14.78 242.83,13.94 247.6,14.78 252.38,13.94 257.16,14.78 261.94,13.94 266.71,14.78 268.47,14.47 269.77,14.47 277.73,22.44 278.25,25.4 277.89,27.47 277.89,28.17 arc(277.83,28.42) 277.69,28.64 277.29,29.04 arc(277.13,29.28) 277.08,29.56 277.08,30.3 arc(277.03,30.4) 276.93,30.45 arc(276.82,30.42) 276.72,30.36 v2(276.64,30.28)
TBT_2_DP_AUXN_R: length 2
  TOP w0.076: 282.56,38.47 282.53,38.47 282.52,38.47 282.38,38.61 282.21,38.61 282.14,38.53 282.14,38.4 URT2.M8
  TOP w0.091: 282.56,38.47 282.8,38.47 282.85,38.52 283.1,38.52 283.18,38.59 283.18,38.71 283.43,38.96 RT117.2
TBT_2_DP_AUXP: length 172.7
  IN1 w0.081: v1(149.36,26.23) 149.45,26.33 149.73,26.33 v2(149.83,26.23) ; v2(276.64,30.81) 276.81,30.64 277.21,30.64 277.68,30.17 280.48,30.17 281.83,31.52 282.47,31.52 282.76,31.81 285.33,31.81 288.82,35.3 288.82,38.13 288.37,38.58 287.37,38.58 287.15,38.37 286.22,38.37 286.06,38.54 284.44,38.54 v1(284.23,38.33)
  IN3 w0.081: v2(149.83,26.23) 149.97,26.37 150.16,26.37 150.75,26.96 151.6,26.96 153.39,25.17 153.39,21.82 157.75,17.45 158.64,17.45 160.01,17.2 163.78,17.86 166.08,17.45 168.52,17.45 171.79,14.18 173.47,14.18 175.94,13.74 180.72,14.58 185.49,13.74 190.27,14.58 195.05,13.74 199.83,14.58 205.05,13.66 209.83,14.5 214.16,13.74 218.94,14.58 223.71,13.74 228.49,14.58 233.27,13.74 238.05,14.58 242.83,13.74 247.6,14.58 252.38,13.74 257.16,14.58 261.94,13.74 266.71,14.58 268.46,14.28 269.85,14.28 277.92,22.34 278.45,25.4 278.08,27.49 278.08,28.17 arc(278.02,28.5) 277.83,28.78 277.43,29.18 arc(277.32,29.35) 277.27,29.56 277.27,30.3 arc(277.17,30.54) 276.93,30.64 arc(276.82,30.67) 276.72,30.73 v2(276.64,30.81)
TBT_2_DP_AUXP_R: length 2.1
  TOP w0.076: 282.47,38.26 282.41,38.21 arc(282.35,38.17) 282.28,38.15 282.03,38.15 arc(281.93,38.17) 281.85,38.23 URT2.L8
  TOP w0.091: 282.47,38.26 282.88,38.26 282.93,38.31 283.63,38.31 RT116.2
TBT_2_LSX_RX: length 170.9
  IN1 w0.064: v2(180.63,39.39) 179.84,38.61 178.64,38.61 178.07,39.17 178.07,39.6 177.49,40.18 176.78,40.18 176.54,40.42 175.94,40.42 175.74,40.61 174.62,40.61 174.29,40.29 173.49,40.29 172.73,41.05 172.11,41.05 172.01,40.95 171.07,40.95 170.68,40.57 v1(170.68,40.55) ; v1(287.79,37.57) 287.73,37.5 287.05,37.5 v2(286.99,37.57)
  IN2 w0.051: v2(286.99,37.57) 286.85,37.57 285.97,38.45 284.58,38.45 283.06,39.97 283.06,41.71 282.68,42.09 281.16,42.09 280.44,41.38 278.44,41.38 277.98,40.92 277.98,40.54 277.75,40.3 276.36,40.3 274.77,38.71 274.77,37.34 274.77,37.22 274.77,37.22 273.7,36.14 273.7,34.12 274.3,33.52 274.3,32.24 274.57,31.97 274.57,30.28 273.85,29.56 273.85,27.95 270.36,24.46 270.36,22.13 268.78,20.55 268.78,16.56 265.92,13.7 264.18,13.7 262.14,11.66 250.13,11.66 248.95,10.48 248.95,9.96 247.27,8.28 233.75,8.28 232.37,6.89 231.71,6.89 231.39,6.58 228.63,6.58 221.63,13.57 218.73,13.57 216.85,15.46 216.85,16.67 216.19,17.33 215.74,17.33 213.15,19.92 213.15,23.62 211.67,25.11 211.67,26.74 210.14,28.26 210.14,29.13 209.68,29.58 208.73,29.58 208.09,30.23 205.86,30.23 205.73,30.1 204.33,30.1 203.35,31.08 197.86,31.08 197,31.94 193.42,31.94 193.02,32.33 192.19,32.33 189.53,34.99 189.04,34.99 185.85,38.19 185.02,38.19 184.54,38.67 183.33,38.67 183.23,38.77 183.23,39.17 183.15,39.24 182.96,39.24 182.87,39.15 182.87,38.73 182.81,38.67 182.29,38.67 182.07,38.89 181.71,38.89 181.57,39.03 180.99,39.03 v2(180.63,39.39)
  IN3 w0.064: v2(180.63,39.39) 181.02,39.79 181.59,39.79 181.73,39.93 181.73,40.75 182.02,41.04 v4(182.4,41.04)
  BOTTOM w0.081: RC693.2 R6174.2 182.93,41.38 182.6,41.04 v4(182.4,41.04)
TBT_2_LSX_RX_R: length 5.7
  TOP w0.081: RT166.2 v1(286.52,37.57)
  IN1 w0.081: v1(281.69,37.92) 283.71,37.92 284.07,37.57 v1(286.52,37.57)
TBT_2_LSX_TX: length 166
  TOP w0.081: v1(288.16,37.98) 288.01,37.98 RT167.1
  IN1 w0.064: v1(170.03,40.55) 170.61,41.12 171.86,41.12 171.96,41.22 172.8,41.22 173.58,40.44 174.23,40.44 174.57,40.78 175.81,40.78 176,40.59 176.61,40.59 176.85,40.35 177.57,40.35 178.24,39.67 178.24,39.24 178.71,38.77 179.53,38.77 180.49,39.73 180.8,39.73 v2(181.14,39.39) ; v2(287.46,37.85) 287.6,37.98 v1(288.16,37.98)
  IN2 w0.051: v2(287.46,37.85) 287.47,37.85 287.37,37.95 286.71,37.95 285.99,38.66 284.58,38.66 283.26,39.99 283.26,41.79 282.79,42.26 281.08,42.26 280.37,41.54 278.32,41.54 277.9,41.12 276.94,41.12 274.62,38.79 274.62,37.28 273.55,36.2 273.55,28.07 270.04,24.57 270.04,22.59 267.61,20.15 267.61,15.82 265.79,14.01 264.06,14.01 262.01,11.96 250,11.96 248.65,10.61 248.65,10.09 247.14,8.58 233.63,8.58 232.24,7.2 231.58,7.2 231.27,6.88 229.55,6.88 222.55,13.88 218.86,13.88 217.15,15.58 217.15,17.11 213.45,20.8 213.45,26.24 209.32,30.38 205.8,30.38 205.67,30.25 204.39,30.25 203.41,31.23 197.92,31.23 197.06,32.09 193.48,32.09 193.08,32.49 192.25,32.49 189.59,35.15 189.15,35.15 185.94,38.35 185.08,38.35 185.07,38.37 185.06,38.37 183.99,39.43 182.24,39.43 182.06,39.61 181.35,39.61 v2(181.14,39.39)
TBT_2_LSX_TX_R: length 5.6
  TOP w0.081: RT167.2 RT3.2
  TOP w0.093: RT3.2 286.16,38.56 285.19,38.56 v3(285.08,38.45) 284.95,38.32 284.95,38.07 284.81,37.92 URT2.M7
TBT_2_SBU1: length 51.3
  TOP w0.076: v1(282.53,39.48) 282.35,39.3 URT2.M10
  IN1 w0.064: v1(282.53,39.48) 282.71,39.48 v2(282.85,39.34) ; v2(279.24,70.39) 279.24,70.5 279.69,70.95 279.69,71.15 282.26,73.71 282.95,73.71 283.47,74.22 v1(283.47,74.73)
  IN3 w0.064: v4(283.06,39.6) 283.06,39.55 v2(282.85,39.34) ; v2(279.24,70.39) 279.58,70.06 279.58,69.67 277.78,67.87 277.78,66.92 274.87,64.01 273.54,64.01 273.02,63.49 v4(273.02,63.45)
  BOTTOM w0.076: v4(283.06,39.6) 283.06,39.9
  BOTTOM w0.081: v4(273.02,63.45) 273.03,63.45 CT306.1 273.03,62.23 RT120.1 v6(273.05,53.43) 273.05,45.39 275.46,42.98 275.46,42.16 276.07,41.55 280.61,41.55 281.54,42.48 282.49,42.48 283.06,41.92 283.06,39.9
TBT_2_SBU2: length 49.6
  IN1 w0.064: v2(279.24,69.89) 279.58,70.22 279.58,70.6 279.86,70.88 279.86,71.08 280.89,72.11 282.42,72.11 283.28,72.98 v1(285.07,72.98) ; v2(282.1,39.6) 281.99,39.6 v1(281.69,39.3)
  IN3 w0.064: v4(272.17,63.5) 272.41,63.5 273.08,64.17 274.8,64.17 277.11,66.49 277.12,66.49 277.62,66.99 277.62,67.94 279.24,69.57 v2(279.24,69.89) ; v4(281.96,39.92) 282.1,39.79 v2(282.1,39.6)
  BOTTOM w0.081: v4(272.17,63.5) 272.19,63.48 RT121.1 272.22,62.8 CT307.1 272.61,61.84 v6(272.61,55.13) 272.61,53.03 272.8,52.84 272.8,45.38 275.23,42.95 275.23,42.11 276,41.34 281.31,41.34 281.66,40.99 281.66,40.23 v4(281.96,39.92)
TBT_2_TRX_C_RD_DTX_N0: length 2.5
  TOP w0.076: URT2.G2 279.87,35.62 280,35.49 280.04,35.44 280.04,35.44 280.08,35.3 280.08,35.03 arc(280.07,34.96) 280.03,34.9 280.02,34.89 arc(279.97,34.82) 279.95,34.74 279.95,34.42
  TOP w0.091: CT12.2 280.17,33.63 280.17,33.98 279.95,34.2 279.95,34.42
TBT_2_TRX_C_RD_DTX_N1: length 2.5
  TOP w0.076: URT2.E2 278.92,35.62 278.78,35.49 278.75,35.45 278.74,35.44 278.7,35.3 278.7,35.03 arc(278.72,34.96) 278.76,34.9 arc(278.81,34.82) 278.83,34.73 278.83,34.42
  TOP w0.091: 278.83,34.42 278.83,34.42 278.83,34.27 278.7,34.13 278.7,33.88 arc(278.65,33.65) 278.52,33.45 CT16.2
TBT_2_TRX_C_RD_DTX_P0: length 2.5
  TOP w0.076: URT2.G1 279.85,35.25 arc(279.74,35.37) 279.62,35.25 279.62,35.04 arc(279.64,34.96) 279.68,34.9 279.69,34.89 arc(279.73,34.83) 279.75,34.75 279.75,34.42
  TOP w0.091: CT11.2 279.97,33.63 279.97,33.9 279.75,34.12 279.75,34.42
TBT_2_TRX_C_RD_DTX_P1: length 2.5
  TOP w0.076: URT2.E1 278.93,35.26 arc(279.05,35.37) 279.16,35.26 279.16,35.04 arc(279.15,34.96) 279.1,34.9 279.09,34.88 arc(279.05,34.82) 279.04,34.75 279.04,34.42
  TOP w0.091: CT15.2 279.08,33.45 arc(278.95,33.65) 278.9,33.88 278.9,34.05 279.04,34.18 279.04,34.42
TBT_2_TRX_DTX_N0: length 153.9
  TOP w0.091: v5(280.36,32.14) 280.28,32.23 arc(280.2,32.35) 280.17,32.49 arc(280.19,32.6) 280.26,32.7 CT12.1
  IN1 w0.081: v1(150.74,24.2) 150.54,24.2 v2(150.27,23.94)
  IN3 w0.081: v5(280.36,32.14) 280.35,32.14 arc(280.22,31.94) 280.17,31.7 280.17,27.5 280.54,25.4 279.83,21.35 270.68,12.2 268.39,12.2 266.71,12.49 261.94,11.65 257.16,12.49 252.38,11.65 247.6,12.49 242.82,11.65 238.05,12.49 233.27,11.65 228.49,12.49 223.71,11.65 218.94,12.49 214.16,11.65 209.83,12.41 205.05,11.57 199.83,12.49 195.05,11.65 190.27,12.49 185.49,11.65 180.79,12.48 176.01,11.64 173.29,12.12 170.94,12.12 167.67,15.39 165.86,15.39 163.78,15.76 160.02,15.1 158.36,15.39 156.73,15.39 150.71,21.41 150.71,24.07 150.63,24.15 150.48,24.15 v2(150.27,23.94)
TBT_2_TRX_DTX_N1: length 151
  TOP w0.091: CT16.1 278.61,32.7 arc(278.67,32.6) 278.7,32.49 278.7,32.34 arc(278.64,32.2) v5(278.51,32.14)
  IN1 w0.081: v2(151.63,24.61) v1(151.39,24.85)
  IN3 w0.081: v2(151.63,24.61) 151.63,24.46 151.77,24.31 151.95,24.3 152.14,24.1 152.14,21.28 157.14,16.28 158.43,16.28 160.02,16 163.79,16.66 165.97,16.28 168.03,16.28 171.31,13 173.37,13 175.94,12.55 180.72,13.39 185.49,12.55 190.27,13.39 195.05,12.55 199.83,13.39 205.05,12.47 209.83,13.31 214.16,12.55 218.94,13.39 223.71,12.55 228.49,13.39 233.27,12.55 238.05,13.39 242.83,12.55 247.6,13.39 252.38,12.55 257.16,13.39 261.93,12.55 266.71,13.39 268.47,13.08 270.31,13.08 279.01,21.77 279.64,25.4 279.27,27.55 279.27,29.28 arc(279.22,29.5) 279.1,29.68 278.85,29.93 arc(278.74,30.1) 278.7,30.29 278.7,31.72 arc(278.66,31.93) 278.54,32.11 v5(278.51,32.14)
TBT_2_TRX_DTX_P0: length 153.6
  TOP w0.091: CT11.1 279.88,32.7 arc(279.94,32.6) 279.97,32.49 arc(279.94,32.35) 279.86,32.23 v5(279.78,32.14)
  IN1 w0.081: v2(150.25,24.55) 150.43,24.55 v1(150.74,24.85)
  IN3 w0.081: v2(150.25,24.55) 150.45,24.34 150.72,24.34 150.91,24.15 150.91,21.49 156.81,15.59 158.37,15.59 160.02,15.3 163.78,15.96 165.88,15.59 167.75,15.59 171.02,12.32 173.31,12.32 176.01,11.84 180.79,12.68 185.49,11.85 190.27,12.69 195.05,11.85 199.83,12.69 205.05,11.77 209.83,12.61 214.16,11.85 218.94,12.69 223.71,11.85 228.49,12.69 233.27,11.85 238.05,12.69 242.82,11.85 247.6,12.69 252.38,11.85 257.16,12.69 261.94,11.85 266.71,12.69 268.41,12.4 270.6,12.4 279.65,21.44 280.34,25.4 279.97,27.49 279.97,31.67 arc(279.92,31.93) v5(279.78,32.14)
TBT_2_TRX_DTX_P1: length 151.2
  TOP w0.091: CT15.1 278.99,32.7 arc(278.92,32.6) 278.9,32.49 278.9,32.34 arc(278.95,32.2) v5(279.09,32.14)
  IN1 w0.081: v1(151.39,24.2) 151.61,23.99 v2(151.61,23.95)
  IN3 w0.081: v2(151.61,23.95) 151.77,24.11 151.77,24.11 151.86,24.11 151.93,24.03 151.94,24.02 151.94,21.2 157.06,16.08 158.42,16.08 160.02,15.8 163.79,16.46 165.95,16.08 167.95,16.08 171.22,12.8 173.35,12.8 175.94,12.35 180.72,13.19 185.49,12.35 190.27,13.19 195.05,12.35 199.83,13.19 205.05,12.27 209.83,13.11 214.16,12.35 218.94,13.19 223.71,12.35 228.49,13.19 233.27,12.35 238.05,13.19 242.83,12.35 247.6,13.19 252.38,12.35 257.16,13.19 261.93,12.35 266.71,13.19 268.45,12.88 270.4,12.88 279.19,21.68 279.85,25.4 279.46,27.56 279.46,29.28 arc(279.41,29.57) 279.24,29.82 278.99,30.07 arc(278.92,30.17) 278.9,30.29 278.9,31.68 arc(278.95,31.93) v5(279.09,32.14)
TBT_2_TRX_RT_DTX_N0: length 42.1
  TOP w0.066: 280.6,40.48 280.61,40.49
  TOP w0.076: URT2.J11 280.65,39.88 arc(280.57,40) 280.54,40.14 280.54,40.35 arc(280.56,40.42) 280.6,40.48
  TOP w0.091: v1(281.05,41.91) 281.1,41.87 arc(281.13,41.83) 281.13,41.78 281.13,41.48 arc(281.13,41.45) 281.11,41.42 280.76,41.08 arc(280.7,40.98) 280.68,40.87 280.68,40.63 arc(280.66,40.57) 280.63,40.52 arc(280.62,40.5) 280.61,40.49 ; JUSBC2.B10 284.36,71.98 arc(284.31,71.97) v5(284.27,71.94)
  IN1 w0.081: v4(279.13,67.35) 279.21,67.27 arc(279.27,67.18) 279.3,67.07 279.3,66.92 arc(279.29,66.84) 279.27,66.77 arc(279.22,66.66) 279.15,66.57 277.74,65.16 arc(277.63,65.09) 277.5,65.06 277.5,65.06 arc(277.22,65.01) 276.99,64.85 276.54,64.4 arc(276.53,64.4) 276.52,64.39 276.47,64.35 arc(276.25,64.02) 276.17,63.63 276.17,58.31 276.03,57.99 276.03,57.99 arc(275.89,57.78) 275.84,57.53 275.84,46.82 arc(276.02,45.93) 276.53,45.17 276.88,44.82 arc(277.37,44.49) 277.96,44.37 279.64,44.37 arc(280.22,44.26) 280.71,43.93 arc(281.06,43.41) 281.18,42.8 281.18,42.2 arc(281.15,42.05) 281.07,41.93 v1(281.05,41.91)
  BOTTOM w0.091: v5(284.27,71.94) 282.35,71.94 arc(281.87,71.84) 281.47,71.57 281.12,71.22 arc(281.11,71.21) 281.1,71.21 arc(280.99,71.04) 280.96,70.84 280.96,70.84 arc(280.93,70.72) 280.87,70.62 280.57,70.32 arc(280.47,70.26) 280.35,70.24 D89.1 280.19,70.11 arc(280.16,69.98) 280.09,69.88 279.78,69.57 arc(279.42,69.03) 279.29,68.39 279.29,67.75 arc(279.25,67.54) v4(279.13,67.35)
TBT_2_TRX_RT_DTX_N1: length 42.9
  TOP w0.076: URT2.C11 278.06,39.76 arc(278.08,39.77) 278.11,39.78 278.16,39.84 arc(278.22,39.96) 278.24,40.11 278.24,40.35 arc(278.23,40.42) 278.19,40.48 arc(278.12,40.58) 278.1,40.7
  TOP w0.091: 278.1,40.7 278.1,40.85 arc(278.06,41.03) 277.94,41.18 arc(277.81,41.26) 277.66,41.29 arc(277.59,41.3) 277.52,41.34 arc(277.35,41.46) 277.14,41.5 arc(277.05,41.52) 276.98,41.57 arc(276.93,41.66) 276.91,41.76 276.91,42.05 arc(276.93,42.15) 276.98,42.23 v4(277.06,42.3) ; JUSBC2.A10 282.9,75.73 arc(282.83,75.76) 282.8,75.83 282.8,75.92 arc(282.78,75.97) 282.73,76.01 arc(282.72,76.01) 282.71,76.01 282.7,76.02 282.42,76.02 arc(282.29,76.02) 282.16,76.01 282.14,76.01 arc(282.05,75.98) 281.96,75.95 281.95,75.94 arc(281.88,75.9) 281.83,75.85 276.88,70.9 276.88,70.9 arc(276.71,70.65) D90.2 276.58,70.36 arc(276.43,70.34) 276.3,70.29 arc(276.21,70.24) 276.13,70.17 276.02,70.06 275.91,69.94 275.58,69.61 arc(275.56,69.59) 275.53,69.56 arc(275.4,69.33) 275.35,69.07 275.36,69.06 arc(275.26,68.58) 274.99,68.18 274.52,67.71 arc(274.43,67.58) 274.4,67.43 274.4,66.89 arc(274.43,66.77) v5(274.49,66.67)
  BOTTOM w0.091: v5(274.49,66.67) 274.49,66.67 arc(274.37,66.49) 274.33,66.28 274.33,65.4 arc(274.36,65.23) 274.46,65.09 arc(274.64,64.82) 274.71,64.49 274.71,53.63 274.71,53.63 arc(274.75,53.41) 274.88,53.22 arc(275.17,52.77) 275.28,52.24 275.28,46.93 arc(275.58,45.4) 276.45,44.1 276.7,43.85 arc(276.87,43.59) 276.93,43.28 276.93,42.51 arc(276.95,42.43) 276.99,42.37 v4(277.06,42.3)
TBT_2_TRX_RT_DTX_P0: length 42.1
  TOP w0.066: 280.94,40.49 280.93,40.5
  TOP w0.076: URT2.J12 280.77,40.13 arc(280.89,40.01) 281,40.13 281,40.35 arc(280.99,40.42) 280.94,40.49
  TOP w0.091: JUSBC2.B11 284.56,71.48 arc(284.4,71.44) v5(284.27,71.35) ; v1(281.43,41.91) 281.36,41.84 arc(281.34,41.81) 281.34,41.78 281.34,41.48 arc(281.32,41.37) 281.25,41.28 280.91,40.93 arc(280.89,40.9) 280.88,40.87 280.88,40.69 280.88,40.68 arc(280.88,40.58) 280.93,40.5
  IN1 w0.081: v1(281.43,41.91) 281.43,41.92 arc(281.39,41.97) 281.38,42.03 281.38,42.8 arc(281.24,43.49) 280.85,44.07 arc(280.3,44.44) 279.64,44.57 277.96,44.57 arc(277.45,44.67) 277.02,44.96 276.67,45.31 arc(276.2,46) 276.04,46.82 276.04,57.53 arc(276.08,57.7) 276.17,57.85 arc(276.32,58.06) 276.37,58.31 276.37,63.63 arc(276.43,63.94) 276.61,64.21 arc(276.65,64.23) 276.68,64.26 277.13,64.71 arc(277.3,64.82) 277.5,64.86 arc(277.71,64.9) 277.88,65.02 279.29,66.43 arc(279.39,66.56) 279.46,66.71 arc(279.49,66.81) 279.49,66.92 279.49,67.12 arc(279.51,67.18) 279.54,67.24 279.66,67.35 v4(279.66,67.35)
  BOTTOM w0.091: v5(284.27,71.35) 283.98,71.35 arc(283.94,71.36) 283.91,71.38 283.87,71.43 arc(283.82,71.5) 283.8,71.59 283.8,71.62 arc(283.77,71.7) 283.69,71.73 282.35,71.73 arc(281.95,71.66) 281.61,71.43 281.4,71.22 281.27,71.09 arc(281.26,71.08) 281.25,71.07 arc(281.18,70.96) 281.16,70.84 ; v4(279.66,67.35) 279.59,67.42 arc(279.52,67.53) 279.5,67.66 279.5,68.39 arc(279.61,68.95) 279.92,69.42 280.16,69.66 arc(280.31,69.76) 280.5,69.8 D87.1 280.63,70.06 arc(280.63,70.09) 280.65,70.12 280.97,70.44 281.01,70.48 arc(281.12,70.65) 281.16,70.84 ; 281.16,70.84 281.16,70.84 281.16,70.84
TBT_2_TRX_RT_DTX_P1: length 42.9
  TOP w0.076: 277.9,40.7 277.9,40.68 277.9,40.68 277.9,40.61 277.9,40.59 arc(277.89,40.54) 277.86,40.5 277.84,40.49 arc(277.8,40.42) 277.78,40.35 277.78,40.22 arc(277.9,40.11) URT2.C12
  TOP w0.089: D88.2 276.19,70.68 arc(276.17,70.57) 276.12,70.46
  TOP w0.091: JUSBC2.A11 282.42,76.23 arc(282.28,76.22) 282.14,76.21 arc(282.13,76.21) 282.12,76.21 arc(281.98,76.18) 281.86,76.13 arc(281.77,76.07) 281.68,75.99 276.65,70.96 arc(276.5,70.86) 276.31,70.82 D88.2 ; v5(273.91,66.67) 274.07,66.84 arc(274.17,66.98) 274.2,67.14 274.2,67.43 arc(274.24,67.66) 274.37,67.85 274.37,67.85 274.85,68.32 arc(275.07,68.66) 275.15,69.06 275.15,69.07 arc(275.21,69.4) 275.38,69.69 275.38,69.7 275.42,69.74 275.42,69.74 275.76,70.08 275.87,70.2 276.07,70.4 arc(276.1,70.43) 276.12,70.46 ; 277.9,40.7 277.9,40.85 arc(277.86,40.97) 277.76,41.06 arc(277.71,41.08) 277.66,41.08 arc(277.51,41.11) 277.39,41.18 arc(277.39,41.19) 277.38,41.19 arc(277.27,41.27) 277.14,41.29 arc(276.97,41.33) 276.83,41.43 arc(276.74,41.58) 276.7,41.76 276.7,41.98 276.67,42.13 arc(276.64,42.18) 276.61,42.22 v4(276.52,42.3)
  BOTTOM w0.091: v4(276.52,42.3) 276.56,42.34 arc(276.69,42.53) 276.73,42.76 276.73,43.28 arc(276.69,43.51) 276.55,43.71 276.31,43.96 arc(275.4,45.32) 275.08,46.93 275.08,52.24 arc(274.99,52.69) 274.73,53.07 arc(274.56,53.33) 274.5,53.63 274.5,64.49 arc(274.45,64.73) 274.32,64.94 arc(274.17,65.15) 274.12,65.4 274.12,66.15 arc(274.12,66.2) 274.12,66.25 arc(274.1,66.32) 274.08,66.4 arc(274.01,66.54) v5(273.91,66.67)
TBT_2_TTX_C_DRX_N0: length 37.7
  TOP w0.091: CT39.2 279.99,42.41 arc(280.03,42.46) 280.05,42.52 arc(280.05,42.54) 280.05,42.57 arc(280.03,42.64) v1(279.95,42.67) ; JUSBC2.A3 283.19,72.23 arc(283.19,72.23) 283.18,72.23 282.62,72.17 arc(282.56,72.15) 282.5,72.12 arc(282.48,72.1) 282.46,72.08 282.16,71.79 280.81,70.43 arc(280.78,70.41) 280.75,70.41 arc(280.66,70.39) 280.58,70.34 280.54,70.3 arc(280.54,70.3) 280.54,70.3 280.54,70.3 arc(280.48,70.25) 280.4,70.24 D85.1 arc(280.17,70.1) 280.13,69.96 280.13,69.96 arc(280.11,69.92) 280.08,69.87 280.08,69.87 arc(280.07,69.85) 280.06,69.83 arc(280.06,69.83) 280.06,69.83 arc(280.05,69.82) 280.05,69.82 279.3,69.07 arc(279.3,69.07) 279.29,69.06 279.29,69.06 arc(279.29,69.06) 279.29,69.06 279.12,68.89 arc(279.03,68.83) v1(278.92,68.81)
  IN1 w0.081: v1(278.92,68.81) 278.92,68.79 arc(278.92,68.78) 278.92,68.77 277.66,67.51 arc(275.28,63.94) 274.44,59.73 274.44,54.7 arc(274.5,54.41) 274.66,54.17 274.71,54.12 arc(274.95,53.76) 275.03,53.34 275.03,46.93 arc(275.29,45.62) 276.04,44.5 276.39,44.15 arc(277.03,43.72) 277.79,43.57 279.05,43.57 279.47,43.57 arc(279.75,43.52) 279.99,43.36 arc(280.03,43.29) 280.05,43.22 280.05,42.89 arc(280.02,42.77) v1(279.95,42.67)
TBT_2_TTX_C_DRX_N1: length 41.4
  TOP w0.091: CT41.2 278.55,42.29 arc(278.51,42.3) 278.47,42.33 278.46,42.34 arc(278.44,42.38) 278.43,42.42 278.43,42.48 arc(278.44,42.53) 278.47,42.57 v4(278.58,42.68) ; JUSBC2.B3 284.76,75.48 arc(284.5,75.53) v5(284.28,75.68)
  BOTTOM w0.091: v4(278.58,42.68) 278.5,42.76 arc(278.47,42.8) 278.45,42.84 arc(278.41,42.92) 278.4,43.01 arc(278.34,43.3) 278.18,43.55 277.26,44.46 arc(276.42,45.73) 276.12,47.23 276.12,52.74 arc(276.04,53.11) 275.83,53.43 arc(275.62,53.75) 275.55,54.11 275.55,67.29 arc(275.5,67.54) 275.36,67.75 275.36,67.75 arc(275.31,67.82) 275.29,67.91 275.29,68.75 arc(275.49,69.77) 276.07,70.64 arc(276.08,70.65) 276.09,70.66 276.09,70.66 arc(276.14,70.69) 276.19,70.7 D86.2 276.56,71.04 arc(276.58,71.15) 276.64,71.24 arc(276.79,71.32) 276.96,71.35 277.11,71.35 arc(277.44,71.41) 277.72,71.6 281.64,75.52 arc(282.23,75.92) 282.93,76.06 283.81,76.06 arc(283.89,76.04) 283.95,76 v5(284.28,75.68)
TBT_2_TTX_C_DRX_P0: length 37.7
  TOP w0.091: JUSBC2.A2 283,71.73 arc(282.95,71.74) 282.9,71.77 arc(282.87,71.81) 282.86,71.86 arc(282.86,71.89) 282.84,71.92 282.8,71.96 arc(282.79,71.97) 282.77,71.97 282.67,71.97 arc(282.64,71.97) 282.62,71.95 arc(282.61,71.95) 282.6,71.94 280.95,70.29 arc(280.86,70.23) 280.75,70.2 arc(280.74,70.2) 280.73,70.2 280.69,70.16 arc(280.64,70.09) 280.63,70.01 D83.1 arc(280.58,69.83) 280.53,69.84 280.42,69.84 arc(280.33,69.8) 280.25,69.74 280.22,69.71 arc(280.22,69.71) 280.22,69.71 arc(280.21,69.69) 280.19,69.68 279.22,68.7 arc(279.2,68.67) 279.19,68.64 v1(279.19,68.54) ; CT38.2 280.36,42.29 280.31,42.34 arc(280.27,42.41) 280.25,42.49 280.26,42.55 arc(280.27,42.59) 280.29,42.62 280.33,42.66 v1(280.33,42.67)
  IN1 w0.081: v1(279.19,68.54) 279.02,68.54 arc(278.97,68.53) 278.93,68.5 278.93,68.5 277.8,67.37 arc(275.46,63.87) 274.64,59.73 274.64,54.7 arc(274.68,54.49) 274.8,54.31 274.85,54.26 arc(275.13,53.84) 275.23,53.34 275.23,46.93 275.23,46.93 arc(275.47,45.69) 276.18,44.64 276.53,44.29 arc(277.11,43.91) 277.79,43.77 279.47,43.77 arc(279.83,43.7) 280.13,43.5 arc(280.22,43.37) 280.25,43.22 280.25,42.79 arc(280.25,42.76) 280.27,42.73 v1(280.33,42.67)

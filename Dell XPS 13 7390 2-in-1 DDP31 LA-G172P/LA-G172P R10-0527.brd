# Allegro board LA-G172P R10-0527.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
INPAQ_HCM1012GH900BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INTEL_9560PD2WGE2_152P
  oval 0.508x0.305 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 9(0,-4) 10(0,-4.5) 11(0,-5) 12(0,-5.5) 13(0,-6) 14(0,-6.5) 15(0,-7) 16(0,-7.5) 17(0,-8) 18(0,-8.5) 19(0,-9) 20(0,-9.5) 21(0,-10) 22(0,-10.5) 23(0,-11) 24(0,-11.5) 25(0,-12) 26(0,-12.5) 27(0,-13) 28(0,-13.5) 49(11.2,-13.5) 50(11.2,-13) 51(11.2,-12.5) 52(11.2,-12) 53(11.2,-11.5) 54(11.2,-11) 55(11.2,-10.5) 56(11.2,-10) 57(11.2,-9.5) 58(11.2,-9) 59(11.2,-8.5) 60(11.2,-8) 61(11.2,-7.5) 62(11.2,-7) 63(11.2,-6.5) 64(11.2,-6) 65(11.2,-5.5) 66(11.2,-5) 67(11.2,-4.5) 68(11.2,-4) 69(11.2,-3.5) 70(11.2,-3) 71(11.2,-2.5) 72(11.2,-2) 73(11.2,-1.5) 74(11.2,-1) 75(11.2,-0.5) 76(11.2,0) A07(1.75,-4) A08(1.75,-4.5) A09(1.75,-5) A10(1.75,-5.5) A11(1.75,-6) A12(1.75,-6.5) A13(1.75,-7) A14(1.75,-7.5) A15(1.75,-8) A16(1.75,-8.5) A17(1.75,-9) A18(1.75,-9.5) A19(1.75,-10) A20(1.75,-10.5) A21(1.75,-11) A22(1.75,-11.5) A23(1.75,-12) A24(1.75,-12.5) A25(1.75,-13) A26(2,-13.65) A27(2.8,-13.65) A28(5.2,-13.65) A29(6,-13.65) A30(8.4,-13.65) A31(9.2,-13.65) A32(9.45,-13) A33(9.45,-12.5) A34(9.45,-12) A35(9.45,-11.5) A36(9.45,-11) A37(9.45,-10.5) A38(9.45,-10) A39(9.45,-9.5) A40(9.45,-9) A41(9.45,-8.5) A42(9.45,-8) A43(9.45,-7.5) A44(9.45,-7) A45(9.45,-6.5) A46(9.45,-6) A47(9.45,-5.5) A48(9.45,-5) A49(9.45,-4.5) A50(9.45,-4)
  oval 0.305x0.508 smd: 29(0.85,-14.35) 30(1.35,-14.35) 31(1.85,-14.35) 32(2.35,-14.35) 33(2.85,-14.35) 34(3.35,-14.35) 35(3.85,-14.35) 36(4.35,-14.35) 37(4.85,-14.35) 38(5.35,-14.35) 39(5.85,-14.35) 40(6.35,-14.35) 41(6.85,-14.35) 42(7.35,-14.35) 43(7.85,-14.35) 44(8.35,-14.35) 45(8.85,-14.35) 46(9.35,-14.35) 47(9.85,-14.35) 48(10.35,-14.35) 77(10.35,0.85) 78(9.85,0.85) 79(9.35,0.85) 80(8.85,0.85) 81(8.35,0.85) 82(7.85,0.85) 83(7.35,0.85) 84(6.85,0.85) 85(6.35,0.85) 86(5.85,0.85) 87(5.35,0.85) 88(4.85,0.85) 89(4.35,0.85) 90(3.85,0.85) 91(3.35,0.85) 92(2.85,0.85) 93(2.35,0.85) 94(1.85,0.85) 95(1.35,0.85) 96(0.85,0.85)
  rect 0.711x0.711 smd: G1(0.1,0.75) G2(0.1,-14.25) G3(11.1,-14.25) G4(11.1,0.75)
  rect 2.997x2.997 smd: G5(3.95,-1.8) G6(3.95,-5.1) G7(3.95,-8.4) G8(3.95,-11.7) G9(7.25,-1.8) G10(7.25,-5.1) G11(7.25,-8.4) G12(7.25,-11.7)
ISL88738HRTZ-T_TQFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_FP241AH-006GAAM_6P
  oval 0.305x0.965 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 0.305x1.143 smd: 7(-0.885,-2.965) 8(3.385,-2.965)
L2N7002DW1T1G_SC88-6
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
L2N7002WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
LBAT54HT1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.225,0)
LED_HT-F196BP5_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
LMUN5111T1G_SC70-3
  oval 0.711x0.991 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MAG_MLV-YT10NR68N-M1L_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
MAG_MMD-04AE-R47M-M1L_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
MAG_MMD-05AHN1R5M-M1L_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
MAG_MMD-10BZN2R2M-M1L_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
MC74VHC1G32DFT2G_SC70-5
  oval 0.457x0.711 smd: 1(-0.65,-0.925) 2(0,-0.925) 3(0.65,-0.925) 4(0.65,0.925) 5(-0.65,0.925)
MEC5105_WFBGA_169P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B6(4,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C6(4,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D6(4,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E6(4,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F6(4,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G6(4,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H6(4,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J6(4,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K6(4,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L6(4,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M6(4,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N6(4,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601)
MMBT3904LP-7B_X1-DFN1006-3
  rect 0.406x0.711 smd: 1(0,0)
  rect 0.406x0.254 smd: 2(-0.7,0.225) 3(-0.7,-0.225)
MMBT3906LP-7B_X1-DFN1006-3
  rect 0.406x0.711 smd: 1(0,0)
  rect 0.406x0.254 smd: 2(-0.7,0.225) 3(-0.7,-0.225)
MP2940AGRT-0010-Z_TQFN28_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
MP2941GL-Z_QFN19_3X4
  oval 1.702x0.254 smd: 1(0,0) 2(0,-1) 3(0,-2) 11(1.9,-1.5) 12(1.9,-0.5)
  oval 0.254x0.787 smd: 4(-0.1,-2.9) 9(2,-2.9) 14(2,0.9) 19(-0.1,0.9)
  oval 0.203x0.787 smd: 5(0.35,-2.9) 6(0.75,-2.9) 7(1.15,-2.9) 8(1.55,-2.9) 15(1.55,0.9) 16(1.15,0.9) 17(0.75,0.9) 18(0.35,0.9)
  oval 0.787x0.254 smd: 10(2.35,-2) 13(2.35,0)
MP86902-BGLT-Z_TQFN21-15_3X4
  oval 1.6x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1.3) 4(0,-2.1) 6(2,-1.7) 7(2,-0.9) 8(2,0)
  custom 0.2x0.2 smd: 5(1,-2.95)
  custom 0.175x0.175 smd: 9(2.2,0.85) 15(-0.2,0.85)
  oval 0.203x0.787 smd: 10(1.8,0.85) 11(1.4,0.85) 12(1,0.85) 13(0.6,0.85) 14(0.2,0.85)
MURAT_BLM15AX700SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX330SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM18EG221SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18KG331SN1D_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
MURAT_BLM18SG260TN1D_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
MURAT_LQP03TN1N2B02D_2P
  rect 0.305x0.305 smd: 1(0,0) 2(0.6,0)
MURAT_LQP03TN1N8B00D_2P
  rect 0.305x0.305 smd: 1(0,0) 2(0.55,0)
NB502GQ-Z_QFN16_3X3
  oval 2.311x0.254 smd: 1(0,0) 2(0,-1) 9(1.7,-0.5)
  oval 0.254x0.889 smd: 3(-0.4,-2.05) 4(0.1,-2.05) 5(0.6,-2.05) 6(1.1,-2.05) 7(1.6,-2.05) 8(2.1,-2.05) 11(2.1,1.05) 12(1.6,1.05) 13(1.1,1.05) 14(0.6,1.05) 15(0.1,1.05) 16(-0.4,1.05)
  oval 1.092x0.254 smd: 10(2.3,0)
NB691GG-Z_QFN11_2X2
  oval 1.702x0.254 smd: 1(0,0) 6(1.3,-0.5)
  oval 0.254x0.838 smd: 2(-0.1,-1.325) 3(0.4,-1.325) 4(0.9,-1.325) 5(1.4,-1.325) 8(1.4,0.825) 9(0.9,0.825) 10(0.4,0.825) 11(-0.1,0.825)
  oval 0.838x0.254 smd: 7(1.725,0)
NB693GQ-Z_QFN16_3X3
  oval 2.311x0.254 smd: 1(0,0) 2(0,-1) 9(1.7,-0.5)
  oval 0.254x0.889 smd: 3(-0.4,-2.05) 4(0.1,-2.05) 5(0.6,-2.05) 6(1.1,-2.05) 7(1.6,-2.05) 8(2.1,-2.05) 11(2.1,1.05) 12(1.6,1.05) 13(1.1,1.05) 14(0.6,1.05) 15(0.1,1.05) 16(-0.4,1.05)
  oval 1.092x0.254 smd: 10(2.3,0)
NSR20F30NXT5G_DSN2-2
  rect 0.432x0.711 smd: 1(-0.05,0)
  rect 0.787x0.508 smd: 2(0.94,0)
PMBT3904MB_SOT883B
  rect 0.711x0.406 smd: 1(0,0)
  rect 0.254x0.406 smd: 2(-0.225,-0.7) 3(0.225,-0.7)
PMDXB600UNE_DFN1010B-6
  oval 0.254x0.305 smd: 1(0,0) 2(0.35,0) 3(0.7,0) 4(0.7,0.85) 5(0.35,0.85) 6(0,0.85)
PTPS65988DHRSHR_VQFN56_7X7-S
  oval 0.991x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7,-5.2) 30(7,-4.8) 31(7,-4.4) 32(7,-4) 33(7,-3.6) 34(7,-3.2) 35(7,-2.8) 36(7,-2.4) 37(7,-2) 38(7,-1.6) 39(7,-1.2) 40(7,-0.8) 41(7,-0.4) 42(7,0)
  oval 0.203x0.991 smd: 15(0.9,-6.1) 16(1.3,-6.1) 17(1.7,-6.1) 18(2.1,-6.1) 19(2.5,-6.1) 20(2.9,-6.1) 21(3.3,-6.1) 22(3.7,-6.1) 23(4.1,-6.1) 24(4.5,-6.1) 25(4.9,-6.1) 26(5.3,-6.1) 27(5.7,-6.1) 28(6.1,-6.1) 43(6.1,0.9) 44(5.7,0.9) 45(5.3,0.9) 46(4.9,0.9) 47(4.5,0.9) 48(4.1,0.9) 49(3.7,0.9) 50(3.3,0.9) 51(2.9,0.9) 52(2.5,0.9) 53(2.1,0.9) 54(1.7,0.9) 55(1.3,0.9) 56(0.9,0.9)
  rect 1.753x2.591 smd: 57(1.625,-1.15)
  rect 1.753x2.54 smd: 58(1.625,-4.075)
  rect 3.404x5.512 smd: 59(4.55,-2.6)
R0201_0OHM
  custom 0.089x0.089 smd: 1(0,0)
  rect 0.381x0.356 smd: 2(0.584,0)
R0402_0OHM
  custom 0.14x0.14 smd: 1(0,0)
  rect 0.508x0.559 smd: 2(0.914,0)
R0603_0OHM
  custom 0.222x0.222 smd: 1(0,0)
  rect 0.635x0.889 smd: 2(1.397,0)
R0805_0OHM
  custom 0.349x0.349 smd: 1(0,0)
  rect 0.813x1.397 smd: 2(1.702,0)
R1206_0OHM
  custom 0.413x0.413 smd: 1(0,0)
  rect 1.016x1.651 smd: 2(2.667,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB520SM-30T2R_EMD2-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751S40T1G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751V40_SC76-2
  rect 0.61x0.61 smd: 1(0,0) 2(2.2,0)
RT6243BGQVF_VQFN18_3P5X3P5
  oval 0.838x0.305 smd: 1(0,0) 12(3.45,0)
  oval 1.397x0.457 smd: 2(0.275,-0.575) 11(3.175,-0.575)
  oval 1.397x0.305 smd: 3(0.275,-1.225) 4(0.275,-1.775) 5(0.275,-2.325) 8(3.175,-2.325) 9(3.175,-1.775) 10(3.175,-1.225)
  oval 0.305x2.845 smd: 6(1.425,-1.65) 7(2.025,-1.65)
  oval 0.305x0.838 smd: 13(2.975,0.8) 14(2.475,0.8) 15(1.975,0.8) 16(1.475,0.8) 17(0.975,0.8) 18(0.475,0.8)
RTS5242-GR_QFN32_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
S-SUN_PM971_291P-T
  round 0.343 smd: A1(-0.001,0.001) A2(0.799,0.001) A4(2.4,0.001) A6(4,0.001) A8(5.6,0.001) A11(8,0.001) A13(9.6,0.001) A15(11.201,0.001) A17(12.801,0.001) A18(13.601,0.001) AA1(-0.001,-16.001) AA2(0.799,-16.001) AA3(1.599,-16.001) AA4(2.4,-16.001) AA5(3.2,-16.001) AA6(4,-16.001) AA7(4.8,-16.001) AA8(5.6,-16.001) AA9(6.4,-16.001) AA10(7.2,-16.001) AA11(8,-16.001) AA12(8.8,-16.001) AA13(9.6,-16.001) AA14(10.401,-16.001) AA15(11.201,-16.001) AA16(12.001,-16.001) AA17(12.801,-16.001) AA18(13.601,-16.001) AB1(-0.001,-16.801) AB2(0.799,-16.801) AB4(2.4,-16.801) AB6(4,-16.801) AB8(5.6,-16.801) AB11(8,-16.801) AB13(9.6,-16.801) AB15(11.201,-16.801) AB17(12.801,-16.801) AB18(13.601,-16.801) AC1(-0.001,-17.601) AC2(0.799,-17.601) AC4(2.4,-17.601) AC6(4,-17.601) AC8(5.6,-17.601) AC11(8,-17.601) AC13(9.6,-17.601) AC15(11.201,-17.601) AC17(12.801,-17.601) AC18(13.601,-17.601) B1(-0.001,-0.799) B2(0.799,-0.799) B4(2.4,-0.799) B6(4,-0.799) B8(5.6,-0.799) B11(8,-0.799) B13(9.6,-0.799) B15(11.201,-0.799) B17(12.801,-0.799) B18(13.601,-0.799) C1(-0.001,-1.599) C2(0.799,-1.599) C3(1.599,-1.599) C4(2.4,-1.599) C5(3.2,-1.599) C6(4,-1.599) C7(4.8,-1.599) C8(5.6,-1.599) C9(6.4,-1.599) C10(7.2,-1.599) C11(8,-1.599) C12(8.8,-1.599) C13(9.6,-1.599) C14(10.401,-1.599) C15(11.201,-1.599) C16(12.001,-1.599) C17(12.801,-1.599) C18(13.601,-1.599) D4(2.4,-2.399) D5(3.2,-2.399) D6(4,-2.399) D7(4.8,-2.399) D8(5.6,-2.399) D9(6.4,-2.399) D10(7.2,-2.399) D11(8,-2.399) D12(8.8,-2.399) D13(9.6,-2.399) D14(10.401,-2.399) D15(11.201,-2.399) E1(-0.001,-3.199) E2(0.799,-3.199) E3(1.599,-3.199) E4(2.4,-3.199) E5(3.2,-3.199) E6(4,-3.199) E7(4.8,-3.199) E8(5.6,-3.199) E9(6.4,-3.199) E10(7.2,-3.199) E11(8,-3.199) E12(8.8,-3.199) E13(9.6,-3.199) E14(10.401,-3.199) E15(11.201,-3.199) E16(12.001,-3.199) E17(12.801,-3.199) E18(13.601,-3.199) F4(2.4,-3.999) F5(3.2,-3.999) F6(4,-3.999) F14(10.401,-3.999) F15(11.201,-3.999) G1(-0.001,-4.8) G2(0.799,-4.8) G3(1.599,-4.8) G4(2.4,-4.8) G5(3.2,-4.8) G7(4.8,-4.8) G8(5.6,-4.8) G9(6.4,-4.8) G10(7.2,-4.8) G11(8,-4.8) G12(8.8,-4.8) G14(10.401,-4.8) G15(11.201,-4.8) G16(12.001,-4.8) G17(12.801,-4.8) G18(13.601,-4.8) H4(2.4,-5.6) H5(3.2,-5.6) H7(4.8,-5.6) H8(5.6,-5.6) H9(6.4,-5.6) H10(7.2,-5.6) H11(8,-5.6) H12(8.8,-5.6) H14(10.401,-5.6) H15(11.201,-5.6) J1(-0.001,-6.4) J2(0.799,-6.4) J3(1.599,-6.4) J4(2.4,-6.4) J5(3.2,-6.4) J7(4.8,-6.4) J8(5.6,-6.4) J9(6.4,-6.4) J10(7.2,-6.4) J11(8,-6.4) J12(8.8,-6.4) J14(10.401,-6.4) J15(11.201,-6.4) J16(12.001,-6.4) J17(12.801,-6.4) J18(13.601,-6.4) K4(2.4,-7.2) K5(3.2,-7.2) K7(4.8,-7.2) K8(5.6,-7.2) K9(6.4,-7.2) K10(7.2,-7.2) K11(8,-7.2) K12(8.8,-7.2) K14(10.401,-7.2) K15(11.201,-7.2) L1(-0.001,-8) L2(0.799,-8) L3(1.599,-8) L4(2.4,-8) L5(3.2,-8) L7(4.8,-8) L8(5.6,-8) L9(6.4,-8) L10(7.2,-8) L11(8,-8) L12(8.8,-8) L14(10.401,-8) L15(11.201,-8) L16(12.001,-8) L17(12.801,-8) L18(13.601,-8) M4(2.4,-8.8) M5(3.2,-8.8) M7(4.8,-8.8) M8(5.6,-8.8) M9(6.4,-8.8) M10(7.2,-8.8) M11(8,-8.8) M12(8.8,-8.8) M14(10.401,-8.8) M15(11.201,-8.8) N1(-0.001,-9.6) N2(0.799,-9.6) N3(1.599,-9.6) N4(2.4,-9.6) N5(3.2,-9.6) N7(4.8,-9.6) N8(5.6,-9.6) N9(6.4,-9.6) N10(7.2,-9.6) N11(8,-9.6) N12(8.8,-9.6) N14(10.401,-9.6) N15(11.201,-9.6) N16(12.001,-9.6) N17(12.801,-9.6) N18(13.601,-9.6) P4(2.4,-10.4) P5(3.2,-10.4) P7(4.8,-10.4) P8(5.6,-10.4) P9(6.4,-10.4) P10(7.2,-10.4) P11(8,-10.4) P12(8.8,-10.4) P14(10.401,-10.4) P15(11.201,-10.4) R1(-0.001,-11.2) R2(0.799,-11.2) R3(1.599,-11.2) R4(2.4,-11.2) R5(3.2,-11.2) R7(4.8,-11.2) R8(5.6,-11.2) R9(6.4,-11.2) R10(7.2,-11.2) R11(8,-11.2) R12(8.8,-11.2) R14(10.401,-11.2) R15(11.201,-11.2) R16(12.001,-11.2) R17(12.801,-11.2) R18(13.601,-11.2) T4(2.4,-12) T5(3.2,-12) T7(4.8,-12) T8(5.6,-12) T9(6.4,-12) T10(7.2,-12) T11(8,-12) T12(8.8,-12) T14(10.401,-12) T15(11.201,-12) U1(-0.001,-12.801) U2(0.799,-12.801) U3(1.599,-12.801) U4(2.4,-12.801) U5(3.2,-12.801) U7(4.8,-12.801) U8(5.6,-12.801) U9(6.4,-12.801) U10(7.2,-12.801) U11(8,-12.801) U12(8.8,-12.801) U14(10.401,-12.801) U15(11.201,-12.801) U16(12.001,-12.801) U17(12.801,-12.801) U18(13.601,-12.801) V4(2.4,-13.601) V5(3.2,-13.601) V14(10.401,-13.601) V15(11.201,-13.601) W1(-0.001,-14.401) W2(0.799,-14.401) W3(1.599,-14.401) W4(2.4,-14.401) W5(3.2,-14.401) W6(4,-14.401) W7(4.8,-14.401) W8(5.6,-14.401) W9(6.4,-14.401) W10(7.2,-14.401) W11(8,-14.401) W12(8.8,-14.401) W13(9.6,-14.401) W14(10.401,-14.401) W15(11.201,-14.401) W16(12.001,-14.401) W17(12.801,-14.401) W18(13.601,-14.401) Y4(2.4,-15.201) Y5(3.2,-15.201) Y6(4,-15.201) Y7(4.8,-15.201) Y8(5.6,-15.201) Y9(6.4,-15.201) Y10(7.2,-15.201) Y11(8,-15.201) Y12(8.8,-15.201) Y13(9.6,-15.201) Y14(10.401,-15.201) Y15(11.201,-15.201)
SAMTE_QSH-030-01-H-D-A_60P-T
  round 1.016 hole 1.016 unplated: (-2.81,5.54) (17.31,5.54)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.74) 3(0.5,0) 4(0.5,5.74) 5(1,0) 6(1,5.74) 7(1.5,0) 8(1.5,5.74) 9(2,0) 10(2,5.74) 11(2.5,0) 12(2.5,5.74) 13(3,0) 14(3,5.74) 15(3.5,0) 16(3.5,5.74) 17(4,0) 18(4,5.74) 19(4.5,0) 20(4.5,5.74) 21(5,0) 22(5,5.74) 23(5.5,0) 24(5.5,5.74) 25(6,0) 26(6,5.74) 27(6.5,0) 28(6.5,5.74) 29(7,0) 30(7,5.74) 31(7.5,0) 32(7.5,5.74) 33(8,0) 34(8,5.74) 35(8.5,0) 36(8.5,5.74) 37(9,0) 38(9,5.74) 39(9.5,0) 40(9.5,5.74) 41(10,0) 42(10,5.74) 43(10.5,0) 44(10.5,5.74) 45(11,0) 46(11,5.74) 47(11.5,0) 48(11.5,5.74) 49(12,0) 50(12,5.74) 51(12.5,0) 52(12.5,5.74) 53(13,0) 54(13,5.74) 55(13.5,0) 56(13.5,5.74) 57(14,0) 58(14,5.74) 59(14.5,0) 60(14.5,5.74)
  rect 2.54x0.432 smd: 61(-0.815,2.87) 64(15.315,2.87)
  rect 4.699x0.432 smd: 62(4.075,2.87) 63(10.425,2.87)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3457BDV-T1-E3_TSOP6
  oval 0.508x1.448 smd: 1(0,0) 2(1,0) 3(2,0) 4(2,2.425) 5(1,2.425) 6(0,2.425)
SLB9670VQ1P2-FW4P4X_VQFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.607x3.607 smd: 33(2.55,-1.75)
SMF4L22A_SOD123FL2
  rect 1.295x1.397 smd: 1(0,0) 2(2.9,0)
SN74AUP1G97DRLR_SOT_6P
  oval 0.305x0.457 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,1.35) 5(0.5,1.35) 6(0,1.35)
SN74LVC1G123DCUR_VSSOP8
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.825) 6(1,2.825) 7(0.5,2.825) 8(0,2.825)
SW_SKSFABE010_4P
  rect 0.559x0.61 smd: 1(0,0) 2(0,-1.65) 3(2.65,0) 4(2.65,-1.65)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
T-SOL_158-9090302600_18P-T
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0)
  oval 1.092x0.356 smd: 10(-5.54,-13.29) 11(-5.54,-13.84) 12(-5.54,-14.39) 13(-5.54,-14.94) 14(-5.54,-15.49) 15(10.26,-15.49) 16(10.26,-14.94) 17(10.26,-14.39) 18(10.26,-13.84)
  oval 1.194x1.803 hole 0.508x1.092: 19(-5.59,-10.45) 22(10.31,-10.45)
  rect 0.889x0.991 smd: 20(-2.39,0) 21(8.41,0)
TAI-T_HCB1608KF-121T3_L0603_2P
  rect 0.991x0.787 smd: 1(0,0) 2(1.6,0)
TAI-T_HCB2012KF-121T50_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
TAI-T_UHP252012NF-R68M_2P
  rect 1.041x2.388 smd: 1(0,0) 2(1.85,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TOKO_1277AS-H-1R0N-P2_2P
  rect 0.762x2.489 smd: 1(0,0) 2(2.45,0)
TOKO_FDSD0412-H-1R0M-P3_2P
  rect 1.702x2.388 smd: 1(0,0) 2(3.5,0)
TPC12
  round 0.305 smd: 1(0,0)
TPC20
  round 0.508 smd: 1(0,0)
TS3DS10224RUKR_WQFN20_3X3-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 11(3.1,-1.6) 12(3.1,-1.2) 13(3.1,-0.8) 14(3.1,-0.4) 15(3.1,0)
  oval 0.203x0.889 smd: 6(0.75,-2.35) 7(1.15,-2.35) 8(1.55,-2.35) 9(1.95,-2.35) 10(2.35,-2.35) 16(2.35,0.75) 17(1.95,0.75) 18(1.55,0.75) 19(1.15,0.75) 20(0.75,0.75)
  rect 1.702x1.702 smd: 21(1.55,-0.8)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TWVM_FPC0510-08RC-TAGHA_8P
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0)
  rect 0.406x1.194 smd: 9(1,-2.85) 10(-4.5,-2.85)
UNIMI_FCECBE015_6P-T
  rect 2.007x2.007 smd: 1(0,0) 2(0,-2.5) 3(-2.5,0) 4(-2.5,-2.5) 5(-5,0) 6(-5,-2.5)
UNIMI_LLGCBE018_6P-T
  round 1.092 hole 1.092 unplated: (-3.125,0) (11.295,0)
  round 2.591 hole 2.591 unplated: (4.085,0)
  custom 1.077x1.077 smd: 1(0,0) 6(8.17,0)
  rect 0.787x0.61 smd: 2(3.345,1.855) 3(4.825,1.855) 4(3.345,-1.855) 5(4.825,-1.855)
W25Q64FVZPIG_WSON8_6X5
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
W25Q256JVEIQ_WSON8_8X6-S
  oval 0.66x0.991 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,8) 6(2.54,8) 7(1.27,8) 8(0,8)
  rect 4.293x3.404 smd: 9(1.905,4)
Y_8Y38420005_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.4,0) 3(1.4,1.1) 4(0,1.1)
Y_9H03200042_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_FW2500025Z_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.4,0) 3(1.4,1.1) 4(0,1.1)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)

## Nets
0.6V_VDDQ_EN: RD43.1 RD44.2 RD400.1
0.6V_VDDQ_EN_P: CD309.1 PU800.11 RD300.1 RD400.2
0.6V_VDDQ_PG: PR802.1 PU800.5 RD41.2
1.1V_MEM_EN: CC707.1 PU700.15 RC736.2 RC737.1 RD43.2
1.1V_MEM_PG: PR703.1 PU700.16 RD42.2
1.8V_PRIM_PG: D475.1 PR503.1 PR509.2 PR912.1 PU500.5 RE245.2
3.3V_CAM_EN: R6163.1 UC1.CV43
3.3V_CAM_EN_R: R704.2 R6162.2 R6163.2 U55.4
3.3V_TBT_L_EN: RT83.2 RT84.2 RT178.1 RT179.1 UT1.3
3.3V_TBT_R_EN: RT93.1 RT94.2 RT95.2 RT158.1 UT2.3
3.3V_TS_EN: R6168.1 UE1.J7
3V_PRIM_EN: RC657.2 U31.5
3VALW_DSW_EN: RC651.2 U31.3
3VALW_PG: PR308.1 PU300.12 RC702.1
3VS_SSD_EN: RS378.2 US1.3
5VALW_PG: PR408.1 PU400.12 RC703.1
5VALWB_PG: PR420.1 PU401.12 RC704.1
+0.6V_VDDQ: PJP800.2 RD45.1
+0.6V_VDDQP: PC806.1 PC807.1 PC808.1 PC809.1 PJP800.1 PL801.2 PR803.1
+0.9V_TBT_L_LC: CT59.1 URT1.J3
+0.9V_TBT_L_LVR: CT60.1 CT200.1 URT1.L6 URT1.M6
+0.9V_TBT_L_SVR: CT49.1 CT50.1 CT51.1 CT52.1 CT53.1 CT54.1 CT55.1 CT56.1 LT8.2 URT1.E3 URT1.E9 URT1.F6 URT1.G3 URT1.G6 URT1.G9
+0.9V_TBT_R_LC: CT82.1 URT2.J3
+0.9V_TBT_R_LVR: CT84.1 CT201.1 URT2.L6 URT2.M6
+0.9V_TBT_R_SVR: CT73.1 CT74.1 CT75.1 CT76.1 CT77.1 CT78.1 CT79.1 CT80.1 LT5.2 URT2.E3 URT2.E9 URT2.F6 URT2.G3 URT2.G6 URT2.G9
+1.1V_MEM: CC130.1 CC131.1 CC132.1 CC133.1 CC134.1 CC135.1 CC136.1 CC137.1 CC138.1 CC139.1 CC140.1 CC141.1 CC142.1 CC395.1 CC643.1 CC644.1 CC645.1 CC646.1 CC647.1 CC648.1 CC660.1 CC661.1 CC662.1 CC663.1 CC664.1 CC665.1 CD3.1 CD4.1 CD5.1 CD6.1 CD7.1 CD17.1 CD18.1 CD19.1 CD20.1 CD21.1 CD22.1 CD33.1 CD34.1 CD35.1 CD36.1 CD37.1 CD38.1 CD55.1 CD56.1 CD57.1 CD58.1 CD59.1 CD60.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD306.1 CD307.1 CD308.1 PJP700.2 RD25.2 RD27.2 RD29.2 RD31.2 RD33.2 RD35.2 RD37.2 RD39.2 RD46.1 RH12.2 UC1.AA37 UC1.AA49 UC1.AB36 UC1.AC35 UC1.AC37 UC1.AD35 UC1.AD36 UC1.AE36 UC1.AF49 UC1.AG36 UC1.AJ36 UC1.AL36 UC1.AL49 UC1.AN36 UC1.AP37 UC1.AR36 UC1.AR37 UC1.AT36 UC1.AT49 UC1.AV36 UC1.AW37 UC1.AY36 UC1.BA37 UC1.BA49 UC1.BB36 UC1.BD36 UC1.BE37 UC1.BF36 UC1.BF37 UC1.BF49 UC1.BG36 UC1.BJ36 UC1.BL37 UC1.BM49 UC1.BN37 UC1.BP38 UC1.BP39 UC1.BR37 UC1.BT38 UC1.BU37 UC1.BU49 UC1.CA39 UC1.CB49 UC1.L38 UC1.L49 UC1.N36 UC1.T49 UC27.1 UC27.2 UC27.7 UD1.A4 UD1.A9 UD1.AB4 UD1.AB9 UD1.F5 UD1.F8 UD1.H1 UD1.H5 UD1.H8 UD1.H12 UD1.K1 UD1.K3 UD1.K10 UD1.K12 UD1.N1 UD1.N3 UD1.N10 UD1.N12 UD1.R1 UD1.R5 UD1.R8 UD1.R12 UD1.U5 UD1.U8 UD2.A4 UD2.A9 UD2.AB4 UD2.AB9 UD2.F5 UD2.F8 UD2.H1 UD2.H5 UD2.H8 UD2.H12 UD2.K1 UD2.K3 UD2.K10 UD2.K12 UD2.N1 UD2.N3 UD2.N10 UD2.N12 UD2.R1 UD2.R5 UD2.R8 UD2.R12 UD2.U5 UD2.U8 UD3.A4 UD3.A9 UD3.AB4 UD3.AB9 UD3.F5 UD3.F8 UD3.H1 UD3.H5 UD3.H8 UD3.H12 UD3.K1 UD3.K3 UD3.K10 UD3.K12 UD3.N1 UD3.N3 UD3.N10 UD3.N12 UD3.R1 UD3.R5 UD3.R8 UD3.R12 UD3.U5 UD3.U8 UD4.A4 UD4.A9 UD4.AB4 UD4.AB9 UD4.F5 UD4.F8 UD4.H1 UD4.H5 UD4.H8 UD4.H12 UD4.K1 UD4.K3 UD4.K10 UD4.K12 UD4.N1 UD4.N3 UD4.N10 UD4.N12 UD4.R1 UD4.R5 UD4.R8 UD4.R12 UD4.U5 UD4.U8
+1.1V_MEMP: PC708.1 PC709.1 PC710.1 PC711.1 PC712.1 PC716.1 PJP700.1 PL701.2 PR702.1
+1.05V_VCCST: PC1106.1 PR1127.1 PR1128.1 PR1129.1 RC592.2 RC602.1 RC604.1 RC606.1 RE147.2 RE477.1 RH80.2 RH95.2 RH588.2
+1.05V_VCCSTG: PR1109.1 R112.1 RC146.2 RC150.2 RC151.2 RC181.2 RC202.2 RC203.2 RC659.2 RH96.2
+1.8V_1.2V_SSD: C4210.1 LS2.1 R6135.2
+1.8V_1.2V_SSD_R: R6135.1 U734.7 U734.8
+1.8V_1.2VDX_SSD: C1695.1 C1696.1 C1697.1 C1698.1 C1699.1 C1700.1 C1704.1 C1705.1 C1706.1 C1707.1 CC389.1 CC390.1 JSSD1.18 LS2.2 USSD1.R7 USSD1.R8 USSD1.R11 USSD1.R12 USSD1.T7 USSD1.T8 USSD1.T11 USSD1.T12 USSD1.U7 USSD1.U8 USSD1.U11 USSD1.U12
+1.8V_3.3V_ALW_VTR3: CE88.1 RE183.2 RH565.2 UE1.N5
+1.8V_MEM: CC394.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD29.1 CD30.1 CD31.1 CD32.1 CD51.1 CD52.1 CD53.1 CD54.1 CD67.1 CD68.1 CD69.1 CD70.1 CD303.1 CD304.1 CD305.1 RC139.2 UD1.F1 UD1.F12 UD1.G4 UD1.G9 UD1.T4 UD1.T9 UD1.U1 UD1.U12 UD2.F1 UD2.F12 UD2.G4 UD2.G9 UD2.T4 UD2.T9 UD2.U1 UD2.U12 UD3.F1 UD3.F12 UD3.G4 UD3.G9 UD3.T4 UD3.T9 UD3.U1 UD3.U12 UD4.F1 UD4.F12 UD4.G4 UD4.G9 UD4.T4 UD4.T9 UD4.U1 UD4.U12
+1.8V_MEM_R: RC139.1 UC23.6
+1.8V_PRIM: C252.1 C256.1 C3011.2 CC386.1 CE54.1 LC1.2 PJP500.2 R6206.1 RC120.2 RC165.1 RC351.1 RC582.1 RC587.2 RC609.1 RC610.1 RE522.2 RH565.1 RH612.1 RH613.1 RH614.1 RH615.1 RH616.1 RH724.2 RH725.2 RW1.2 RW29.2 RW32.2 RW43.2 UC22.1 UC22.2 UC22.7 UC23.1 UC23.2 UC23.7 UC24.1 UC24.2 UC25.1 UC25.2 UE10.6
+1.8V_PRIMP: PC505.2 PC506.1 PC507.1 PC508.1 PC509.1 PJP500.1 PL500.2 PR502.1
+1.8VS: C248.1 R441.2 R444.1 R445.1 R724.2 R6128.2 R6129.2 RE451.2
+1.8VS_AUDIO: C276.1 CA24.1 CA29.1 R211.2 RA36.1 RA41.1 UA1.20
+1.8VS_AUDIO_R: R211.1 UC25.7 UC25.8
+1.8VS_R: R441.1 UC24.7 UC24.8
+3.3V_ALW2: PC313.1 PR308.2 PU300.3 RE152.1
+3.3V_ALW_UE1: CE43.1 CE44.1 CE45.1 CE49.1 CE50.1 CE51.1 RE49.2 RE113.1 UE1.B7 UE1.G8 UE1.H1 UE1.K2 UE1.M9
+3.3V_BAT_LDO: PD101.2 PD604.2 PR110.2 QE23.2 RE520.1 RPD114.1 RPD115.1 RTCD2.2
+3.3V_EC_PLL: CE47.1 CE48.1 RE113.2 UE1.F1
+3.3V_TBT_L: CT363.2 LT3.2 RT13.2 RT16.2 RT18.2 RT79.1 RT168.2 RT172.2 RT180.2 RT181.2 RT203.2 RT218.2 RT222.2
+3.3V_TBT_L_ANA: CT58.1 URT1.L2
+3.3V_TBT_L_B: LT3.1 UT1.7 UT1.8
+3.3V_TBT_L_DB: RT203.1 URT1.J5
+3.3V_TBT_L_FLASH: DT1.1 JDB3.1 RT20.2 RT21.2 RT22.2 RT23.2 UTS1.8
+3.3V_TBT_L_FLASH_R: DT1.2 RT168.1 RT169.1 RT176.1 RT186.1
+3.3V_TBT_L_LC: CT57.1 RT63.2 RT64.2 RT65.2 RT97.2 RT176.2 URT1.E5
+3.3V_TBT_L_SVR: CT62.1 CT63.1 CT365.1 RT181.1 URT1.M4 URT1.M5
+3.3V_TBT_L_SX: CT61.1 RT180.1 URT1.E6
+3.3V_TBT_R: CT212.2 LT15.2 RT37.2 RT38.2 RT41.2 RT88.1 RT171.2 RT173.2 RT184.2 RT185.2 RT202.2 RT219.2 RT224.2
+3.3V_TBT_R_ANA: CT69.1 URT2.L2
+3.3V_TBT_R_B: LT15.1 UT2.7 UT2.8
+3.3V_TBT_R_DB: RT202.1 URT2.J5
+3.3V_TBT_R_FLASH: DT2.1 JDB4.1 RT42.2 RT43.2 RT44.2 RT45.2 UTS2.8
+3.3V_TBT_R_FLASH_R: DT2.2 RT170.1 RT171.1 RT177.1 RT187.1
+3.3V_TBT_R_LC: CT68.1 RT71.2 RT72.2 RT73.2 RT98.2 RT177.2 URT2.E5
+3.3V_TBT_R_SVR: CT71.1 CT72.1 CT366.1 RT185.1 URT2.M4 URT2.M5
+3.3V_TBT_R_SX: CT70.1 RT184.1 URT2.E6
+3.3V_VPS_TPM: C96.1 C97.1 C1387.1 R626.2 R687.2 R5717.2 U712.14 U712.22
+3.3VA_TBT_L: CT64.1 CT302.1 CT303.1 RT79.2 URT1.J7
+3.3VA_TBT_R: CT81.1 CT304.1 CT305.1 RT88.2 URT2.J7
+3.3VDX_SSD: C1675.1 C1686.1 C1687.1 C1688.1 C1689.1 C1690.1 C1691.1 CC387.1 CC388.1 JSSD1.19 R6133.2 USSD1.D9 USSD1.D10 USSD1.E9 USSD1.E10 USSD1.W9 USSD1.W10 USSD1.Y9 USSD1.Y10
+3.3VDX_SSD_R: R6133.1 U733.7 U733.8
+3V_1.8V_HDA: CC23.1 CC168.2 LC2.2 UC1.DF26
+3V_1.8V_HDA_R: CC167.2 LC2.1 RC165.2 RC168.2
+3V_5V_CAM_PWR: R694.2 R720.2 U55.5
+3V_NB_LID: JIO1.22 PD603.1 PD604.1 PR600.1 PR601.1 PR602.1 PR606.1 PU600.8 QF1.2 R390.2 RE411.1 RE478.1 RE479.1
+3V_NB_LID_R: RE411.2 UE6.8
+3V_PRIM: C1468.1 CC164.1 CC170.1 CC171.1 CC620.1 CC621.1 CC622.1 CC625.1 CC632.1 CC633.1 CC652.2 D20.2 JAPS1.1 JAPS1.7 R138.1 R210.1 R311.1 R410.1 R616.1 R617.1 R656.1 R5717.1 R6048.2 R6172.1 R6173.1 R6174.1 R6175.1 R6205.1 RC168.1 RC583.1 RC616.1 RC617.1 RC671.1 RC672.1 RC673.1 RC680.1 RC682.1 RC687.2 RC744.2 RC745.1 RC747.1 RC751.1 RC752.1 RH143.2 RH144.2 RH592.2 RH603.2 RH604.2 RH605.2 RH606.2 RH607.2 RH618.2 RH629.2 RH646.1 RH647.2 RH660.2 RH666.2 RH667.2 RH672.2 RH692.2 RH709.1 RH742.2 RH745.1 RH746.1 RT8.2 RT109.2 RT186.2 RT187.2 RT189.2 UC1.DF23 UC1.DG26 UC1.DG28 UC6.5 UC7.5 UC8.1 UC8.5 UC9.5 UC10.5 UC11.1 UC11.5 UH1.5
+3V_PRIM_R: R6048.1 U31.8 U31.9
+3V_SPI: CH35.1 D20.1 JSPI1.8 JSPI1.9 RC745.2 UH8.8
+3VALW: C37.1 C216.1 C229.1 C235.1 C240.1 C243.1 C454.1 C455.1 C622.1 C628.1 C1469.1 C1678.1 C4199.1 C4201.1 C4202.1 C4203.1 C4216.1 CC1.1 CE46.1 CE52.1 CE53.1 CM1.2 CM2.2 CS94.1 CT211.1 CT361.1 JAPS1.3 JIO1.14 JIO1.16 JIO1.18 PD603.2 PJP300.2 PR101.1 PR103.1 PR509.1 PR900.1 PR1102.1 PR1111.1 PR1112.1 PR1113.1 PR1114.1 PR1409.1 Q30.2 Q30.5 R283.1 R322.1 R375.1 R532.1 R626.1 R652.1 R688.1 R694.1 R6204.2 RC147.2 RC663.1 RC664.1 RE49.1 RE87.2 RE96.1 RE97.1 RE98.1 RE99.1 RE100.1 RE101.1 RE102.1 RE108.2 RE109.2 RE111.2 RE112.2 RE122.1 RE123.1 RE124.2 RE130.1 RE133.1 RE156.2 RE194.1 RE200.2 RE201.1 RE202.1 RE203.1 RE204.1 RE208.1 RE210.2 RE211.2 RE212.2 RE213.2 RE215.1 RE247.1 RE426.2 RE445.2 RE446.2 RE449.2 RE458.2 RE459.2 RE469.2 RE470.2 RE481.2 RE483.2 RE484.2 RE486.2 RE488.2 RE493.2 RE521.1 RE525.1 RPD84.1 RPD93.1 RT93.2 RT178.2 RT223.2 RT225.2 RTCD3.2 RW19.2 RW39.2 RW40.2 U7.5 U15.5 U31.1 U31.2 U31.6 U31.7 U34.1 U34.2 U34.6 U34.7 U51.1 U51.2 U51.4 U733.1 U733.2 UC2.5 UC4.5 UC5.5 UC30.1 UC30.2 UC30.4 UC31.5 UE5.6 UE8.5 UM1.13 UM2.13 US1.1 US1.2 UT1.1 UT1.2 UT1.4 UT2.1 UT2.2 UT2.4 UW2.6
+3VALW_DSW: C218.1 CC180.1 R204.2 R267.2 RH297.2 RH301.2 RH460.2 RH601.2 RH653.2 UC1.DE31
+3VALW_DSW_R: R204.1 U31.13 U31.14
+3VALW_TPM: C421.1 C422.1 R688.2 U712.1
+3VALWP: PC305.2 PC306.1 PC307.1 PC308.1 PC309.1 PC310.1 PC311.1 PJP300.1 PL301.2 PR304.1
+3VS: C230.1 C640.1 C4180.1 CC17.1 CC77.2 F5.1 JDEBUG2.1 JDEBUG2.2 JIO1.20 PR1200.1 PR1202.1 R36.2 R37.2 R39.2 R40.2 R176.1 R200.1 R216.2 R220.1 R232.1 R530.1 R531.1 R638.2 R649.1 R666.1 R687.1 R704.1 R6157.2 RC222.2 RC223.2 RC244.2 RC338.1 RC339.1 RC433.1 RC631.1 RC655.2 RC656.2 RC665.1 RC666.1 RC667.1 RC668.1 RC717.1 RC741.1 RC742.1 RC743.1 RE1.2 RE93.2 RE237.1 RH39.1 RH40.1 RH41.1 RH621.2 RH631.1 RH655.2 RH713.1 RH727.1 RH733.2 RH738.2 RH739.2 RT12.2 RT35.2 RTCR2.2 UC29.5 UH6.5
+3VS_AUDIO: C277.1 R227.2 RA18.1 RA29.1 RA65.2
+3VS_AUDIO_R: R227.1 U51.7 U51.8
+3VS_CR: C800.1 C4217.1 CR7.1 CR8.1 CR20.1 CR23.1 R669.2 RR10.1 RR11.1 UCR1.11 UCR1.27
+3VS_CR_R: R669.1 UC31.1
+3VS_FP: C4183.1 C4186.1 F2.2 JFP1.8 QF2.2 R629.2
+3VS_FP_R: C2990.1 F2.1 R390.1 R638.1
+3VS_MID: F5.2 JUFC1.5 JUFC1.6 TP144.1(TP-1)
+3VS_R: R216.1 UC30.7 UC30.8
+3VS_SSD: C4230.1 CS89.1 CS90.1 CS91.1 CS92.1 CS93.1 JNGFF1.2 JNGFF1.4 JNGFF1.62 JNGFF1.64 JNGFF1.66 RS200.2 RS377.2
+3VS_SSD_R: RS200.1 US1.7 US1.8
+3VS_TPM: C94.1 C95.1 R200.2 U712.8
+3VS_TS: C223.1 C451.1 C452.1 F4.2 JEDP1.33 R238.2 R239.2 R245.2 R288.2 TP126.1(TP-1)
+3VS_TS_R: F4.1 U34.13 U34.14
+3VS_WLAN: C233.1 CW1.1 CW2.1 CW3.1 CW4.1 CW9.1 CW10.1 CW11.1 CW12.1 R222.2 R620.2 UWL1.4 UWL1.5 UWL1.72 UWL1.73 UWL1.A48 UWL1.A49
+3VS_WLAN_R: R222.1 R620.1 U34.8 U34.9
+5VALW: C246.1 C4204.1 C4231.1 PJP400.2 QC1.1 R720.1 R6207.1 RPD121.1 U36.1 U36.2 U36.4 UC12.3 UC13.3 UC24.4 UC25.4 UC27.3 UC28.1 UC28.2 UC28.4
+5VALW_L_TBT: CPD7.1 CPD8.1 RPD121.2 UPD1.1 UPD1.2 UPD1.25
+5VALWB: C4212.1 C4221.1 C4222.1 JDEBUG1.1 JDEBUG1.2 JIO1.2 JIO1.4 JIO1.6 JIO1.8 JIO1.10 JIO1.12 PJP401.2 RPD96.1 U31.4 U34.4 U60.1 U60.2 U60.4 U733.4 U734.4 U735.4 UC22.3 UC23.3 US1.4
+5VALWB_R_TBT: CPD17.1 CPD18.1 RPD96.2 UPD2.1 UPD2.2 UPD2.25
+5VALWBP: PC421.2 PC422.1 PC423.1 PC425.1 PC426.1 PC427.1 PC428.1 PJP401.1 PL403.2 PR416.1
+5VALWP: PC405.2 PC406.1 PC407.1 PC408.1 PC410.1 PC411.1 PC412.1 PJP400.1 PL401.2 PR404.1
+5VBS: C801.1 C1125.2 C4182.2 D470.1 LT10.1 R41.2 R670.2
+5VBS_FAN2: JFAN2.1 LT10.2
+5VBS_R: R670.1 U60.7 U60.8
+5VS: C1124.2 C4181.2 C4207.1 D469.1 LT9.1 R38.2 R6182.2
+5VS_AUDIO: C278.1 C625.1 C635.1 CA52.1 CA53.1 DA11.1 LA1.2 LA2.1 R612.2 R716.2
+5VS_AUDIO_R: R716.1 U36.7 U36.8
+5VS_FAN1: JFAN1.1 LT9.2
+5VS_R: R6182.1 UC28.7 UC28.8
+8.4V_BATT+: PC231.1 PC232.1 PQ202.1 PQ202.2 PQ202.3 PR211.4
+AVDD1: CA19.1 CA22.1 CA23.1 LA1.1 RA64.2 UA1.40
+DVDD: CA33.1 CA39.1 CA54.1 R636.1 RA13.2 RA29.2 RA36.2 RA57.1 UA1.3
+DVDD_MIC: C1540.1 F1.2 JUFC1.4 TP143.1(TP-1)
+DVDDIO: CA36.1 CA38.1 RA18.2 RA41.2 UA1.18
+PVDD: CA25.1 CA26.1 CA30.1 CA31.1 LA2.2 UA1.41 UA1.46
+V1.05A_BYPASS: RC595.2 UC1.DJ15
+V1.05A_MIPI60: R111.2 R114.1 R123.2 R270.2
+V1.05A_VREF_DEBUG: C1544.1 JMIPI60.1 R111.1
+V3.3A_1.8A_PCH_SPI: CC30.1 R261.1 RC582.2 RC583.2 RH141.2 RH635.2 RH643.2 UC1.DB34
+VBATT: PC102.1 PC234.1 PL100.2 PL101.2 PL102.2 PQ202.5 PR134.1 PR236.2
+VCC1.05_OUT_FET: CC629.1 CC638.1 R123.1 UC1.BY2 UC1.CB2 UC1.CC1 UC12.1 UC12.2 UC12.7 UC13.1 UC13.2 UC13.7
+VCC1.05_OUT_PCH: TP100.1(TP-1) UC1.DF29 UC1.DF31 UC1.DG29 UC1.DG31
+VCC1P05_OUTPUT_PLL: CC147.1 CC148.1 UC1.CD1 UC1.CD2
+VCC1P8A: CC129.1 CC188.1 CC308.1 CC668.1 RC718.2 UC1.BG9 UC1.BJ9 UC1.BM9 UC1.BW1 UC1.BW2
+VCC1P8A_R: RC351.2 RC718.1 UC22.6
+VCC1V8_TBT_L_LDO: CPD6.1 UPD1.35
+VCC1V8_TBT_R_LDO: CPD16.1 UPD2.35
+VCC3V3_TBT_L_LDO: CPD1.1 CPD4.1 JDB1.1 RPD11.1 RPD12.1 RPD13.1 RPD14.1 RPD90.1 RPD92.1 RPD129.2 RPD170.2 RPD183.2 RPD196.2 RPD197.2 RPD198.2 RT169.2 RTCD4.2 UPD1.9 UPD3.8
+VCC3V3_TBT_R_LDO: CPD11.1 CPD14.1 JDB2.1 RPD59.1 RPD60.1 RPD61.1 RPD62.1 RPD99.1 RPD102.1 RPD137.2 RPD168.2 RPD184.2 RPD201.2 RPD202.2 RPD203.2 RT170.2 RTCD5.2 UPD2.9 UPD4.8
+VCC_SFR_OC: CC144.1 CC145.1 CC189.1 CC721.1 RC643.2 UC1.CG38 UC1.CG41 UC1.CG42 UC1.CG49
+VCC_SFR_OC_R: RC643.1 UC27.6
+VCCA_CLKLDO_1P8: CC177.1 LC1.1 RC120.1 RC589.1 UC1.DW15
+VCCDPHY_1P24: CC184.1 UC1.DW32
+VCCDSW_1P05: CC183.1 UC1.DD34
+VCCIN: PC1300.1 PC1301.1 PC1302.1 PC1304.1 PC1305.1 PC1306.1 PC1307.1 PC1308.1 PC1309.1 PC1310.1 PC1311.1 PC1312.1 PC1313.1 PC1314.1 PC1315.1 PC1316.1 PC1317.1 PC1318.1 PC1319.1 PC1320.1 PC1321.1 PC1322.1 PC1323.1 PC1334.1 PC1335.1 PC1336.1 PC1337.1 PC1338.1 PC1339.1 PC1340.1 PC1341.1 PC1342.1 PC1343.1 PC1344.1 PC1345.1 PL1200.2 PL1201.2 PR1119.1 PR1300.1 UC1.A19 UC1.A21 UC1.A23 UC1.A24 UC1.A27 UC1.A29 UC1.AA12 UC1.AB1 UC1.AB13 UC1.AC12 UC1.B19 UC1.B23 UC1.B27 UC1.B29 UC1.BN10 UC1.BP9 UC1.BP11 UC1.BR10 UC1.BT9 UC1.BT11 UC1.BU10 UC1.BV9 UC1.BV36 UC1.BW9 UC1.BW10 UC1.BW36 UC1.BY10 UC1.C19 UC1.C23 UC1.C27 UC1.C29 UC1.CA9 UC1.CA36 UC1.CB10 UC1.CC9 UC1.CC11 UC1.CC36 UC1.CD10 UC1.CE11 UC1.CE34 UC1.CE35 UC1.CF10 UC1.CF33 UC1.CG11 UC1.CG34 UC1.CG35 UC1.CH10 UC1.CJ11 UC1.CJ34 UC1.CJ35 UC1.CK10 UC1.CL34 UC1.CL35 UC1.CN34 UC1.CN35 UC1.CP33 UC1.CR34 UC1.CR35 UC1.CT33 UC1.CT34 UC1.CT35 UC1.CU33 UC1.D19 UC1.D21 UC1.D23 UC1.D24 UC1.D27 UC1.D29 UC1.F19 UC1.F21 UC1.F23 UC1.F24 UC1.F27 UC1.F29 UC1.G1 UC1.G19 UC1.G23 UC1.G27 UC1.G29 UC1.H19 UC1.H23 UC1.H27 UC1.H29 UC1.J18 UC1.J20 UC1.J22 UC1.J23 UC1.J26 UC1.J28 UC1.J30 UC1.J32 UC1.K17 UC1.K19 UC1.K21 UC1.K23 UC1.K24 UC1.K27 UC1.K29 UC1.K31 UC1.M1 UC1.U1 UC1.V13 UC1.W12 UC1.Y13
+VCCIN_AUX: PC1000.1 PC1001.1 PC1002.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1030.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1035.1 PC1036.1 PC1037.1 PC1038.1 PC1039.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1055.1 PL900.2 PR903.1 UC1.AH1 UC1.AJ1 UC1.AL1 UC1.AM1 UC1.AN1 UC1.AT9 UC1.AT11 UC1.AU10 UC1.AV9 UC1.AW10 UC1.AY9 UC1.AY11 UC1.BA10 UC1.BB9 UC1.CH1 UC1.CK11 UC1.CL10 UC1.CM11 UC1.CN1 UC1.CN10 UC1.CP11 UC1.CR10 UC1.CT11 UC1.CU10 UC1.CV1 UC1.CV11 UC1.CW10 UC1.CY11 UC1.DC1 UC1.DC11 UC1.DE12 UC1.DF12 UC1.P13 UC1.R12 UC1.T13 UC1.U12
+VCCIO_OUT: QE15.1 R113.1 R178.1 R246.1 R274.1 R360.2 RC723.1 RC724.1 UC1.AD7
+VCCLDOSTD_OUT_0P85: CC185.1 CC260.1 UC1.DW37
+VCCPFUSE_3P3: RC747.2 UC1.DC33
+VCCPRIM_1P8: CC173.1 CC174.1 CC175.1 RC587.1 UC1.DD35 UC1.DF15 UC1.DF17 UC1.DF18 UC1.DF20 UC1.DF34 UC1.DG17 UC1.DG18 UC1.DG20
+VCCPRTC_3P3: CC181.1 CC182.1 RC696.1 UC1.DG33
+VCCST_CPU: CC153.1 CC154.1 CC666.1 RC592.1 RC630.2 UC1.CB1
+VCCST_R: RC630.1 UC13.6
+VCCSTG_CPU: CC155.1 CC156.1 CC667.1 RC639.2 UC1.BY1
+VCCSTG_OUT: CC191.1 UC1.AB34 UC1.F33 UC1.G33 UC1.R35 UC1.T34 UC1.U35 UC1.V34
+VCCSTG_OUT_LGC: RC659.1 UC1.E5
+VCCSTG_R: RC639.1 UC12.6
+VDDQ_MEM: CD23.1 CD24.1 CD25.1 CD26.1 CD27.1 CD28.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CD47.1 CD48.1 CD49.1 CD50.1 CD61.1 CD62.1 CD63.1 CD64.1 CD65.1 CD66.1 CD77.1 CD78.1 CD79.1 CD80.1 CD81.1 CD83.1 CD84.1 CD85.1 CD86.1 CD87.1 CD88.1 CD89.1 CD90.1 CD91.1 RD1.1 RD2.1 RD3.1 RD4.1 RD21.1 RD22.1 RD23.1 RD24.1 RD45.2 RD46.2 UD1.AA3 UD1.AA5 UD1.AA8 UD1.AA10 UD1.B3 UD1.B5 UD1.B8 UD1.B10 UD1.D1 UD1.D5 UD1.D8 UD1.D12 UD1.F3 UD1.F10 UD1.U3 UD1.U10 UD1.W1 UD1.W5 UD1.W8 UD1.W12 UD2.AA3 UD2.AA5 UD2.AA8 UD2.AA10 UD2.B3 UD2.B5 UD2.B8 UD2.B10 UD2.D1 UD2.D5 UD2.D8 UD2.D12 UD2.F3 UD2.F10 UD2.U3 UD2.U10 UD2.W1 UD2.W5 UD2.W8 UD2.W12 UD3.AA3 UD3.AA5 UD3.AA8 UD3.AA10 UD3.B3 UD3.B5 UD3.B8 UD3.B10 UD3.D1 UD3.D5 UD3.D8 UD3.D12 UD3.F3 UD3.F10 UD3.U3 UD3.U10 UD3.W1 UD3.W5 UD3.W8 UD3.W12 UD4.AA3 UD4.AA5 UD4.AA8 UD4.AA10 UD4.B3 UD4.B5 UD4.B8 UD4.B10 UD4.D1 UD4.D5 UD4.D8 UD4.D12 UD4.F3 UD4.F10 UD4.U3 UD4.U10 UD4.W1 UD4.W5 UD4.W8 UD4.W12
+VIN_3V3_L_TBT: CPD5.1 RPD84.2 RPD114.2 UPD1.5
+VIN_3V3_R_TBT: CP10.1 RPD93.2 RPD115.2 UPD2.5
+VSS_PLL: CE47.2 CE48.2 UE1.G1
AGND: CA9.2 CA11.2 CA15.2 CA17.1 CA18.2 CA19.2 CA20.1 CA22.2 CA23.2 CA24.2 CA29.2 CA51.2 CA58.2 CA59.2 CA60.2 CA61.2 CA62.2 CA63.2 CA78.2 CA79.2 CA80.2 CA81.2 CA82.2 CA83.2 CA84.2 CA85.2 JHP1.6 RA10.1 RA22.2 RA23.2 RA25.2 UA1.22 UA1.37
DV12S: CR5.1 CR6.1 CR9.2 UCR1.10 UCR1.14
DV33_18: CR15.1 UCR1.18

# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_D_CA4: length 39
  IN1 w0.099: v1(118.42,59.26) 118.42,59.55 119.06,60.19 119.06,62.09 v2(119.06,62.09) 119.3,62.33 119.3,62.73 118.97,63.05 118.97,64 118.77,64.2 118.54,64.2 118.42,64.08 v1(118.42,63.81) ; v1(133.8,42.31) v2(134.27,42.57)
  IN3 w0.099: v2(119.06,62.09) 119.44,62.09 119.53,62.18 119.53,62.67 119.6,62.74 120,62.74 120.11,62.63 120.11,60.57 120.83,59.85 120.83,58.05 124.32,54.57 124.32,53.78 126.28,51.83 130.01,51.83 134.35,47.49 134.35,47.16 134.62,46.89 134.62,46.05 135.68,44.99 135.68,42.36 135.46,42.14 134.7,42.14 v2(134.27,42.57)
DDR_D_CA5: length 36.5
  IN1 w0.081: v1(134.27,47.29) 134.16,47.29 v2(133.99,47.12)
  IN1 w0.099: v1(118.42,59.91) 118.09,60.24 118.09,60.89 v2(118.61,61.41) 118.4,61.62 118.4,63.14 v1(118.42,63.16)
  IN3 w0.099: v2(118.61,61.41) 118.61,61.66 118.71,61.76 118.97,61.76 119.07,61.66 119.07,61.17 119.17,61.07 119.37,61.07 119.47,61.17 119.47,61.66 119.57,61.76 119.72,61.76 119.86,61.62 119.86,60.04 119.96,59.94 120.38,59.94 120.48,59.84 120.48,59.64 120.38,59.54 119.65,59.54 119.53,59.43 119.53,59.24 119.63,59.14 120.38,59.14 120.48,59.05 120.48,58.85 120.38,58.75 120.02,58.75 119.93,58.65 119.93,57.86 120.61,57.17 120.75,57.17 120.97,57.38 121.11,57.38 121.25,57.24 121.25,57.1 121.03,56.89 121.03,56.75 121.17,56.61 121.31,56.61 121.53,56.82 121.67,56.82 121.81,56.68 121.81,56.54 121.59,56.33 121.59,56.19 121.73,56.05 121.87,56.05 122.09,56.26 122.23,56.26 122.37,56.12 122.37,55.98 122.15,55.77 122.15,55.63 122.29,55.49 122.43,55.49 122.65,55.7 122.79,55.7 122.93,55.56 122.93,55.42 122.72,55.21 122.72,55.07 122.86,54.93 123,54.93 123.21,55.14 123.35,55.14 123.49,55 123.49,54.86 123.28,54.65 123.28,54.5 123.42,54.36 123.56,54.36 123.77,54.58 123.91,54.58 124.05,54.44 124.05,54.3 123.84,54.08 123.84,53.94 123.87,53.91 123.87,53.88 126.17,51.57 129.91,51.57 133.99,47.49 v2(133.99,47.12)
DDR_D_CKE0: length 39.2
  IN1 w0.099: v1(131.97,43.61) v2(131.6,43.24) ; v1(112.82,59.91) 112.82,60.49 112.87,60.54 113.05,60.54 113.1,60.49 113.1,60.13 113.22,60.01 113.35,60.01 113.43,60.09 113.43,60.59 113.67,60.83 113.87,60.83 v2(113.93,60.89) 113.98,60.95 113.98,62.06 112.88,63.16 v1(112.82,63.16)
  IN3 w0.099: v2(131.6,43.24) 131.23,43.61 131.23,45.1 131.38,45.26 131.38,45.65 131.11,45.92 131.11,46.31 129.4,48.02 127,48.02 126.17,48.85 122.37,48.85 117.63,53.59 116.66,53.59 116.14,54.11 116.14,54.42 114.71,55.84 114.71,56.56 114.63,56.65 114.63,56.82 114.81,57.01 114.81,57.15 114.67,57.29 114.53,57.29 114.26,57.02 113.77,57.02 113.63,57.16 113.63,57.3 113.63,58.06 113.53,58.16 113.12,58.16 113.02,58.26 113.02,58.46 113.12,58.55 113.53,58.55 113.63,58.65 113.63,59.59 113.73,59.69 114.21,59.69 114.31,59.79 114.31,59.99 114.21,60.09 113.61,60.09 113.52,60.18 113.52,60.42 113.6,60.5 113.86,60.5 113.93,60.56 v2(113.93,60.89)
DDR_D_CKE1: length 41.5
  IN1 w0.081: v1(132.89,44.91) 132.47,44.91 v2(132.43,44.95)
  IN1 w0.099: v1(113.62,59.91) 114.39,60.67 114.39,61.9 v2(114.74,62.26) 115.08,62.6 115.08,63.21 114.81,63.48 113.94,63.48 v1(113.62,63.16)
  IN3 w0.099: v2(114.74,62.26) 114.92,62.44 115.92,62.44 116.54,61.82 116.54,60.67 116.2,60.32 116.06,60.32 115.66,60.72 115.52,60.72 115.38,60.58 115.38,60.44 115.78,60.04 115.78,59.9 115.64,59.76 115.5,59.76 115.36,59.9 115.22,59.9 115.08,59.76 115.08,59.62 115.22,59.48 115.22,59.34 115.05,59.17 115.05,57.97 115.33,57.69 115.43,57.69 115.54,57.81 115.68,57.81 115.82,57.67 115.82,57.53 115.67,57.37 115.67,57.23 116.12,56.78 116.12,55.8 116.2,55.72 116.34,55.72 116.58,55.96 116.71,55.96 116.89,55.78 116.89,55.64 116.67,55.41 116.67,55.27 116.94,55 117.94,55 122.88,50.07 126.68,50.07 127.51,49.24 127.75,49.24 127.84,49.34 127.84,49.84 127.94,49.93 128.14,49.93 128.24,49.84 128.24,49.34 128.34,49.24 130.01,49.24 132.15,47.1 132.15,45.87 132.43,45.59 v2(132.43,44.95)
DDR_D_CLK: length 34.7
  IN1 w0.089: v1(116.02,59.91) 116.24,59.91 116.33,60 116.33,60.11 115.66,60.78 115.66,61.3 v2(115.44,61.53) 115.64,61.73 115.64,62.18 116.34,62.88 116.34,63.08 116.25,63.16 v1(116.02,63.16)
  IN1 w0.102: v1(131.97,44.26) v2(131.67,44.41)
  IN3 w0.102: v2(131.67,44.41) 132.06,44.8 132.06,45.32 131.82,45.55 131.82,46.61 129.7,48.73 127.29,48.73 126.47,49.56 122.67,49.56 117.51,54.71 116.85,54.71 115.4,56.16 115.4,57.23 114.79,57.84 114.79,61.39 115.35,61.95 115.57,61.95 115.62,61.89 115.62,61.72 v2(115.44,61.53)
DDR_D_CLK#: length 34.6
  IN1 w0.081: v1(131.97,44.91) v2(131.67,45.05)
  IN1 w0.089: v1(116.82,63.16) 116.6,63.16 116.52,63.08 116.52,62.8 115.82,62.1 115.82,61.74 v2(116.04,61.53) 115.85,61.34 115.85,60.85 116.51,60.19 116.51,60 116.6,59.91 v1(116.82,59.91)
  IN3 w0.102: v2(131.67,45.05) 131.73,45.05 131.81,45.13 131.81,45.28 131.62,45.47 131.62,46.52 129.62,48.53 127.21,48.53 126.38,49.36 122.58,49.36 117.43,54.51 116.77,54.51 115.2,56.08 115.2,57.15 114.59,57.76 114.59,61.47 115.27,62.15 115.65,62.15 115.83,61.98 115.83,61.74 v2(116.04,61.53)
DDR_D_CS#0: length 42.5
  IN1 w0.099: v1(112.82,59.26) 112.79,59.29 112.31,59.29 112.26,59.35 112.26,59.94 112.58,60.26 112.58,61.05 112.76,61.23 112.87,61.23 112.96,61.14 112.96,61.02 113.05,60.93 v2(113.2,60.93) 113.2,62.48 112.86,62.83 112.8,62.83 112.54,63.08 112.54,63.59 112.76,63.81 v1(112.82,63.81) ; v1(135.63,42.96) v2(135.31,43.15)
  IN3 w0.099: v2(113.2,60.93) 112.77,60.49 112.77,57.58 113.57,56.78 114.2,56.78 114.38,56.59 114.38,55.81 115.86,54.34 115.86,54.01 117.6,52.27 118.59,52.27 122.27,48.6 126.07,48.6 126.89,47.77 129.3,47.77 130.86,46.21 130.86,45.9 130.72,45.75 130.72,44.92 130.98,44.65 130.98,43.2 131.35,42.84 131.67,42.84 132.24,42.26 133.68,42.26 133.83,42.41 133.83,42.79 133.97,42.93 135.1,42.93 v2(135.31,43.15)
DDR_D_CS#1: length 41
  IN1 w0.099: v1(133.8,42.96) v2(133.35,43.22) ; v1(112.02,63.81) 112.21,63.81 112.29,63.73 112.29,62.97 112.57,62.7 112.57,62.27 112.72,62.11 112.72,61.84 v2(112.54,61.66) 112.54,61.34 112.34,61.14 112.34,60.37 112.02,60.06 112.02,59.26 v1(112.02,59.26)
  IN3 w0.099: v2(112.54,61.66) 112.73,61.66 113.96,62.9 115.03,62.9 115.25,62.68 116.04,62.68 116.78,61.94 116.78,60.5 115.93,59.65 115.93,57.94 116.65,57.22 116.65,56.87 117.65,55.87 117.65,55.65 122.98,50.32 129.39,50.32 132.41,47.29 132.41,46.04 132.92,45.53 132.92,43.56 133.27,43.22 v2(133.35,43.22)
DDR_D_D0_0: length 29.7
  TOP w0.089: v1(130.06,47.4) 130.18,47.29 UC1.J48
  IN1 w0.099: v1(130.06,47.4) 130.02,47.44 129.69,47.44 129.12,48.01 129.01,48.01 128.65,48.37 127.93,48.37 127.5,47.94 126.6,47.94 126.37,48.18 125.68,48.18 125.32,48.54 124.26,48.54 121.51,51.29 121.51,57.47 122.08,58.04 122.08,58.78 121.84,59.02 121.84,65.74 120.82,66.77 119.03,66.77 118.74,67.06 v1(118.42,67.06)
DDR_D_D0_1: length 34.5
  IN1 w0.099: v1(130.41,45.98) 130.42,45.99 130.42,46.25 130.66,46.5 130.66,46.93 130.57,47.02 130.57,47.89 129.94,48.53 129.65,48.53 129.47,48.71 129.29,48.71 128.96,49.04 127.58,49.04 127.18,48.65 126.96,48.65 126.68,48.93 125.99,48.93 125.63,49.3 124.57,49.3 122.26,51.6 122.26,57.15 122.84,57.73 122.84,59.11 122.6,59.34 122.6,66.19 121.91,66.88 121.91,67.62 121.88,67.64 121.88,67.67 121.18,68.38 118.02,68.38 117.71,68.07 117.18,68.07 v1(116.82,67.71)
DDR_D_D0_2: length 30.1
  TOP w0.089: v1(129.77,47.99) 129.83,47.94 UC1.J49
  IN1 w0.099: v1(118.42,67.71) 120.94,67.71 121.41,67.25 121.41,66.67 122.1,65.98 122.1,59.13 122.33,58.9 122.33,57.93 121.76,57.36 121.76,51.4 124.36,48.79 125.42,48.79 125.78,48.43 126.47,48.43 126.73,48.17 127.41,48.17 127.83,48.59 128.76,48.59 129.11,48.24 129.24,48.24 129.49,47.99 v1(129.77,47.99)
DDR_D_D0_3: length 29
  TOP w0.089: UC1.G47 v1(128.87,46.33)
  TOP w0.102: UD4.E9 v1(117.26,65.32)
  IN1 w0.099: v1(128.87,46.33) 128.86,46.32 128.86,46.29 128.55,45.98 128.28,45.98 128.05,46.21 123.8,46.21 119.54,50.47 119.54,55.6 119.16,55.98 119.16,58.84 119.54,59.22 119.54,63.98 119.31,64.21 119.12,64.21 118.85,64.48 118.09,64.48 117.26,65.31 v1(117.26,65.32)
DDR_D_D0_4: length 33.7
  IN1 w0.099: v1(116.82,67.06) 116.82,67.26 116.97,67.41 117.52,67.41 117.79,67.68 117.79,67.8 118.04,68.06 121.11,68.06 121.66,67.51 121.66,66.78 122.35,66.09 122.35,59.24 122.58,59 122.58,57.83 122.01,57.26 122.01,51.5 124.47,49.04 125.53,49.04 125.89,48.68 126.57,48.68 126.86,48.4 127.29,48.4 127.71,48.82 128.85,48.82 129.19,48.47 129.37,48.47 129.55,48.29 129.85,48.29 130.34,47.8 130.34,46.7 v1(130.41,46.63)
DDR_D_D0_5: length 28.6
  IN1 w0.081: 127.9,47.44 128.2,47.75 128.39,47.75 128.75,47.39 128.87,47.39 129.01,47.24 129.01,47.04 128.98,47 128.98,46.75 129.14,46.58 v1(129.14,45.98)
  IN1 w0.099: v1(118.42,65.76) 118.49,65.76 119.03,65.22 119.53,65.22 120.29,64.46 120.29,58.65 119.92,58.27 119.92,56.29 120.29,55.91 120.29,50.79 124.12,46.96 127.5,46.96 127.9,47.36 127.9,47.44
DDR_D_D0_6: length 27
  TOP w0.089: UC1.G48 v1(128.77,47.14)
  IN1 w0.099: v1(118.42,65.11) 118.81,64.72 119.32,64.72 119.79,64.25 119.79,59.11 119.41,58.74 119.41,56.08 119.79,55.7 119.79,50.58 123.91,46.46 127.76,46.46 128.44,47.14 v1(128.77,47.14)
DDR_D_D0_7: length 28.4
  IN1 w0.099: v1(116.82,65.11) 116.82,65.33 117.07,65.58 117.41,65.58 117.81,65.18 118.11,65.18 118.29,65.37 118.55,65.37 118.95,64.97 119.43,64.97 120.04,64.35 120.04,58.96 119.67,58.59 119.67,56.18 120.04,55.81 120.04,50.68 124.01,46.71 127.57,46.71 128.3,47.44 v1(128.3,47.49)
DDR_D_D1_0: length 44.9
  IN1 w0.081: v2(113.19,65.1) 113.18,65.11 v1(112.82,65.11)
  IN1 w0.099: v1(130.14,42.31) v2(130.61,42.59)
  IN3 w0.099: v2(130.61,42.59) 130.61,42.49 130.49,42.38 130.35,42.38 130.28,42.45 130.28,44.63 130.48,44.83 130.48,45.72 129.04,47.17 122.84,47.17 118.34,51.66 117.35,51.66 114.91,54.1 114.91,54.89 113.49,56.31 113.35,56.31 112.3,57.35 112.3,57.79 111.29,58.8 111.29,59.84 109.65,61.48 109.65,62.63 111.53,64.51 113.47,64.51 113.57,64.42 115.72,64.42 115.88,64.58 115.88,65.02 115.75,65.15 114.47,65.15 114.41,65.1 v2(113.19,65.1)
DDR_D_D1_1: length 48
  IN1 w0.081: v1(112.82,67.06) v2(112.51,67.2)
  IN1 w0.099: v2(128.78,42.59) 129.1,42.86 v1(129.23,42.96)
  IN3 w0.099: v2(128.78,42.59) 128.56,42.37 116,42.37 108.5,49.87 108.5,55.39 107.92,55.96 107.92,58.14 107.16,58.9 107.16,65.25 107.61,65.69 107.61,65.83 108.17,66.39 108.17,67.23 109,68.06 110.77,68.06 111.22,67.6 111.65,67.6 111.81,67.75 112.16,67.75 112.49,67.42 112.49,67.22 v2(112.51,67.2)
DDR_D_D1_2: length 49.6
  IN1 w0.081: v1(112.82,67.71) v2(113.26,68.03)
  IN1 w0.099: v2(128.78,41.85) v1(129.23,42.31)
  IN3 w0.099: v2(128.78,41.85) 128.54,42.09 115.88,42.09 108.24,49.72 108.24,55.29 107.67,55.86 107.67,58.04 106.91,58.8 106.91,65.35 107.36,65.8 107.36,65.93 107.92,66.5 107.92,67.33 108.94,68.36 112.39,68.36 112.52,68.49 112.83,68.49 113.26,68.07 v2(113.26,68.03)
DDR_D_D1_3: length 45.5
  IN1 w0.081: v1(111.22,67.71) 111.2,67.73 v2(110.39,67.73)
  IN1 w0.099: v1(129.23,44.26) v2(128.78,44.45)
  IN3 w0.099: v2(110.39,67.73) 109.02,67.73 108.43,67.13 108.43,66.3 107.86,65.72 107.86,65.59 107.41,65.15 107.41,59.01 108.18,58.25 108.18,56.07 108.75,55.49 108.75,49.97 116.1,42.62 125.43,42.62 127.03,44.22 128.55,44.22 v2(128.78,44.45)
DDR_D_D1_4: length 45.2
  IN1 w0.081: v1(112.82,65.76) v2(113.26,66.25)
  IN1 w0.099: v1(130.14,42.96) v2(129.69,42.59)
  IN3 w0.099: v2(129.69,42.59) 129.28,42.17 129.28,41.22 129.39,41.11 129.97,41.11 130.05,41.19 130.05,44.75 130.26,44.96 130.26,45.59 128.93,46.91 122.74,46.91 118.24,51.41 117.24,51.41 114.66,53.99 114.66,54.8 113.42,56.03 113.3,56.03 112.07,57.26 112.07,57.69 111.06,58.71 111.06,59.66 110.56,60.15 109.72,60.15 109.4,60.48 109.4,62.73 111.25,64.58 111.25,65.06 111.41,65.23 112.07,65.23 112.24,65.05 112.64,65.05 112.85,65.27 112.85,66.32 112.95,66.41 113.16,66.41 113.26,66.32 v2(113.26,66.25)
DDR_D_D1_5: length 45
  IN1 w0.081: v2(110.8,65) 110.91,65.11 v1(111.22,65.11)
  IN1 w0.099: v1(130.14,44.26) v2(129.69,44.45)
  IN3 w0.099: v2(129.69,44.45) 129.69,44.75 130.03,45.09 130.03,45.43 128.79,46.66 126.55,46.66 122.63,46.66 118.13,51.16 117.14,51.16 116.93,51.37 116.79,51.37 116.37,50.94 116.23,50.94 116.09,51.08 116.09,51.23 116.51,51.65 116.51,51.79 116.37,51.93 116.23,51.93 115.81,51.51 115.67,51.51 115.53,51.65 115.53,51.79 115.95,52.21 115.95,52.35 115.81,52.49 115.67,52.49 115.25,52.07 115.11,52.07 114.97,52.21 114.97,52.35 115.39,52.77 115.39,52.91 114.69,53.61 114.55,53.61 114.13,53.19 113.99,53.19 113.85,53.33 113.85,53.47 114.27,53.89 114.27,54.03 114.14,54.16 114.14,54.3 114.37,54.52 114.37,54.66 114.23,54.8 114.09,54.8 113.86,54.58 113.72,54.58 113.58,54.72 113.58,54.86 113.81,55.09 113.81,55.23 113.67,55.37 113.53,55.37 113.34,55.18 112.41,55.18 112.12,55.46 112.12,56.84 111.87,57.1 111.02,57.1 110.91,57.21 110.91,58.16 111.01,58.26 111.01,58.4 110.87,58.54 110.73,58.54 110.63,58.44 110.49,58.44 110.35,58.58 110.35,58.77 110.73,59.15 110.73,59.29 110.59,59.43 110.45,59.43 110.04,59.02 109.9,59.02 109.15,59.78 109.15,63.52 109.63,64 110.61,64.98 110.79,64.98 v2(110.8,65)
DDR_D_D1_6: length 45.5
  IN1 w0.099: v1(111.22,67.06) v2(111.53,67.2) ; v1(129.23,44.91) v2(128.78,45.19)
  IN3 w0.099: v2(128.78,45.19) 128.75,45.16 128.75,45.01 128.41,44.67 123.38,44.67 121.58,42.87 116.2,42.87 109,50.07 109,55.6 108.43,56.17 108.43,58.35 107.67,59.11 107.67,65.04 108.11,65.49 108.11,65.62 108.68,66.19 108.68,66.58 108.94,66.84 109.48,66.84 109.89,67.24 110.42,67.24 110.67,67 111.33,67 v2(111.53,67.2)
DDR_D_D1_7: length 45.5
  IN1 w0.081: v1(130.14,44.91) v2(129.69,45.3)
  IN1 w0.099: v1(111.22,65.76) 110.86,66.02 v2(110.84,66.01)
  IN3 w0.099: v2(110.84,66.01) 110.74,66.01 110.12,65.39 110.12,64.87 109.69,64.44 109.55,64.44 109.38,64.62 109.24,64.62 109.11,64.49 109.11,64.33 109.27,64.16 109.27,64.02 108.9,63.65 108.9,59.66 110.39,58.16 110.39,57.06 110.72,56.73 111.73,56.73 111.83,56.63 111.83,56.43 111.73,56.33 111.24,56.33 111.11,56.21 111.11,55.28 111.21,55.18 111.88,55.18 111.98,55.08 111.98,54.89 111.88,54.79 111.21,54.79 111.11,54.69 111.11,53.92 111.21,53.82 112.93,53.82 114.04,52.71 114.04,52.57 113.54,52.07 113.54,51.93 113.68,51.79 113.82,51.79 114.32,52.29 114.46,52.29 114.6,52.15 114.6,52.01 114.1,51.51 114.1,51.37 114.24,51.23 114.38,51.23 114.88,51.73 115.02,51.73 115.16,51.59 115.16,51.45 114.66,50.95 114.66,50.81 114.8,50.67 114.94,50.67 115.44,51.17 115.58,51.17 116.44,50.32 118.49,50.32 122.64,46.16 127.87,46.16 128.06,45.97 129.08,45.97 129.69,45.36 v2(129.69,45.3)
DDR_D_D2_0: length 24.7
  IN1 w0.081: 117.09,55.44 116.89,55.64 116.89,55.95 v1(116.82,56.01)
  IN1 w0.099: 117.09,55.44 117.09,54.41 117.23,54.27 117.23,51.74 117.33,51.64 117.74,51.64 117.84,51.54 117.84,49.65 118.02,49.47 119.33,49.47 120.88,47.92 120.88,45.47 121,45.35 121.2,45.35 121.3,45.45 121.3,47.11 121.4,47.21 121.59,47.21 121.69,47.11 121.69,45.45 121.79,45.35 121.99,45.35 122.09,45.45 122.09,46.31 122.19,46.41 122.39,46.41 122.49,46.31 122.49,45.45 122.58,45.35 125.82,45.35 126.39,44.78 v1(126.69,44.78)
DDR_D_D2_1: length 25.6
  IN1 w0.099: v1(127.99,44.78) 127.94,44.82 127.94,44.98 127.85,45.08 127.68,45.08 127.58,45.17 127.58,45.37 127.68,45.47 128.06,45.47 128.16,45.57 128.16,45.76 128.06,45.86 123.66,45.86 119.19,50.33 119.19,51.2 119.09,51.3 118.44,51.3 118.34,51.4 118.34,51.6 118.44,51.7 119.09,51.7 119.19,51.8 119.19,52 119.09,52.1 118.44,52.1 118.34,52.2 118.34,52.39 118.44,52.49 119.09,52.49 119.19,52.59 119.19,52.79 119.09,52.89 118.44,52.89 118.34,52.99 118.34,53.19 118.44,53.29 119.09,53.29 119.19,53.39 119.19,53.58 119.09,53.68 118.44,53.68 118.34,53.78 118.34,53.98 118.44,54.08 119.09,54.08 119.19,54.18 119.19,54.38 119.09,54.47 118.44,54.47 118.34,54.57 118.34,54.77 118.44,54.87 119.09,54.87 119.19,54.97 119.19,55.24 119.07,55.36 v1(118.42,55.36)
DDR_D_D2_2: length 26.4
  IN1 w0.099: v1(116.82,55.36) 116.82,55.09 116.39,54.66 116.39,53.49 116.49,53.39 116.88,53.39 116.98,53.29 116.98,53.09 116.88,52.99 116.49,52.99 116.39,52.89 116.39,52.7 116.49,52.6 116.88,52.6 116.98,52.5 116.98,52.3 116.88,52.2 116.49,52.2 116.39,52.1 116.39,51.9 116.49,51.81 116.88,51.81 116.98,51.71 116.98,51.51 116.88,51.41 116.49,51.41 116.39,51.31 116.39,51.11 116.49,51.01 117.49,51.01 117.59,50.91 117.59,50.72 117.49,50.62 116.49,50.62 116.39,50.52 116.39,50.32 116.49,50.22 117.49,50.22 117.59,50.12 117.59,49.92 117.49,49.82 116.49,49.82 116.39,49.73 116.39,49.32 116.49,49.22 119.22,49.22 120.63,47.81 120.63,45.2 120.73,45.1 125.71,45.1 v1(126.04,44.78)
DDR_D_D2_3: length 30.4
  IN1 w0.099: v1(118.42,57.31) 117.63,58.1 117.39,58.1 117.35,58.14 117.34,58.14 117.25,58.23 116.45,58.23 114.68,56.45 114.68,56.07 114.4,55.79 114.4,53.38 114.03,53.01 114.03,45.67 116.57,43.13 122.71,43.13 122.72,43.12 125.32,43.12 125.45,43.24 125.81,43.24 125.85,43.2 126.81,43.2 126.98,43.37 127.25,43.37 v1(127.34,43.45)
DDR_D_D2_4: length 25.2
  IN1 w0.099: v1(118.42,56.01) 117.78,56.01 117.69,55.91 117.69,55.66 117.78,55.56 117.88,55.56 117.98,55.46 117.98,55.2 117.88,55.1 117.47,55.1 117.37,55 117.37,54.5 117.47,54.4 117.99,54.4 118.09,54.3 118.09,54.11 117.99,54.01 117.58,54.01 117.48,53.91 117.48,53.71 117.58,53.61 117.99,53.61 118.09,53.51 118.09,53.31 117.99,53.21 117.58,53.21 117.48,53.12 117.48,52.92 117.58,52.82 117.99,52.82 118.09,52.72 118.09,52.52 117.99,52.42 117.58,52.42 117.48,52.32 117.48,52.12 117.58,52.03 117.99,52.03 118.09,51.93 118.09,51.15 118.19,51.05 118.84,51.05 118.93,50.95 118.93,50.75 118.84,50.65 118.19,50.65 118.09,50.56 118.09,49.85 118.22,49.73 119.43,49.73 123.55,45.6 126.41,45.6 126.51,45.51 126.51,45.14 126.61,45.05 126.81,45.05 126.91,45.14 126.91,45.51 127.01,45.6 127.24,45.6 127.34,45.51 v1(127.34,44.78)
DDR_D_D2_5: length 31.9
  IN1 w0.099: v1(118.42,57.96) 118.13,57.96 117.76,58.33 117.52,58.33 117.39,58.46 116.26,58.46 114.42,56.62 114.42,56.24 114.14,55.96 114.14,53.48 113.78,53.11 113.78,45.56 116.47,42.87 122.61,42.87 122.61,42.87 125.4,42.87 125.55,43.01 127.25,43.01 127.59,43.34 127.88,43.34 v1(127.99,43.45)
DDR_D_D2_6: length 26.4
  IN1 w0.099: v1(126.69,43.45) 126.69,43.69 126.33,44.04 125.38,44.04 124.96,43.62 122.93,43.62 122.92,43.63 116.87,43.63 114.53,45.96 114.53,51.66 115.13,52.25 115.13,53.56 115.04,53.64 115.04,55.77 115.18,55.9 115.18,56.24 115.68,56.74 116.25,56.74 v1(116.82,57.31)
DDR_D_D2_7: length 26.4
  IN1 w0.099: v1(116.82,57.96) 116.49,57.63 116.49,57.39 116.12,57.02 115.58,57.02 114.93,56.36 114.93,55.98 114.79,55.84 114.79,53.48 114.88,53.39 114.88,52.37 114.28,51.78 114.28,45.86 116.76,43.38 122.82,43.38 122.82,43.37 125.22,43.37 125.32,43.47 126.02,43.47 v1(126.04,43.45)
DDR_D_D3_0: length 33
  IN1 w0.099: v1(111.21,57.92) 110.87,57.58 110.16,57.58 109.64,57.06 109.64,52.8 109.89,52.55 109.89,50.31 110.76,49.44 110.76,44.31 114.86,40.22 126.04,40.22 v1(126.69,40.87)
DDR_D_D3_1: length 39
  IN1 w0.076: v1(112.82,57.96) 112.71,57.96 112.37,58.3 111.54,58.3 111.45,58.39 110.9,58.39 110.88,58.37
  IN1 w0.081: 110.88,58.37 110.59,58.08
  IN1 w0.099: v1(127.99,40.87) 127.87,40.87 126.72,39.71 114.65,39.71 110.26,44.11 110.26,47.48 108.3,49.44 108.3,57 108.78,57.48 109.32,57.48 109.92,58.08 110.59,58.08
DDR_D_D3_2: length 30.9
  IN1 w0.099: v1(126.04,40.87) 125.64,40.47 114.97,40.47 111.01,44.43 111.01,49.55 110.14,50.42 110.14,52.73 109.93,52.94 109.93,52.96 109.89,53 109.89,55.98 110.15,56.23 110.35,56.23 110.9,56.79 110.9,56.99 v1(111.22,57.31)
DDR_D_D3_3: length 32.7
  IN1 w0.099: v1(127.99,42.15) 128.05,42.09 128.35,42.09 128.45,42.18 128.45,43.13 128.34,43.23 128.11,43.23 128.01,43.13 128.01,42.7 127.8,42.49 127.49,42.49 127.15,42.82 125.7,42.82 125.49,42.62 124.45,42.62 124.35,42.51 116.33,42.51 116.18,42.66 116.04,42.66 115.9,42.52 115.76,42.52 115.62,42.67 115.62,42.81 115.76,42.94 115.76,43.08 115.62,43.22 115.48,43.22 115.34,43.09 115.2,43.09 115.06,43.23 115.06,43.37 115.2,43.5 115.2,43.64 115.06,43.78 114.92,43.78 114.78,43.65 114.64,43.65 114.5,43.79 114.5,43.93 114.64,44.06 114.64,44.2 114.54,44.31 114.4,44.31 114.26,44.17 114.12,44.17 113.98,44.31 113.98,44.45 114.12,44.59 114.12,44.73 113.42,45.42 113.42,51.82 113.32,51.92 113.17,51.92 113.08,52.01 113.08,52.21 113.17,52.31 113.32,52.31 113.42,52.41 113.42,53.8 113.52,53.9 113.69,53.9 113.79,54 113.79,54.24 113.67,54.35 113.52,54.35 113.25,54.63 113.25,54.72 113.32,54.79 113.32,54.93 113.18,55.08 113.04,55.08 112.91,54.94 112.78,54.94 112.58,55.13 112.58,55.29 112.67,55.38 112.8,55.38 v1(112.82,55.36)
DDR_D_D3_4: length 37.8
  IN1 w0.076: 110.95,58.11 111.03,58.19 111.34,58.19 111.43,58.09 112.28,58.09 112.82,57.55 v1(112.82,57.31)
  IN1 w0.081: 110.67,57.83 110.95,58.11
  IN1 w0.099: v1(127.34,40.87) 126.43,39.96 114.75,39.96 110.51,44.21 110.51,47.61 108.56,49.56 108.56,56.9 108.89,57.23 109.42,57.23 110.03,57.83 110.67,57.83
DDR_D_D3_5: length 31.9
  IN1 w0.099: v1(127.34,42.15) 127.38,42.19 127.38,42.33 127.07,42.64 125.84,42.64 125.57,42.36 124.54,42.36 124.44,42.26 115.67,42.26 113.6,44.33 113.6,44.47 113.72,44.58 113.72,44.76 113.59,44.89 113.27,44.89 113.17,44.99 113.17,51.56 113.11,51.62 112.78,51.62 112.46,51.95 112.46,52.95 112.57,53.06 113.06,53.06 113.15,53.15 113.15,53.39 113.08,53.46 112.29,53.46 112.19,53.56 112.19,53.74 112.3,53.86 113.1,53.86 113.23,53.99 113.23,54.29 112.85,54.67 112.49,54.67 112.4,54.77 112.4,54.98 112.34,55.04 112.1,55.04 112.02,55.12 112.02,55.64 112.21,55.83 112.38,55.83 112.56,55.65 112.77,55.65 112.91,55.78 112.91,55.92 v1(112.82,56.01)
DDR_D_D3_6: length 31.1
  IN1 w0.099: v1(111.22,55.36) 111.41,55.36 111.67,55.1 111.67,53.82 111.77,53.72 111.83,53.72 111.93,53.62 111.93,53.43 111.83,53.33 111.77,53.33 111.67,53.23 111.67,53.03 111.77,52.93 112.11,52.93 112.21,52.83 112.21,52.63 112.11,52.53 111.97,52.53 111.87,52.43 111.87,51.44 112.22,51.1 112.36,51.1 112.63,51.37 112.79,51.37 112.92,51.24 112.92,51.1 112.64,50.81 112.64,50.67 112.92,50.39 112.92,47.5 112.82,47.41 112.6,47.41 112.5,47.31 112.5,47.11 112.6,47.01 112.82,47.01 112.92,46.91 112.92,46.71 112.82,46.61 112.6,46.61 112.5,46.51 112.5,46.32 112.6,46.22 112.82,46.22 112.92,46.12 112.92,45.92 112.82,45.82 112.6,45.82 112.5,45.72 112.5,45.52 112.6,45.42 112.82,45.42 112.92,45.32 112.92,44.65 115.56,42.01 124.56,42.01 124.66,42.11 125.64,42.11 125.96,42.43 126.99,42.43 127.05,42.37 127.05,42.21 126.99,42.15 v1(126.69,42.15)
DDR_D_D3_7: length 32.1
  IN1 w0.099: v1(126.04,42.15) 126.33,42.15 126.48,42 126.48,41.72 126.4,41.63 126.12,41.63 126.05,41.7 126.05,41.78 125.94,41.89 125.75,41.89 125.65,41.79 125.65,41.68 125.55,41.58 125.43,41.58 125.14,41.86 124.84,41.86 124.66,41.68 115.47,41.68 112.23,44.93 112.23,47.7 112.33,47.8 112.57,47.8 112.67,47.9 112.67,48.1 112.57,48.2 112.33,48.2 112.23,48.3 112.23,48.49 112.33,48.59 112.57,48.59 112.67,48.69 112.67,48.89 112.57,48.99 112.33,48.99 112.23,49.09 112.23,49.28 112.33,49.38 112.57,49.38 112.67,49.48 112.67,49.68 112.57,49.78 112.33,49.78 112.23,49.88 112.23,50.05 111.89,50.39 111.89,50.53 112.06,50.71 112.06,50.85 111.92,50.99 111.78,50.99 111.61,50.81 111.47,50.81 111.36,50.92 111.36,51.52 111.45,51.62 111.5,51.62 111.6,51.72 111.6,51.92 111.5,52.02 111.45,52.02 111.36,52.11 111.36,52.34 111.45,52.44 111.48,52.44 111.58,52.54 111.58,52.74 111.48,52.83 111.45,52.83 111.36,52.93 111.36,53.23 111.14,53.44 111.14,53.72 111.24,53.82 111.31,53.82 111.41,53.92 111.41,54.11 111.31,54.21 111.24,54.21 111.14,54.31 111.14,54.48 110.92,54.71 110.92,55.54 111.22,55.84 v1(111.22,56.01)
DDR_D_DQS0: length 30.3
  IN1 w0.081: 126.13,47.65 127.53,47.65 128.03,48.15 128.56,48.15 128.91,47.79 129.02,47.79 129.61,47.2 129.86,47.2 130,47.07 130,46.55 v1(129.76,46.31)
  IN1 w0.102: 126.13,47.65 126.04,47.65 126.03,47.66 125.97,47.66 125.96,47.67 124.41,47.67 121,51.08 121,59.73 121.34,60.06 121.34,65.04 120.44,65.94 118.95,65.94 118.58,66.31 117.73,66.31 v1(117.62,66.41)
DDR_D_DQS1: length 45.4
  IN1 w0.081: v1(112.02,66.41) v2(111.72,66.08)
  IN1 w0.102: v1(130.14,43.61) v2(129.69,43.71)
  IN3 w0.102: v2(111.72,66.08) 111.86,66.08 111.98,66.2 111.98,66.38 111.85,66.51 110.83,66.51 110.31,65.99 109.62,65.99 109.43,65.8 109.43,65.53 108.38,64.47 108.38,59.46 109.74,58.1 109.74,56.2 110.46,55.47 110.46,50.78 117.12,44.12 120.98,44.12 122.52,45.65 127.27,45.65 127.35,45.74 128.97,45.74 129.33,45.39 129.33,43.97 129.21,43.85 129.21,43.67 129.29,43.58 129.57,43.58 v2(129.69,43.71)
DDR_D_DQS2: length 25.3
  IN1 w0.102: v1(127.66,44.11) 127.66,44.1 127.52,44.1 127.1,44.52 125.9,44.52 125.83,44.59 119.61,44.59 119.4,44.38 117.19,44.38 115.59,45.98 115.59,50.68 115.89,50.97 115.89,53.82 115.77,53.94 115.77,55.09 116.5,55.83 116.5,56.21 117.17,56.88 117.56,56.88 117.62,56.82 v1(117.62,56.66)
DDR_D_DQS3: length 31.9
  IN1 w0.102: v1(112.02,56.66) 112.16,56.66 112.24,56.74 112.24,56.87 112.15,56.96 111.7,56.96 110.87,56.13 110.87,55.82 110.64,55.59 110.64,53.23 110.85,53.02 110.85,50.71 111.72,49.84 111.72,44.72 115.26,41.18 124.77,41.18 124.87,41.08 125.41,41.08 125.72,41.39 126.49,41.39 126.91,41.81 127.18,41.81 127.26,41.73 127.26,41.59 127.16,41.49 v1(127.01,41.49)
DDR_D_DQS#0: length 30.3
  IN1 w0.081: v1(129.76,46.96) 129.82,46.9 129.82,46.65 129.72,46.55 129.51,46.55 129.43,46.63 129.43,47.12 128.95,47.61 128.84,47.61 128.48,47.96 128.1,47.96 127.61,47.47 125.95,47.47
  IN1 w0.102: 125.95,47.47 124.33,47.47 120.8,51 120.8,59.81 121.13,60.14 121.13,64.96 120.36,65.73 118.87,65.73 118.5,66.1 117.72,66.1 117.62,66 v1(117.62,65.76)
DDR_D_DQS#1: length 45.4
  IN1 w0.081: v1(112.02,65.76) v2(112.32,66.09)
  IN1 w0.102: v1(129.23,43.61) 129.1,43.64 v2(128.78,43.71)
  IN3 w0.102: v2(112.32,66.09) 112.18,66.23 112.18,66.46 111.93,66.71 110.74,66.71 110.22,66.19 109.53,66.19 109.23,65.89 109.23,65.61 108.17,64.56 108.17,59.38 109.53,58.02 109.53,56.11 110.26,55.39 110.26,50.69 117.03,43.92 121.06,43.92 122.6,45.45 127.35,45.45 127.44,45.54 128.89,45.54 129.13,45.3 129.13,44.06 v2(128.78,43.71)
DDR_D_DQS#2: length 25.2
  IN1 w0.102: v1(127.01,44.11) 126.8,44.32 125.82,44.32 125.75,44.39 119.7,44.39 119.49,44.18 117.1,44.18 115.39,45.9 115.39,50.76 115.69,51.06 115.69,53.74 115.56,53.86 115.56,55.18 116.3,55.91 116.3,56.3 117.09,57.08 117.55,57.08 117.62,57.16 v1(117.62,57.31)
DDR_D_DQS#3: length 31.9
  IN1 w0.102: v1(112.02,57.31) 111.87,57.16 111.61,57.16 110.67,56.21 110.67,55.91 110.43,55.68 110.43,53.15 110.65,52.94 110.65,50.63 111.52,49.76 111.52,44.64 115.18,40.97 124.69,40.97 124.78,40.88 125.5,40.88 125.8,41.18 127.13,41.18 127.44,41.49 v1(127.66,41.49)
DDR_D_ODTA: length 3.6
  TOP w0.081: 109.99,64.14 108.76,64.14 108.75,64.12 RD38.1 108.41,63.86 108.43,63.84 RD37.1
  TOP w0.102: UD4.G2 110.9,64.14 109.99,64.14
DDR_D_ODTB: length 3.8
  TOP w0.081: RD39.1 v1(108.43,59.54)
  IN1 w0.064: 110.21,58.9 109.74,58.9 109.1,59.54 v1(108.43,59.54)
  IN1 w0.081: 110.21,58.9 110.97,58.9 v1(111.22,58.65)
DDR_DRAMRST#: length 16.1
  TOP w0.081: RH12.1 168.17,58.96 168.36,59.16 v3(169.07,59.16) 169.36,58.87 169.36,57.41 168.52,56.58 168.52,55.99 168.7,55.81 RH42.1 v1(169.01,55.4) ; UC1.DK47 169.92,47.16 169.56,47.52 169.56,48 169.51,48.06 169.51,48.49 169.76,48.73 169.76,51.09 169.51,51.33 v1(169.51,51.46)
  IN1 w0.064: v1(169.01,55.4) 168.1,54.49 168.1,52.53 168.31,52.32 168.36,52.32 168.75,51.94 169.04,51.94 v1(169.51,51.46)
DDR_DRAMRST#_R: length 110.2
  TOP w0.081: v1(169.42,64.12) 169.03,63.73 169.03,63.13 168.05,62.15 168.05,60.25 168.52,59.78 169.14,59.78 169.75,59.17 169.75,57.25 169.01,56.51 RH42.2 ; v1(121.44,58.58) 121.25,58.77 121.25,59.02 CC740.1 120.39,59.03 119.82,58.46 119.53,58.46 119.36,58.29 119.08,58.29 119.01,58.22 118.68,58.22 118.42,58.47 UD4.T11
  IN1 w0.064: v2(121.46,58.25) 121.49,58.28 121.49,58.54 v1(121.44,58.58) ; 146.59,69.06 146.5,69.15 144.86,69.15 144.76,69.25 143.9,69.25 143.24,69.9 139.73,69.9 v2(139.1,69.27) ; 146.59,69.06 146.59,68.55 ; 146.59,69.06 146.68,69.15 150.74,69.15 151.34,68.55 ; v1(156.81,64.46) 156.61,64.46 156.13,63.98 155.48,63.98 154.25,65.21 153.69,65.21 152.85,64.37 152.03,64.37 151.68,64.03 151.43,64.03 ; 151.43,68.46 151.53,68.36 152.6,68.36 152.97,68.73 154.29,68.73 154.57,69.01 157.3,69.01 157.3,69.02 157.91,69.02 157.93,69 167.33,69 169.53,66.8 169.53,64.22 v1(169.42,64.12)
  IN1 w0.081: 146.55,64.73 146.9,64.39 147.4,64.39 147.59,64.2 148.93,64.2 149.15,64.42 149.3,64.42 149.38,64.5 149.38,64.56 149.52,64.7 149.73,64.7 149.75,64.68 149.82,64.62 150.38,64.62 150.96,64.03 151.43,64.03 ; 146.55,64.73 146.59,64.77 146.59,68.55 ; 146.55,64.73 146.54,64.72 143.94,64.72 143.68,64.46 v1(143.23,64.46) ; v1(133.28,58.61) 133.36,58.61 133.52,58.44 v2(133.52,58.32) ; 151.43,68.46 151.34,68.55
  IN3 w0.064: v2(133.52,58.32) 133.16,57.95 132.56,57.95 132.49,58.01 131.6,58.01 131.41,57.82 128.99,57.82 128.67,58.14 126.46,58.14 125.95,58.65 123.95,58.65 123.5,58.2 121.52,58.2 v2(121.46,58.25) 121.49,58.28 121.49,66.28 124.97,69.75 134.06,69.75 135.02,68.79 138.19,68.79 138.65,69.25 139.08,69.25 v2(139.1,69.27)
DDR_VREF_I: length 9
  TOP w0.081: TP81.1 211.29,32.67 209.14,32.67 207.74,31.28 204.88,31.28 204.69,31.47 204.69,32.08 USSD1.Y14
DDR_VTT_CTRL: length 12.2
  TOP w0.081: TP37.1 126.34,45.12 126.96,45.75 128,45.75 128.44,45.31 129.48,45.31
  TOP w0.089: UC1.M39 131.61,42.96 131.29,43.28 130.98,43.28 130.59,43.67 130.59,45.12 130.4,45.31 129.48,45.31
DEBUG_TX: length 5.7
  TOP w0.081: v1(227.38,9.83) 227.35,9.83 226.89,10.29 RE209.2
  IN1 w0.064: v1(227.38,9.83) 227.68,9.53 228.4,9.53 229.24,8.69 230.2,8.69 230.46,8.43 230.46,7.66 v1(230.8,7.31)
DIAG0_I2C_SCL_I: length 7.9
  TOP w0.081: USSD1.E13 v5(203.09,44.88)
  BOTTOM w0.081: TP38.1 202.6,45.38 v5(203.09,44.88) 203.44,45.23 203.98,45.23 204.23,44.98 204.23,44.22 205.19,43.26 205.19,42.15 205.78,41.56 JSSD1.8
DIAG1_I2C_SDA_I: length 6.4
  TOP w0.081: v5(203.85,44.83) 203.5,45.18 USSD1.D13
  BOTTOM w0.081: JSSD1.9 205.77,40.56 204.96,41.36 204.96,43.01 TP39.1 203.8,44.78 v5(203.85,44.83)
DISP_UTILS: length 0.8
  IN1 w0.064: v1(127.88,24.85) 127.88,25.23 v2(127.86,25.25)
  IN3 w0.064: v4(127.86,24.87) v2(127.86,25.25)
DISPOFF#: length 153.2
  TOP w0.081: JEDP1.22 v1(132.5,83.41) ; v1(218.6,49.54) 219.95,49.54 RH744.1 ; D2.1 187.44,40.76 187.51,40.83 C761.2 R31.2 186.85,42.07 186.53,42.39 186.53,43.41 187.42,44.3 188.5,44.3 189.42,45.22 189.94,45.22 190.54,45.82 191.3,45.82 191.77,46.3 v1(192.2,46.3)
  IN1 w0.064: v1(192.2,46.3) 192.2,46.9 193.88,48.58 193.88,49.84 194.31,50.27 v2(194.7,50.27) 194.7,51.27 195.3,51.87 195.3,52.7 196.98,54.39 196.98,54.85 198.28,56.15 198.28,59.2 197.7,59.78 197.7,60.22 197.82,60.34 197.82,64.98 198.07,65.23 198.07,68.13 197.8,68.4 197.42,68.4 v2(197.08,68.06) ; v1(218.6,49.54) v2(218.6,49.13) ; v1(132.5,83.41) v2(132.5,82.59) 132.67,82.42 132.67,81.87 133.36,81.18 133.36,80.27 132.64,79.54 132.64,78.35 v1(132.24,77.95)
  IN2 w0.051: v2(218.6,49.13) 218.27,48.8 216.28,48.8 215.81,48.33 212.56,48.33 211.64,49.26 207.01,49.26 206.42,48.68 204.01,48.68 203.08,47.75 203.08,46.31 202.82,46.05 199.22,46.05 195.18,50.09 194.88,50.09 v2(194.7,50.27) ; v2(132.5,82.59) 132.5,81.84 135.24,79.11 143.62,79.11 144.44,78.28 144.44,75.63 145.85,74.22 149.34,74.22 150.33,74.42 152.22,74.42 154.41,76.6 154.95,76.6 155.76,77.42 162,77.42 162.2,77.21 163.94,77.21 164.14,77.42 165.74,77.42 171.54,71.63 173.83,71.63 174.67,70.79 176.47,70.79 179.43,67.83 189.44,67.83 189.65,67.62 195.5,67.62 195.7,67.42 196.43,67.42 197.07,68.06 v2(197.08,68.06)
  IN3 w0.064: v2(132.5,82.59) 132.38,82.71 v4(132.38,83.06)
  BOTTOM w0.081: v3(132,82.52) 131.98,82.54 131.98,82.66 v4(132.38,83.06)
DISPOFF_R#: length 1.1
  TOP w0.081: QC2.2 220.57,47.24 RH744.2
DMIC_CLK12: length 208.8
  TOP w0.081: v3(35.02,12.23) 34.7,12.23 v1(34.58,12.1) 34.58,11.86 34.37,11.65 33.78,11.65 33.52,11.91 CA57.1 RA62.1 ; v1(160.98,77.06) 160.92,77.12 160.92,80.12 161.28,80.48 161.28,81.61 161.9,82.23 JUFC1.15
  IN1 w0.064: v1(34.58,12.1) 34.7,12.1 34.77,12.17 34.77,12.28 34.62,12.42 34.05,12.42 33.69,12.78 33.69,14.16 34.17,14.64 35.07,14.64 35.5,14.21 35.5,14.04 35.99,13.56 40.56,13.56 41.38,14.38 47.96,14.38 50.06,16.48 50.48,16.48 v2(50.65,16.65) ; v1(160.98,77.06) 161.2,76.84 v2(161.2,76.62)
  IN2 w0.051: v2(161.2,76.62) 160.95,76.86 155.92,76.86 155.16,76.1 154.62,76.1 153.33,74.81 153.33,73.89 152.6,73.16 145.92,73.16 140.48,78.6 133.83,78.6 131.23,81.2 131.23,82.86 130.11,83.98 124.42,83.98 123.08,82.65 123.08,82.12 121.24,80.28 121.24,77.75 119.05,75.56 100.13,75.56 99.14,74.57 91.08,74.57 87.88,71.37 73.28,71.37 70.85,68.94 70.85,24.74 67.68,21.57 67.48,20.58 67.38,20.34 67.28,20.09 65.37,18.18 56.66,18.18 54.95,16.47 50.83,16.47 v2(50.65,16.65)
  IN3 w0.064: v4(161.59,76.74) 161.32,76.74 v2(161.2,76.62)
  BOTTOM w0.081: R634.2 161.47,76.25 R612.1 161.59,76.36 v4(161.59,76.74)
DMIC_CLK12_R: length 4.3
  TOP w0.081: UA1.5 29.34,12.77 29.75,12.36 31.41,12.36 31.85,11.92 31.85,11.72 32.04,11.53 32.16,11.53 32.25,11.62 RA62.2
DMIC_DATA12: length 207.4
  TOP w0.081: v1(160.6,77.06) 160.71,77.17 160.71,80.21 161.07,80.57 161.07,81.7 161.6,82.22 161.6,83.36 161.5,83.46 JUFC1.16 ; v1(34.83,11.72) 34.77,11.72 34.45,11.41 33.86,11.41 33.77,11.32 33.77,11.32 33.54,11.09 CA64.1 RA58.1
  IN1 w0.064: v2(160.2,76.51) 160.6,76.91 v1(160.6,77.06) ; v2(50.65,16.11) 50.48,16.29 50.14,16.29 48.04,14.19 41.46,14.19 40.64,13.37 35.91,13.37 35.31,13.96 35.31,14.13 34.99,14.45 34.25,14.45 33.88,14.08 33.88,12.86 34.13,12.61 34.7,12.61 34.96,12.36 34.96,12.09 34.83,11.96 v1(34.83,11.72)
  IN2 w0.051: v2(50.65,16.11) 50.83,16.29 55.02,16.29 56.74,18.01 65.45,18.01 67.43,19.99 67.65,20.53 67.84,21.48 71.02,24.66 71.02,68.87 73.35,71.19 87.95,71.19 91.16,74.4 99.22,74.4 100.2,75.38 119.12,75.38 121.42,77.68 121.42,80.2 123.26,82.04 123.26,82.58 124.49,83.81 130.03,83.81 131.05,82.79 131.05,81.13 133.76,78.42 140.41,78.42 145.84,72.98 152.67,72.98 153.51,73.82 153.51,74.74 154.69,75.92 155.23,75.92 155.99,76.68 160.03,76.68 v2(160.2,76.51)
  IN3 w0.064: v4(160.73,76.73) 160.42,76.73 v2(160.2,76.51)
  BOTTOM w0.081: v4(160.73,76.73) R655.2 160.08,76.27 R618.1
DMIC_DATA12_R: length 4.5
  TOP w0.081: RA58.2 32.25,11.12 32.04,11.34 31.97,11.34 31.97,11.35 31.96,11.35 31.66,11.64 31.66,11.65 31.66,11.66 31.66,11.85 31.34,12.17 29.56,12.17 28.94,12.78 UA1.4
DP_RCOMP: length 2
  IN1 w0.254: v2(132.99,24.35) 132.99,24.52 v1(133.33,24.85)
  IN3 w0.305: v2(132.99,24.35) 133,24.36 133.07,24.36 133.28,24.57 v4(133.32,24.57)
  BOTTOM w0.102: v4(133.32,24.57) v3(134.21,24.57)
EC_TOUCHPAD_INTR#: length 96.1
  TOP w0.081: JIO1.31 252.65,6.37 251.81,7.21 249.44,7.21 248.75,7.9 243.68,7.9 241.84,9.74 v3(241.84,12.48) 241.84,14.24 241.32,14.76 v1(241.32,15.44)
  IN1 w0.064: v2(228.63,20.47) 228.8,20.29 228.8,20.11 229.57,18.25 230.76,17.06 238.9,17.06 240.13,15.83 241.07,15.83 241.32,15.59 v1(241.32,15.44) ; v1(207.9,61.16) v2(207.9,60.83)
  IN3 w0.064: v4(207.87,61.28) 207.87,60.86 v2(207.9,60.83) 208.2,60.53 209.32,60.53 209.43,60.63 211.24,60.63 211.9,59.97 213.06,59.97 213.84,59.97 214.07,59.74 214.61,59.74 215.2,60.33 218.4,60.33 219.11,59.62 219.11,48.47 215.39,44.75 215.39,38.35 216.78,36.96 219.4,36.96 221.2,35.15 221.2,33.8 221.2,33.8 221.2,27.57 225.63,23.14 226.99,23.14 227.41,22.73 227.41,22.55 227.64,22.32 227.94,22.32 228.42,21.83 228.42,20.67 v2(228.63,20.47)
EDP_AUXN: length 194.5
  IN1 w0.081: v1(135.24,25.83) 135.53,25.29 135.53,24.99 135.41,24.86 135.41,23.15 131.44,19.19 128.89,19.19 128.31,18.61 125.64,18.61 120.61,13.58 113.56,13.58 112.07,12.09 93.3,12.09 92.16,13.23 85.39,13.23 84.96,12.81 82.89,12.81 82.63,12.55 80.33,12.55 78.98,13.9 75.63,13.9 71.57,17.96 71.57,71.35 76.07,75.84 107.74,75.84 108.82,74.77 112.18,74.77 112.54,75.12 129.38,75.12 129.78,74.72 133.25,74.72 v5(133.63,75.1)
  BOTTOM w0.091: v5(133.63,75.1) 133.82,75.29 133.82,76.84 C10.1
EDP_AUXN_CONN: length 7.4
  TOP w0.091: v5(134.84,82.37) 135,82.53 135,83.43 134.9,83.53 JEDP1.16
  BOTTOM w0.091: C10.2 133.82,77.79 133.82,78.22 134.2,78.6 134.76,78.6 135.03,78.87 v7(135.03,81.19) 135.03,82.18 v5(134.84,82.37)
EDP_AUXP: length 194.5
  IN1 w0.081: v1(135.24,25.18) 135.24,25.17 135.03,24.96 135.03,24.81 135.21,24.63 135.21,23.24 131.36,19.39 128.81,19.39 128.23,18.81 125.56,18.81 120.53,13.78 113.47,13.78 111.99,12.29 93.38,12.29 92.24,13.43 85.31,13.43 84.88,13.01 82.81,13.01 82.55,12.75 80.42,12.75 79.06,14.1 75.72,14.1 71.77,18.04 71.77,71.27 76.15,75.65 107.66,75.65 108.73,74.57 112.26,74.57 112.62,74.93 129.29,74.93 129.7,74.52 133.34,74.52 133.51,74.7 133.92,74.7 134.09,74.52 134.44,74.52 134.55,74.64 134.55,74.82 134.27,75.1 v5(134.21,75.1)
  BOTTOM w0.091: v5(134.21,75.1) 134.02,75.29 134.02,76.84 C9.1
EDP_AUXP_CONN: length 7.4
  TOP w0.091: v5(135.43,82.37) 135.2,82.6 135.2,83.43 135.3,83.53 JEDP1.15
  BOTTOM w0.091: C9.2 134.02,77.79 134.02,78.14 134.28,78.4 134.84,78.4 135.24,78.79 v7(135.24,79.45) 135.24,82.18 v5(135.43,82.37)
EDP_BIA_PWM: length 33.7
  TOP w0.081: v1(176.06,36.14) 175.77,36.43 175.22,36.43 174.77,36.88 172.44,36.88 171.66,36.11 171.66,32.19 171.01,31.54 171.01,30.3 171.26,30.05 171.93,30.05 172.32,29.67 173.19,29.67 173.43,29.9 173.43,30.14 173.17,30.4 173.17,32.09 173.46,32.39 UC1.DU19 ; v3(184.94,41.12) 184.94,41.63 v1(184.96,41.64) 185.33,42.01 D3.3
  IN1 w0.064: v1(176.06,36.14) 176.06,36.15 176.36,36.45 177.06,36.45 178.53,34.99 182.62,34.99 184.25,36.61 184.25,39.55 184.67,39.97 184.67,41.2 184.94,41.48 184.94,41.63 v1(184.96,41.64)
EDP_HPD: length 184.3
  TOP w0.081: v3(179.43,25.89) 179.38,25.95 178.3,25.95 v1(177.98,26.27) ; UE1.C13 216.74,64.41 216.8,64.41 v1(217.01,64.62) ; JEDP1.20 v1(133.3,83.41)
  IN1 w0.064: v2(198.41,68.93) 198.4,68.93 198.4,65.09 198.15,64.84 198.15,60.49 200.06,58.57 200.06,56.19 199.47,55.59 199.47,53.96 197.44,51.93 197.44,51.2 197.82,50.82 v2(197.82,49.93) 197.82,49.65 193.77,45.6 193.77,34.32 194.3,33.78 194.3,31.56 193.9,31.15 193.9,30.34 193.5,29.95 193.5,27.16 v2(193.83,26.83) ; v1(133.3,83.41) 133.29,83.41 133.18,83.3 v2(133.18,82.61) 133.18,82.12 133.75,81.55 133.75,81.17 134.06,80.85 134.06,79.44 133.91,79.29 133.91,78.29 v1(133.57,77.95)
  IN1 w0.081: v2(216.07,50.99) 215.63,51.44 215.63,52.76 215.83,52.97 215.83,54.94 215.16,55.61 215.16,56.09 215.28,56.21 215.28,56.84 215.78,57.34 215.78,57.61 216.1,57.93 216.1,58.63 216.59,59.12 216.59,60.82 216.87,61.1 216.87,64.04 217.01,64.18 v1(217.01,64.62) ; v2(175.02,29.05) 175.02,29.11 v1(174.76,29.37) ; v2(177.12,27.02) 177.12,27.01 177.87,26.26 177.98,26.26 v1(177.98,26.27)
  IN2 w0.051: v2(133.18,82.61) 133.18,81.6 135.36,79.41 143.74,79.41 145.69,77.47 146.22,77.47 146.27,77.5 146.54,77.62 146.84,77.67 150.16,77.67 150.46,77.62 150.73,77.5 150.78,77.47 155.38,77.47 155.63,77.72 162.12,77.72 162.33,77.52 163.81,77.52 164.02,77.72 165.87,77.72 171.66,71.93 173.96,71.93 174.79,71.09 176.59,71.09 179.55,68.13 189.57,68.13 189.78,67.92 194.37,67.92 194.9,68.45 196.51,68.45 196.66,68.6 198.08,68.6 v2(198.41,68.93) ; v2(177.12,27.02) 175.1,29.05 v2(175.02,29.05)
  IN3 w0.064: v2(193.83,26.83) 193.7,26.97 191.49,26.97 191.03,26.51 185.08,26.51 183.95,27.64 179.68,27.64 179.43,27.89 178.38,27.89 178.17,27.68 177.78,27.68 v2(177.12,27.02)
  IN3 w0.081: v2(216.07,50.99) 214.65,50.99 214.35,50.68 204.88,50.68 204.63,50.94 201.37,50.94 200.86,50.43 198.9,50.43 198.38,49.91 197.85,49.91 v2(197.82,49.93)
EDP_TXN0: length 203.3
  IN1 w0.081: v5(135.73,76.11) 135.73,76.83 135.43,77.13 133.81,77.13 132.97,76.29 112.05,76.29 111.7,75.94 109.3,75.94 108.23,77.01 75.58,77.01 70.4,71.84 70.4,17.48 75.15,12.73 78.5,12.73 79.85,11.38 83.12,11.38 83.38,11.64 85.44,11.64 85.87,12.07 91.67,12.07 92.82,10.92 115.13,10.92 116.62,12.41 121.09,12.41 126.13,17.45 128.8,17.45 129.38,18.02 131.93,18.02 137.01,23.1 137.01,25.18 136.1,26.08 135.87,26.08 v1(135.8,26.16)
  BOTTOM w0.091: C2.1 135.73,77.02 135.55,76.83 135.55,76.29 v5(135.73,76.11)
EDP_TXN0_CONN: length 7.2
  TOP w0.091: JEDP1.12 136.5,83.65 136.4,83.55 136.4,83.17 136.77,82.81 136.77,82.35 v5(136.96,82.15)
  BOTTOM w0.091: v5(136.96,82.15) 136.77,81.96 v7(136.77,79.51) 136.77,79.25 135.55,78.03 135.55,77.79 C2.2
EDP_TXN1: length 202.6
  IN1 w0.081: v5(137.39,76.12) 137.43,76.08 137.43,75.78 137.3,75.65 136.85,75.65 136.7,75.51 134.49,75.51 134.07,75.92 133.71,75.92 133.29,75.51 112.38,75.51 112.02,75.16 108.98,75.16 107.9,76.23 75.91,76.23 71.19,71.51 71.19,17.8 75.47,13.52 78.82,13.52 80.17,12.16 82.79,12.16 83.05,12.42 85.12,12.42 85.55,12.85 92,12.85 93.14,11.71 113.27,11.71 113.44,11.87 113.44,12.91 113.72,13.19 114.24,13.19 114.48,12.96 114.48,11.79 114.56,11.71 114.8,11.71 114.88,11.79 114.88,12.96 115.12,13.19 120.77,13.19 125.8,18.23 128.47,18.23 129.05,18.8 131.6,18.8 136.22,23.43 136.22,24.38 136.14,24.46 135.66,24.46 135.59,24.39 135.59,24.27 135.66,24.2 v1(135.8,24.2)
  BOTTOM w0.091: C4.1 137.38,77.02 137.2,76.83 137.2,76.31 v5(137.39,76.12)
EDP_TXN1_CONN: length 7.1
  TOP w0.091: v5(138.23,82.14) 138.04,82.33 138.04,82.86 137.6,83.3 137.6,83.57 137.7,83.67 JEDP1.9
  BOTTOM w0.091: v5(138.23,82.14) 138.04,81.95 138.04,78.91 v7(137.82,78.69) 137.2,78.07 137.2,77.79 C4.2
EDP_TXN2: length 202.3
  IN1 w0.081: v1(134.68,24.85) 134.68,24.69 134.53,24.55 134.4,24.55 134.23,24.38 134.23,23.09 131.12,19.97 128.57,19.97 127.99,19.4 125.32,19.4 120.28,14.36 112.6,14.36 112.37,14.13 112.37,13.5 112.25,13.38 112.08,13.38 111.96,13.5 111.96,14.13 111.73,14.36 111.39,14.36 111.16,14.13 111.16,12.96 111.08,12.87 110.83,12.87 110.75,12.96 110.75,14.13 110.52,14.36 110.18,14.36 109.95,14.13 109.95,12.96 109.87,12.87 109.62,12.87 109.54,12.96 109.54,14.13 109.31,14.36 108.94,14.36 108.71,14.13 108.71,13.35 108.29,12.92 106.35,12.92 106.13,13.14 104.92,13.14 104.65,12.87 93.63,12.87 92.48,14.02 85.06,14.02 84.64,13.59 82.57,13.59 82.31,13.33 80.66,13.33 79.31,14.68 75.96,14.68 72.36,18.29 72.36,71.03 76.39,75.06 107.42,75.06 108.49,73.99 112.51,73.99 112.86,74.34 128.9,74.34 129.3,73.94 134.73,73.94 135.69,74.9 138.04,74.9 138.65,75.51 138.65,75.75 139.02,76.12 v5(139.04,76.12)
  BOTTOM w0.091: v5(139.04,76.12) 138.85,76.31 138.85,76.83 139.03,77.02 C6.1
EDP_TXN2_CONN: length 7.1
  TOP w0.091: JEDP1.6 138.9,83.68 138.8,83.59 138.8,83.4 139.5,82.7 139.5,82.23 v5(139.69,82.04)
  BOTTOM w0.091: C6.2 138.85,77.79 138.85,78.23 139.49,78.87 v7(139.49,79.53) 139.49,81.84 v5(139.69,82.04)
EDP_TXN3: length 202.6
  IN1 w0.081: v5(140.63,75.16) 140.63,75.78 140.42,75.99 140.04,75.99 139.79,75.74 139.55,75.74 138.28,74.47 135.8,74.47 134.89,73.55 128.38,73.55 127.98,73.96 113.02,73.96 112.67,73.6 108.33,73.6 107.26,74.68 76.55,74.68 72.74,70.87 72.74,18.45 76.12,15.07 79.47,15.07 80.82,13.72 82.15,13.72 82.41,13.98 84.48,13.98 84.9,14.4 92.64,14.4 93.79,13.26 104.49,13.26 104.76,13.53 105.56,13.53 105.76,13.73 105.76,14.53 105.98,14.75 106.19,14.75 106.31,14.63 106.31,13.51 106.51,13.31 106.92,13.31 107.11,13.51 107.11,14.63 107.23,14.75 107.4,14.75 107.52,14.63 107.52,13.51 107.72,13.31 108.13,13.31 108.32,13.51 108.32,14.63 108.44,14.75 120.12,14.75 125.16,19.78 127.83,19.78 128.18,20.13 128.18,20.13 128.41,20.36 130.96,20.36 133.85,23.25 133.85,24.97 134.39,25.51 v1(134.68,25.51)
  BOTTOM w0.091: C8.1 140.62,77.02 140.44,76.83 140.44,75.36 v5(140.63,75.16)
EDP_TXN3_CONN: length 7.2
  TOP w0.091: JEDP1.3 140.1,83.68 140.01,83.59 140.01,83.51 140.36,83.16 140.49,83.16 140.88,82.78 140.88,82.12 v5(141.07,81.93)
  BOTTOM w0.091: v5(141.07,81.93) 140.88,81.74 v7(140.88,79.35) 140.88,79.09 140.44,78.66 140.44,77.79 C8.2
EDP_TXP0: length 203.3
  IN1 w0.081: v5(135.15,76.11) 135.14,76.1 134.91,76.1 134.83,76.18 134.83,76.47 134.91,76.55 135.1,76.55 135.16,76.49 135.46,76.49 135.53,76.56 135.53,76.75 135.35,76.94 133.89,76.94 133.05,76.1 112.13,76.1 111.78,75.74 109.22,75.74 108.14,76.81 75.66,76.81 70.6,71.75 70.6,17.56 75.23,12.93 78.58,12.93 79.93,11.58 83.04,11.58 83.3,11.84 85.36,11.84 85.79,12.26 91.76,12.26 92.9,11.12 115.04,11.12 116.53,12.61 121.01,12.61 126.05,17.64 128.72,17.64 129.29,18.22 131.84,18.22 136.81,23.19 136.81,25.1 136.02,25.89 135.64,25.89 135.57,25.82 135.57,25.68 135.75,25.51 v1(135.8,25.51)
  BOTTOM w0.091: v5(135.15,76.11) 135.34,76.3 135.34,76.83 135.16,77.02 C1.1
EDP_TXP0_CONN: length 7.2
  TOP w0.091: v5(136.37,82.15) 136.56,82.35 136.56,82.72 136.2,83.09 136.2,83.47 136.1,83.57 JEDP1.13
  BOTTOM w0.091: C1.2 135.34,77.79 135.34,78.12 136.56,79.34 v7(136.56,81.19) 136.56,81.96 v5(136.37,82.15)
EDP_TXP1: length 202.6
  IN1 w0.081: v1(135.8,24.85) 136,24.66 136.23,24.66 136.42,24.46 136.42,23.35 131.68,18.61 129.13,18.61 128.56,18.03 125.89,18.03 120.85,13 115.2,13 115.08,12.88 115.08,11.7 114.88,11.51 114.48,11.51 114.28,11.7 114.28,12.88 114.16,13 113.8,13 113.63,12.83 113.63,11.78 113.36,11.51 93.06,11.51 91.92,12.65 85.63,12.65 85.2,12.22 83.14,12.22 82.88,11.96 80.09,11.96 78.74,13.32 75.39,13.32 70.99,17.72 70.99,71.59 75.82,76.43 107.98,76.43 109.06,75.35 111.94,75.35 112.29,75.71 133.21,75.71 133.62,76.12 134.15,76.12 134.57,75.71 136.62,75.71 136.81,75.89 v5(136.81,76.12)
  BOTTOM w0.091: v5(136.81,76.12) 137,76.31 137,76.83 136.81,77.02 C3.1
EDP_TXP1_CONN: length 7.1
  TOP w0.091: v5(137.64,82.14) 137.83,82.33 137.83,82.78 137.4,83.21 137.4,83.56 137.3,83.66 JEDP1.10
  BOTTOM w0.091: v5(137.64,82.14) 137.83,81.95 v7(137.83,81.38) 137.83,78.99 137,78.16 137,77.79 C3.2
EDP_TXP2: length 202.3
  IN1 w0.081: v1(134.68,24.2) 134.68,24.27 134.6,24.35 134.48,24.35 134.43,24.3 134.43,23.01 131.2,19.77 128.65,19.77 128.07,19.2 125.4,19.2 120.37,14.16 112.68,14.16 112.57,14.04 112.57,13.42 112.33,13.18 112,13.18 111.76,13.42 111.76,14.04 111.64,14.16 111.48,14.16 111.36,14.04 111.36,12.87 111.16,12.68 110.75,12.68 110.55,12.87 110.55,14.04 110.43,14.16 110.27,14.16 110.15,14.04 110.15,12.87 109.95,12.68 109.54,12.68 109.34,12.87 109.34,14.04 109.23,14.16 109.03,14.16 108.91,14.04 108.91,13.26 108.37,12.72 106.27,12.72 106.05,12.94 105,12.94 104.73,12.68 93.54,12.68 92.4,13.82 85.15,13.82 84.72,13.39 82.65,13.39 82.39,13.13 80.58,13.13 79.22,14.49 75.88,14.49 72.16,18.2 72.16,71.11 76.31,75.26 107.5,75.26 108.57,74.19 112.42,74.19 112.78,74.54 128.98,74.54 129.38,74.14 134.65,74.14 135.61,75.1 137.96,75.1 138.45,75.59 138.45,76.12 v5(138.46,76.12)
  BOTTOM w0.091: C5.1 138.46,77.02 138.65,76.83 138.65,76.31 v5(138.46,76.12)
EDP_TXP2_CONN: length 7.1
  TOP w0.091: v5(139.11,82.04) 139.3,82.23 139.3,82.62 138.6,83.32 138.6,83.57 138.5,83.67 JEDP1.7
  BOTTOM w0.091: C5.2 138.65,77.79 138.65,78.32 139.29,78.96 v7(139.29,81.19) 139.29,81.86 v5(139.11,82.04)
EDP_TXP3: length 202.6
  IN1 w0.081: v1(134.68,26.16) 134.84,26.16 134.9,26.09 134.9,25.85 134.83,25.77 134.57,25.77 134.49,25.7 134.31,25.7 133.65,25.05 133.65,23.33 130.87,20.56 128.49,20.56 128.32,20.56 127.98,20.22 127.75,19.98 125.08,19.98 120.04,14.95 108.36,14.95 108.13,14.71 108.13,13.59 108.04,13.51 107.8,13.51 107.72,13.59 107.72,14.71 107.48,14.95 107.15,14.95 106.92,14.71 106.92,13.59 106.84,13.51 106.59,13.51 106.51,13.59 106.51,14.71 106.28,14.95 105.9,14.95 105.56,14.61 105.56,13.81 105.48,13.73 104.68,13.73 104.41,13.46 93.87,13.46 92.73,14.6 84.82,14.6 84.39,14.17 82.33,14.17 82.07,13.91 80.9,13.91 79.55,15.27 76.2,15.27 72.94,18.53 72.94,70.78 76.63,74.48 107.17,74.48 108.25,73.4 112.75,73.4 113.1,73.76 127.9,73.76 128.3,73.36 134.97,73.36 135.89,74.27 138.36,74.27 139.63,75.54 139.87,75.54 140.13,75.79 140.34,75.79 140.43,75.7 140.43,75.53 140.07,75.16 v5(140.04,75.16)
  BOTTOM w0.091: C7.1 140.05,77.02 140.23,76.83 140.23,75.36 v5(140.04,75.16)
EDP_TXP3_CONN: length 7.2
  TOP w0.091: JEDP1.4 139.7,83.69 139.81,83.58 139.81,83.42 140.28,82.95 140.41,82.95 140.67,82.69 140.67,82.12 v5(140.48,81.93)
  BOTTOM w0.091: C7.2 140.23,77.79 140.23,78.74 140.67,79.18 v7(140.67,81.19) 140.67,81.74 v5(140.48,81.93)
EDRAM_OPIO_RCOMP: length 1.9
  TOP w0.254: UC1.A14 125.89,31.16 125.89,31.43 v5(125.83,31.49)
  BOTTOM w0.127: v3(126.33,31.49) v5(125.83,31.49)
  BOTTOM w0.305: v5(125.83,31.49) 125.41,31.07 RH6.1
EMMC_RCOMP: length 0.7
  IN1 w0.089: v2(173.51,36.87) 173.46,36.92 v1(173.46,37.23)
  IN3 w0.064: v2(173.51,36.87) 173.41,36.76 v4(173.41,36.55)
EN_INVPWR: length 133.2
  TOP w0.081: v1(87.98,67.22) 87.75,66.99 R29.1 87.75,64.97 87.55,64.77 Q16.2 ; UE1.B2 207.49,65.57 v1(205.96,65.57)
  IN1 w0.064: v2(103,68.34) 102.31,68.34 101.04,69.61 97.17,69.61 96.95,69.84 95.82,69.84 93.35,67.37 88.13,67.37 v1(87.98,67.22) ; v2(205.96,65) v1(205.96,65.57)
  IN2 w0.051: v2(205.96,65) 205.4,65 203.17,62.76 198.29,62.76 197.93,63.12 194.94,63.12 194.4,63.66 194.39,63.66 194.04,64.02 194.04,64.02 193.65,64.41 189.45,64.41 189.16,64.13 178.4,64.13 177.71,64.82 175.51,64.82 175.06,64.37 172.46,64.37 167.46,69.37 166.55,69.37 164.38,71.54 160.36,71.54 159.53,70.71 155.11,70.71 154.05,69.65 149.43,69.65 149.13,69.36 144.48,69.36 143.66,70.17 138.88,70.17 138.35,69.64 136.5,69.64 135.66,70.48 126.2,70.48 126.03,70.65 109.08,70.65 107.96,69.53 104.63,69.53 103.44,68.34 v2(103,68.34)
EN_INVPWR_R: length 4.2
  TOP w0.254: R30.1 97.05,69.23 R231.2 97.9,69.23 v1(97.9,69.24)
  IN1 w0.254: v1(100.43,69.29) 97.96,69.29 v1(97.9,69.24)
ENBKL_TS: length 15.3
  TOP w0.081: v1(183.84,34.42) 184.18,34.07 RH732.1
  IN1 w0.064: v1(183.84,34.42) 183.6,34.66 178.29,34.66 177.6,35.35 176.53,35.35 175.71,34.53 174.77,34.53 174.61,34.36 173.54,34.36 172.64,33.47 171.35,33.47 v1(170.68,34.14)
ENVDD: length 4.3
  TOP w0.081: R25.1 C760.2 106.26,67.54 U7.4 105.38,67.6 104.87,67.09 D1.1
ENVDD_PCH: length 125
  TOP w0.081: v5(103.73,62.14) 103.92,62.14 105.52,63.74 D1.3
  IN1 w0.089: v1(171.33,34.14) 171.33,34.13 v2(171.66,33.81)
  IN3 w0.064: v2(171.66,33.81) 171.33,34.14 169.45,34.14 168.87,33.55 168.87,32.78 166.38,30.29 159.61,30.29 158.8,31.1 142.19,31.1 141.02,29.94 141.02,29.08 140.55,28.6 140.55,26.73 134.06,20.24 129.94,20.24 127.72,18.02 v4(126.14,18.02) ; v5(103.73,62.14) 103.79,62.08 103.79,51.93 106.97,48.76 106.97,45.97 106.31,45.31 106.31,44.57 105.48,43.74 105.48,33.21 106.08,32.61 106.08,31.79 105.48,31.19 105.48,23.36 106.84,22.01 v4(107.79,22.01)
  BOTTOM w0.081: v4(126.14,18.02) v3(125.32,18.02) 124.92,18.02 124.67,18.28 120.82,18.28 119.64,17.09 114.04,17.09 113.44,17.69 113.44,20.29 111.73,22.01 v4(107.79,22.01)
ESPI_ALERT#: length 1.1
  IN1 w0.064: v2(211.9,60.69) v1(211.9,60.36)
  IN3 w0.064: v4(212.44,60.23) 211.99,60.69 v2(211.9,60.69)

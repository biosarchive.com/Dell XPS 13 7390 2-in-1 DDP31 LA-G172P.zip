# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_CA4: length 35.1
  IN1 w0.099: v1(156.81,59.26) 156.81,59.27 v2(156.5,59.58) ; v2(156.21,61.27) 155.66,61.27 155.54,61.16 155.54,60.95 155.42,60.83 155.26,60.83 155.14,60.95 155.14,61.16 155.03,61.27 154.85,61.27 153.62,60.04 153.62,59.82 153.66,59.79 153.66,59.63 153.54,59.51 153.38,59.51 153.34,59.54 153.18,59.54 152.94,59.31 152.94,59.12 153.06,59 153.67,59 153.8,58.87 153.8,58.71 153.69,58.6 153.06,58.6 152.94,58.49 152.94,57.42 153.06,57.3 153.29,57.3 153.4,57.19 153.4,57.02 153.29,56.91 153.06,56.91 152.93,56.78 152.93,56.63 153.05,56.51 153.3,56.51 153.4,56.41 153.4,56.22 153.3,56.11 153.05,56.11 152.93,56 152.93,54.93 148.78,50.78 148.78,48.79 148.76,48.77 148.76,48.77 148.76,48.76 148.33,48.33 148.33,47.37 148.84,46.86 148.84,46.49 148.73,46.38 148.48,46.38 148.34,46.24 148.34,46.13 148.43,46.05 148.67,46.05 148.84,45.88 148.84,45.35 148.94,45.25 149.07,45.25 149.17,45.35 149.17,45.61 149.27,45.71 149.42,45.71 149.52,45.61 149.52,45.45 149.56,45.41 149.92,45.41 150.01,45.51 150.01,46.06 149.68,46.4 149.38,46.4 149.28,46.3 v1(149.28,45.98) ; v1(156.81,63.81) 156.81,63.8 v2(156.5,63.49)
  IN3 w0.099: v2(156.5,59.58) 156.76,59.58 156.85,59.66 156.85,59.87 156.74,59.98 156.47,59.98 156.38,60.06 156.38,60.3 156.47,60.38 156.68,60.38 156.78,60.48 156.78,60.62 156.68,60.71 156.46,60.71 156.21,60.96 v2(156.21,61.27) 156.21,61.4 156.31,61.5 156.51,61.5 156.64,61.62 156.64,61.79 156.54,61.89 156.3,61.89 156.13,62.06 156.13,63.11 v2(156.5,63.49)
DDR_A_CA5: length 30
  IN1 w0.081: v1(156.81,59.91) 157,59.92 v2(157.17,60.11)
  IN1 w0.099: v1(146.78,47.94) 146.78,46.72 146.87,46.63 147.5,46.63 147.61,46.73 147.61,46.95 147.49,47.07 147.16,47.07 147.04,47.19 147.04,47.35 147.16,47.47 147.5,47.47 147.62,47.58 147.62,47.74 147.51,47.84 147.16,47.84 147.05,47.96 147.05,48.5 147.18,48.63 147.56,48.63 148.03,49.1 148.03,51.09 152.18,55.25 152.18,59.68 154.55,62.06 155.41,62.06 155.49,62.14 156.93,62.14 v2(156.94,62.13) ; v1(156.81,63.16) v2(157.18,62.86)
  IN3 w0.099: v2(157.18,62.86) 156.94,63.1 156.53,63.1 156.37,62.94 156.37,62.23 156.47,62.13 v2(156.94,62.13) 157.34,61.73 157.34,60.39 157.17,60.22 v2(157.17,60.11)
DDR_A_CKE0: length 31.1
  IN1 w0.081: v2(162.83,62.94) 162.61,63.16 v1(162.41,63.16)
  IN1 w0.099: v1(149.28,47.94) 149.33,47.98 149.49,47.98 149.79,48.28 149.79,50.35 154.41,54.97 154.41,56.65 155.3,57.54 155.47,57.54 155.6,57.41 155.74,57.41 155.83,57.5 155.83,57.64 155.65,57.82 155.65,58.15 155.78,58.28 156.59,58.28 156.64,58.33 157.02,58.33 157.09,58.27 157.09,58.16 157.17,58.08 157.33,58.08 157.43,58.17 158.03,58.17 158.16,58.04 158.32,58.04 158.41,58.12 158.41,58.27 158.47,58.33 159.1,58.33 159.42,58.65 159.42,58.68 159.42,58.68 159.42,58.94 159.48,59 159.74,59 159.74,59 159.77,59 160.07,59.29 160.07,60.58 160.2,60.71 160.2,60.84 160.04,61 159.76,61 159.58,61.17 159.58,61.52 159.78,61.72 160.15,61.72 160.47,62.04 161.73,62.04 161.74,62.02 161.75,62.02 161.94,61.83 161.94,61.82 162.65,61.12 163.05,61.12 v2(163.21,61.28) ; v1(162.41,59.91) v2(162.81,60.23)
  IN3 w0.099: v2(162.81,60.23) 162.74,60.3 162.74,60.54 162.86,60.65 163.49,60.65 163.57,60.73 163.57,60.93 v2(163.21,61.28) 163.47,61.54 163.47,62.01 162.83,62.65 v2(162.83,62.94)
DDR_A_CKE1: length 34.4
  IN1 w0.081: v1(161.61,63.16) v2(161.21,63.48) ; v1(161.61,59.91) 161.59,59.94 161.48,59.95 161.33,59.83 161.32,59.7 v2(161.34,59.66)
  IN1 w0.099: v2(161.73,61.14) 161.73,61.34 161.81,61.42 162.01,61.42 162.2,61.23 162.2,61.08 161.84,60.71 161.84,60.6 161.95,60.48 161.95,60.32 161.84,60.2 161.67,60.2 161.42,60.46 160.91,60.46 160.74,60.28 160.74,60.04 160.8,59.98 160.91,59.98 160.99,59.91 160.99,59.38 160.76,59.15 160.76,58.81 160.38,58.43 160.38,57.99 160.5,57.88 160.5,57.71 160.38,57.6 160.22,57.6 160.1,57.48 160.1,57.32 160.22,57.2 160.38,57.2 160.45,57.14 160.45,56.95 160.31,56.81 160.18,56.81 160.12,56.75 160.12,55.92 159.9,55.7 159.34,55.7 159.28,55.64 159.28,54.97 159.04,54.73 157.95,54.73 157.87,54.81 157.87,54.81 157.78,54.9 157.78,54.91 157.76,54.92 157.76,55.25 157.47,55.54 157.31,55.54 157.19,55.42 157.19,54.58 157.11,54.49 156.88,54.49 156.73,54.65 156.05,54.65 155.95,54.55 155.95,54.23 154.37,52.64 153.82,52.64 151.01,49.83 151.01,48.39 151.05,48.34 151.05,46.41 150.77,46.12 150.63,46.12 150.24,46.52 150.24,46.81 150.05,47 149.96,47 v1(149.92,46.96)
  IN3 w0.099: v2(161.21,63.48) 161.21,62.85 161.99,62.08 161.99,61.4 v2(161.73,61.14) 161.79,61.08 161.79,60.48 161.64,60.34 160.85,60.34 160.77,60.25 160.77,60.05 160.85,59.97 161.12,59.97 161.34,59.75 v2(161.34,59.66)
DDR_A_CLK: length 29.9
  IN1 w0.081: 155.8,56.39 155.82,56.39 155.83,56.4 156.34,56.4 156.48,56.25 157.24,56.25 157.41,56.09 158.18,56.09 158.26,56.17 158.91,56.17 158.99,56.25 159.68,56.25 159.87,56.44 159.87,57.85 160.13,58.11 160.13,58.76 160.51,59.15 160.51,60.37 160.91,60.78 160.91,61.37 v2(161.08,61.53) ; v1(159.21,63.16) v2(159.61,62.83)
  IN1 w0.099: v2(159.46,60.21) 159.44,60.23 159.26,60.21 159.18,60.1 159.2,59.92 v1(159.21,59.91)
  IN1 w0.102: 155.8,56.39 155.29,56.39 155.12,56.21 155.12,54.67 154.8,54.35 154.8,54.23 154.89,54.14 154.89,53.89 154.45,53.45 153.88,53.45 150.5,50.06 150.5,48.45 150.78,48.17 150.78,47.56 150.82,47.52 150.82,46.91 v1(150.55,46.63)
  IN3 w0.099: 159.29,60.26 159.34,60.21 v2(159.46,60.21) ; 160.89,61.33 160.89,61.34 v2(161.08,61.53) 160.87,61.75 160.87,61.99 160.51,62.35 159.39,62.35 159.3,62.43 159.3,62.73 159.3,62.73 159.3,62.77 159.4,62.86 159.59,62.86 v2(159.61,62.83)
  IN3 w0.102: 159.29,60.26 159.27,60.28 159.27,60.6 159.37,60.7 160.67,60.7 160.89,60.92 160.89,61.33
DDR_A_CLK#: length 29.9
  IN1 w0.081: 155.8,56.59 155.82,56.59 155.83,56.58 156.42,56.58 156.56,56.44 157.31,56.44 157.48,56.27 158.1,56.27 158.19,56.36 158.84,56.36 158.92,56.44 159.61,56.44 159.68,56.51 159.68,57.92 159.95,58.18 159.95,58.84 160.33,59.22 160.33,60.45 160.73,60.85 160.73,61.39 160.58,61.53 v2(160.48,61.53) ; v1(158.41,63.16) v2(158.81,62.83)
  IN1 w0.099: v2(158.81,60.23) 158.76,60.24 158.42,59.96 v1(158.41,59.91)
  IN1 w0.102: 155.8,56.59 155.21,56.59 154.92,56.3 154.92,54.76 154.59,54.44 154.59,54.15 154.69,54.06 154.69,53.97 154.37,53.65 153.8,53.65 150.29,50.14 150.29,48.37 150.58,48.08 150.58,47.75 150.27,47.44 150.27,47.18 150.35,47.1 150.46,47.1 150.55,47.18 v1(150.55,47.29)
  IN3 w0.099: 160.67,61.72 160.67,61.9 160.42,62.15 159.3,62.15 159.1,62.35 159.1,62.81
  IN3 w0.102: 159.1,62.81 159.05,62.86 158.84,62.86 v2(158.81,62.83) ; v2(158.81,60.23) 158.91,60.23 159.06,60.38 159.06,60.68 159.28,60.9 160.58,60.9 160.68,61.01 160.68,61.33 v2(160.48,61.53) 160.67,61.72
DDR_A_CS#0: length 38.1
  IN1 w0.081: v2(162.81,63.48) 162.73,63.48 162.42,63.72 v1(162.41,63.81)
  IN1 w0.099: v1(162.41,59.26) v2(162.88,59.58) ; v1(151.19,42.31) 151.1,42.23 150.48,42.23 150.32,42.38 150.32,43.93 150.55,44.16 150.55,44.38 150.28,44.66 150.28,46.14 149.61,46.81 149.61,47.41 149.4,47.63 149.18,47.63 149.03,47.77 149.03,48.04 149.21,48.22 149.29,48.22 149.53,48.46 149.53,50.47 154.16,55.09 154.16,56.79 155.2,57.84 155.2,58.2 155.87,58.86 156.14,58.86 156.42,58.58 157.11,58.58 157.28,58.41 157.69,58.41 157.86,58.58 158.99,58.58 159.19,58.78 159.19,59.03 159.39,59.23 159.64,59.23 159.82,59.41 159.82,60.58 159.49,60.91 159.32,61.09 159.32,61.6 159.68,61.96 160.03,61.96 160.35,62.28 161.83,62.28 162.38,61.73 162.54,61.73 v2(162.58,61.7)
  IN3 w0.099: v2(162.81,63.48) 162.43,63.48 162.18,63.24 162.18,62.66 162.58,62.26 v2(162.58,61.7) 162.53,61.7 162.41,61.58 162.41,59.98 162.81,59.58 v2(162.88,59.58)
DDR_A_CS#1: length 36.7
  IN1 w0.081: v1(163.21,63.81) v2(163.61,64.05)
  IN1 w0.099: v2(164.03,61.78) 164.14,61.78 164.23,61.69 164.23,61.03 164.13,60.93 163.84,60.93 163.77,60.87 163.77,60.64 163.68,60.55 163.44,60.55 163.38,60.62 163.38,60.81 163.31,60.88 163.04,60.88 162.97,60.82 162.97,60.63 162.92,60.58 162.47,60.58 162.4,60.51 162.4,60.29 162.33,60.21 162.19,60.21 161.97,59.99 161.97,59.36 161.91,59.29 161.69,59.29 161.59,59.19 161.59,58.96 161.31,58.69 160.97,58.69 160.73,58.45 160.73,57.88 160.83,57.78 160.99,57.78 161.11,57.67 161.11,57.5 160.99,57.39 160.76,57.39 160.68,57.31 160.68,56.82 160.39,56.54 160.39,55.83 159.99,55.43 159.63,55.43 159.54,55.35 159.54,54.83 159.21,54.5 158.11,54.5 157.86,54.24 156.32,54.24 154.45,52.37 153.9,52.37 151.26,49.73 151.26,48.5 151.29,48.47 151.29,46.29 151.17,46.17 151.17,46.03 151.37,45.84 151.37,45.72 151.25,45.6 151.09,45.6 150.89,45.81 150.64,45.81 150.56,45.73 150.56,44.72 151.02,44.26 v1(151.19,44.26) ; v1(163.21,59.26) v2(163.61,59.01)
  IN3 w0.099: v2(163.61,59.01) 163.35,59.27 163.35,59.7 163.57,59.92 163.7,59.92 163.97,60.19 163.97,60.67 164.22,60.92 164.22,61.55 164.03,61.75 v2(164.03,61.78) 164.01,61.79 164.01,62.15 163.93,62.23 163.67,62.23 163.58,62.32 163.58,62.5 163.68,62.6 163.88,62.6 163.98,62.69 163.98,62.98 163.88,63.08 163.63,63.08 163.38,63.33 163.38,63.84 163.59,64.05 v2(163.61,64.05)
DDR_A_D0_0: length 33.2
  TOP w0.089: v1(155.87,47.14) 155.71,47.14 155.56,47.29 UC1.CA48
  IN1 w0.099: v1(164.01,67.06) 164.41,67.06 164.53,66.94 164.53,66.74 164.64,66.62 165,66.62 165.12,66.74 165.12,66.94 165.24,67.06 166.1,67.06 168.13,65.03 168.13,59.53 167.54,58.95 167.54,56.52 166.76,55.74 166.76,53.17 166.59,53 166.59,52.46 166.34,52.21 164.98,50.85 164.45,50.85 161.99,48.4 161.84,48.4 161.57,48.13 160.73,48.13 160.65,48.05 160.34,48.05 160.21,48.18 158.97,48.18 158.83,48.32 158.83,48.7 158.72,48.82 158.55,48.82 158.44,48.7 158.44,48.28 158.36,48.19 157.2,48.19 156.15,47.14 v1(155.87,47.14)
DDR_A_D0_1: length 35.1
  IN1 w0.099: v1(164.01,67.71) 164.01,67.41 164.11,67.31 164.56,67.31 164.68,67.43 164.68,67.7 164.79,67.82 164.96,67.82 165.07,67.7 165.07,67.43 165.19,67.31 165.35,67.31 165.47,67.43 165.47,67.7 165.59,67.82 165.75,67.82 165.87,67.7 165.87,67.43 165.98,67.31 166.2,67.31 168.41,65.11 168.41,63.72 168.93,63.2 168.93,62.38 169.08,62.23 169.08,60.08 168.98,59.98 168.53,59.98 168.43,59.88 168.43,59.4 167.8,58.76 167.8,57.13 167.8,56.42 167.01,55.64 167.01,53.06 166.84,52.89 166.84,52.36 166.59,52.11 165.09,50.6 164.97,50.6 164.55,50.6 162.1,48.15 161.94,48.15 161.7,47.91 160.82,47.91 160.74,47.83 160.25,47.83 160.12,47.95 157.29,47.95 155.97,46.63 v1(155.55,46.63)
DDR_A_D0_2: length 30.3
  TOP w0.089: v1(155.87,47.93) 155.85,47.93 155.85,47.94 UC1.CA49
  IN1 w0.099: v1(155.87,47.93) 155.96,47.93 157.8,49.77 158.53,49.77 158.6,49.7 158.6,49.57 158.68,49.5 158.92,49.5 159,49.58 159,49.7 159.06,49.76 159.33,49.76 159.4,49.7 159.4,49.58 159.47,49.51 159.71,49.51 159.79,49.59 159.79,49.71 159.86,49.77 160.77,49.77 160.78,49.77 161.44,49.77 161.65,49.77 164.16,52.29 164.33,52.29 164.44,52.17 164.58,52.17 164.72,52.31 164.72,52.46 164.61,52.57 164.61,52.73 165.54,53.67 165.54,56.24 165.87,56.57 165.87,57.8 166,57.92 166.23,57.92 166.33,58.02 166.33,58.22 166.23,58.32 166,58.32 165.87,58.45 165.87,58.99 166.91,60.04 166.91,63.74 166.73,63.92 166.59,63.92 166.41,63.74 166.25,63.74 166.13,63.86 166.13,64.06 166.5,64.44 166.5,64.59 166.38,64.72 166.22,64.72 166.02,64.52 165.88,64.52 165.7,64.7 165.7,64.95 165.6,65.05 165.46,65.05 165.41,65.01 165.22,65.01 165.11,65.12 165.11,65.27 165.16,65.32 165.16,65.43 165.08,65.51 164.71,65.51 164.46,65.76 v1(164.01,65.76)
DDR_A_D0_3: length 32.8
  TOP w0.089: v1(154.41,47.63) 154.29,47.75 UC1.BV49
  IN1 w0.081: 164.79,55.61 164.18,55 164.18,54.51
  IN1 w0.099: 164.79,55.61 164.79,56.56 165.07,56.84 165.07,57.86 164.97,57.96 164.46,57.96 164.31,58.1 164.31,58.26 164.41,58.36 164.97,58.36 165.07,58.46 165.07,59.43 165.4,59.76 165.4,59.9 165.32,59.98 165.32,60.12 165.46,60.26 165.6,60.26 165.68,60.18 165.82,60.18 166.13,60.49 166.13,61.57 165.94,61.76 165.94,61.97 166.13,62.16 166.13,62.54 165.87,62.8 165.56,62.8 164.58,63.78 164.58,64.2 164.27,64.5 163.55,64.5 163.32,64.73 161.68,64.73 161.03,65.38 161.03,65.52 161.18,65.67 161.32,65.67 161.88,65.11 162.41,65.11 v1(162.41,65.11) ; 164.18,54.51 164.18,54.5 164.18,53.37 161.33,50.53 160.46,50.53 160.46,50.53 157.58,50.53 155.7,48.64 155.09,48.64 154.47,48.03 154.47,47.69 v1(154.41,47.63)
DDR_A_D0_4: length 36.8
  IN1 w0.099: v1(162.41,67.06) 162.92,67.57 163.31,67.57 163.84,68.09 166.22,68.09 168.66,65.65 168.66,63.86 169.21,63.31 169.21,62.51 169.33,62.38 169.33,59.35 169.05,59.06 169.05,57.68 168.88,57.5 168.36,57.5 168.13,57.28 168.13,56.29 167.26,55.42 167.26,52.96 167.09,52.79 167.09,52.26 166.84,52 165.19,50.35 164.87,50.35 164.86,50.35 164.66,50.35 162.23,47.92 162.03,47.92 161.79,47.68 160.91,47.68 160.84,47.6 160.16,47.6 160.04,47.72 157.37,47.72 155.64,45.98 v1(155.55,45.98)
DDR_A_D0_5: length 33.2
  IN1 w0.099: v1(164.01,65.11) 163.97,65.15 163.97,65.36 164.1,65.49 164.4,65.49 164.83,65.06 164.83,64.81 164.89,64.74 165.3,64.74 165.45,64.59 165.45,64.18 166.64,63 166.64,60.12 165.62,59.1 165.62,56.68 165.29,56.35 165.29,53.77 161.54,50.02 160.67,50.02 157.73,50.02 155.89,48.19 155.28,48.19 154.92,47.84 154.92,47.32 154.67,47.07 154.67,46.39 154.39,46.11 154.27,46.11 154.18,46.19 154.18,46.35 154.08,46.44 153.94,46.44 153.83,46.33 153.83,45.63 153.77,45.57 153.61,45.57 153.54,45.64 153.54,46.5 154.02,46.98 154.36,46.98 154.43,46.92 154.43,46.77 v1(154.29,46.63)
DDR_A_D0_6: length 39.1
  TOP w0.089: UC1.BV45 v1(154.62,45.98)
  IN1 w0.099: v1(154.62,45.98) 155.05,45.98 155.32,45.72 155.78,45.72 156.01,45.94 156.01,46.03 157.44,47.47 159.97,47.47 160.06,47.37 160.93,47.37 160.99,47.44 161.88,47.44 162.13,47.69 162.32,47.69 162.32,47.7 162.36,47.7 164.76,50.1 165.29,50.1 167.09,51.9 167.09,51.9 167.35,52.15 167.35,52.68 167.51,52.85 167.51,55.31 168.73,56.53 168.73,56.65 169.31,57.23 169.31,58.94 169.58,59.22 169.58,62.51 169.46,62.63 169.46,63.42 168.91,63.98 168.91,66.59 167.15,68.34 163.63,68.34 163.28,67.99 162.69,67.99 v1(162.41,67.71)
DDR_A_D0_7: length 32.2
  IN1 w0.099: v1(162.41,65.76) 162.42,65.76 162.82,65.76 162.94,65.65 162.94,65.51 162.67,65.24 162.67,65.09 162.78,64.97 162.96,64.97 163.22,65.23 163.36,65.23 163.73,64.86 163.99,64.86 164.06,64.78 164.23,64.78 164.33,64.89 164.48,64.89 164.6,64.77 164.6,64.59 165.08,64.11 165.08,63.97 164.97,63.86 164.97,63.72 165.07,63.62 165.21,63.62 165.35,63.76 165.51,63.76 165.63,63.65 165.63,63.48 165.5,63.36 165.5,63.21 165.64,63.07 165.78,63.07 165.91,63.2 166.07,63.2 166.39,62.89 166.39,60.22 165.37,59.2 165.37,56.78 165.04,56.45 165.04,55.38 164.92,55.27 164.77,55.27 164.65,55.15 164.65,54.99 164.77,54.87 164.93,54.87 165.04,54.76 165.04,54.59 164.93,54.47 164.55,54.47 164.43,54.36 164.43,54.19 164.55,54.08 164.92,54.08 165.04,53.96 165.04,53.88 161.44,50.28 160.57,50.28 157.66,50.28 155.8,48.42 155.18,48.42 154.7,47.93 154.7,47.43 154.49,47.22 154.36,47.22 v1(154.29,47.29)
DDR_A_D1_0: length 42.6
  IN1 w0.081: v1(158.41,65.11) v2(158.78,65.13)
  IN1 w0.099: v1(156.68,44.26) v2(156.23,44.45)
  IN3 w0.099: v2(158.78,65.13) 159.12,65.13 159.49,64.76 159.94,64.76 160.1,64.92 160.24,64.92 160.43,64.74 160.43,64.6 160.2,64.37 160.2,64.23 160.67,63.75 160.67,63.6 160.45,63.37 160.26,63.37 159.12,64.51 157.06,64.51 155.88,63.33 155.88,59.06 156.22,58.72 157.01,58.72 157.16,58.57 160.3,58.57 160.66,58.21 160.66,58.21 161.39,57.48 161.53,57.48 161.63,57.58 161.63,58.03 161.73,58.13 161.93,58.13 162.03,58.03 162.03,57.47 162.14,57.36 162.4,57.36 162.52,57.24 162.52,57.08 162.4,56.96 161.52,56.96 161.4,56.84 161.4,56.68 161.52,56.56 162.3,56.56 162.41,56.45 162.41,56.28 162.3,56.17 161.52,56.17 161.4,56.05 161.4,55.89 161.52,55.77 162.3,55.77 162.41,55.65 162.41,55.49 162.3,55.37 161.52,55.37 161.4,55.26 161.4,53.87 156.48,48.95 156.48,47.27 155.86,46.65 155.86,44.9 156.23,44.53 v2(156.23,44.45)
DDR_A_D1_1: length 38.6
  IN1 w0.099: v1(156.68,42.96) 156.67,42.96 156.23,42.6 v2(156.23,42.59) ; v1(156.81,65.76) v2(156.36,66.08)
  IN3 w0.099: v2(156.36,66.08) 156.36,66.17 155.96,66.57 155.96,67.64 156.06,67.74 156.68,67.74 156.79,67.62 156.79,66.38 156.93,66.25 156.93,65.27 157.08,65.12 158.01,65.12 158.1,65.03 158.1,64.86 158.01,64.76 156.93,64.76 155.65,63.48 155.65,58.94 156.09,58.5 156.86,58.5 157.03,58.32 160.15,58.32 161.15,57.32 161.15,53.97 156.26,49.08 156.26,47.37 155.63,46.74 155.63,44.81 155.9,44.54 155.9,43.01 156.23,42.68 v2(156.23,42.59)
DDR_A_D1_2: length 40.6
  IN1 w0.081: v2(158.81,66.17) 158.77,66.16 v1(158.41,65.76)
  IN1 w0.099: v2(156.19,45.04) 156.37,44.88 v1(156.68,44.91)
  IN3 w0.099: v2(158.81,66.17) 158.94,66.3 159.03,66.3 159.18,66.15 159.18,65.44 159.55,65.07 159.87,65.07 159.95,65.15 160.34,65.15 160.45,65.26 160.45,65.45 160.55,65.55 160.7,65.55 160.84,65.41 160.84,65.25 160.94,65.15 161.17,65.15 161.29,65.27 161.29,65.52 161.42,65.64 161.58,65.64 161.68,65.54 161.68,65.3 161.88,65.11 161.98,65.11 162.1,64.99 162.1,64.58 162.22,64.46 162.38,64.46 162.5,64.58 162.5,65.63 162.62,65.76 162.79,65.76 162.89,65.66 162.89,64.51 163,64.41 163.16,64.41 163.29,64.54 163.29,65.34 163.4,65.45 163.57,65.45 163.68,65.34 163.68,64.43 163.8,64.32 163.96,64.32 164.08,64.43 164.08,64.99 164.2,65.11 164.4,65.11 166.14,63.37 166.14,59.96 165.02,58.84 165.02,55.78 164.06,54.82 161.87,54.82 161.65,54.6 161.65,53.76 156.71,48.82 156.71,47.18 156.16,46.62 156.16,45.07 v2(156.19,45.04)
DDR_A_D1_3: length 42.1
  IN1 w0.099: v1(157.59,42.31) v2(157.14,41.85) ; v1(156.81,67.06) v2(157.12,67.2)
  IN3 w0.099: v2(157.12,67.2) 157.12,67.44 157.69,68.01 157.69,68.07 157.99,68.38 164.65,68.38 167.1,65.93 167.1,64.94 167.86,64.18 167.86,59.22 167.32,58.68 167.32,55.76 163.29,51.73 162.61,51.73 160.99,50.11 160.52,50.11 159.2,48.79 159.2,48.66 158.67,48.13 158.67,46.91 158.47,46.71 158.47,46.33 157.93,45.79 157.93,44.65 157.72,44.43 157.72,42.43 v2(157.14,41.85)
DDR_A_D1_4: length 39.9
  IN1 w0.099: v1(156.81,65.11) 156.47,64.91 v2(156.41,64.92) ; v1(156.68,42.31) v2(156.23,41.85)
  IN3 w0.099: v2(156.23,41.85) 156.23,42.07 155.87,42.42 155.87,42.64 155.66,42.85 155.66,44.46 155.41,44.71 155.41,46.84 156.03,47.46 156.03,49.21 160.81,53.99 160.81,57.23 159.95,58.09 156.83,58.09 156.65,58.27 155.95,58.27 154.91,59.31 154.91,59.79 154.31,60.39 154.31,60.68 154.31,60.68 154.31,61.51 154.43,61.62 155.26,61.62 155.38,61.74 155.38,61.9 155.26,62.02 154.43,62.02 154.31,62.14 154.31,62.33 154.31,62.33 154.31,62.86 154.41,62.96 155.26,62.96 155.38,63.08 155.38,63.24 155.26,63.36 154.4,63.36 154.26,63.5 154.26,63.97 154.91,64.62 155.33,64.62 155.44,64.73 155.44,65.87 155.56,65.99 155.72,65.99 155.84,65.87 155.84,64.62 155.97,64.49 156.31,64.49 156.41,64.59 v2(156.41,64.92)
DDR_A_D1_5: length 38.8
  IN1 w0.081: v1(158.41,67.71) v2(158.64,68.03)
  IN1 w0.099: v1(157.59,42.96) v2(157.13,42.59)
  IN3 w0.099: v2(157.13,42.59) 157.49,42.94 157.49,44.57 157.71,44.79 157.71,45.91 158.23,46.44 158.23,46.84 158.43,47.04 158.43,48.38 160.51,50.46 160.68,50.46 162.96,52.73 163.94,52.73 167.03,55.82 167.03,58.77 167.61,59.35 167.61,63.98 166.77,64.81 166.77,65.38 165.89,66.26 165.3,66.26 164.69,66.88 164.69,67.61 164.26,68.03 v2(158.64,68.03)
DDR_A_D1_6: length 38.8
  IN1 w0.081: v1(158.41,67.06) v2(158.1,67.2)
  IN1 w0.099: v1(157.59,44.26) v2(157.13,44.45)
  IN3 w0.099: v2(157.13,44.45) 157.13,44.62 157.47,44.96 157.47,46.49 157.37,46.6 157.37,47.68 160.4,50.71 160.58,50.71 162.85,52.98 163.83,52.98 166.78,55.93 166.78,58.87 167.35,59.45 167.35,63.87 166.52,64.71 166.52,65.28 165.78,66.01 165.2,66.01 164.43,66.78 164.43,67.48 164.15,67.76 159.1,67.76 159.04,67.7 157.71,67.7 157.53,67.52 157.53,67.07 157.63,66.97 158.01,66.97 158.1,67.07 v2(158.1,67.2)
DDR_A_D1_7: length 40.9
  IN1 w0.099: v2(156.38,68.07) 156.39,68 v1(156.81,67.71) ; v1(157.59,44.91) 157.96,45.16 v2(158.26,45.11)
  IN3 w0.099: v2(156.38,68.07) 156.38,68.22 157.13,68.97 157.8,68.97 158.12,68.65 164.74,68.65 168.11,65.28 168.11,59.09 167.61,58.58 167.61,55.69 165.77,53.85 165.77,52.73 164.52,51.48 162.72,51.48 161.1,49.86 160.82,49.86 160.13,49.17 160.13,48.52 159.82,48.22 159.18,48.22 158.93,47.97 158.93,46.85 158.7,46.61 158.7,46.23 158.26,45.8 v2(158.26,45.11)
DDR_A_D2_0: length 15.2
  TOP w0.102: UD1.B4 v1(162.78,55.25)
  IN1 w0.081: 153.57,48.26 153.05,47.74 v1(153.05,47.29)
  IN1 w0.099: 153.57,48.26 153.57,48.41 153.57,48.41 153.57,48.44 154.67,49.55 155.32,49.55 157.41,51.63 160,51.63 160,51.64 160.87,51.64 162.82,53.58 162.82,54.28 162.45,54.65 162.45,55.05 162.65,55.25 v1(162.78,55.25)
DDR_A_D2_1: length 16.4
  IN1 w0.099: v1(164.01,56.01) 163.57,55.57 163.57,53.62 161.92,51.97 161.08,51.13 160.21,51.13 160.21,51.13 157.55,51.13 155.51,49.1 154.86,49.1 154.02,48.25 154.02,48.04 153.63,47.65 153.63,47.34 153.05,46.76 v1(153.05,46.63)
DDR_A_D2_2: length 16
  TOP w0.089: UC1.BT49 153.32,47.66 v1(153.35,47.66)
  IN1 w0.081: 153.79,48.17 153.35,47.73 v1(153.35,47.66)
  IN1 w0.099: 153.79,48.17 153.79,48.35 154.77,49.32 155.41,49.32 157.47,51.38 160.11,51.38 160.11,51.38 160.98,51.38 161.67,52.08 163.08,53.48 163.08,54.41 162.96,54.52 162.96,54.86 163.19,55.09 163.19,55.73 162.89,56.03 162.44,56.03 v1(162.41,56.01)
DDR_A_D2_3: length 19.3
  IN1 w0.099: v1(164.01,57.31) 163.71,57.61 163.35,57.61 162.8,58.16 162.05,58.16 161.76,57.86 161.76,57.61 161.87,57.5 161.87,57.24 160.88,56.25 160.88,55.64 160.41,55.17 160.41,53.6 160.16,53.35 159.29,53.35 159.29,53.35 156.67,53.35 154.82,51.51 154.25,51.51 152.12,49.37 152.12,48.34 151.79,48.01 v1(151.79,47.94)
DDR_A_D2_4: length 17.8
  IN1 w0.099: v1(153.05,45.98) 152.81,45.98 152.73,45.9 152.73,45.63 152.81,45.55 153.12,45.55 153.31,45.74 153.31,46.63 153.88,47.2 153.88,47.59 154.24,47.95 154.24,48.12 155,48.87 155.6,48.87 157.61,50.88 160.32,50.88 161.19,50.88 163.83,53.52 163.83,55.17 v1(164.01,55.36)
DDR_A_D2_5: length 17.4
  IN1 w0.099: v1(162.41,57.31) 162.41,57.12 161.36,56.07 161.36,55.43 160.92,54.99 160.92,53.4 160.37,52.85 159.5,52.85 159.5,52.85 156.88,52.85 155.01,50.99 154.48,50.99 152.62,49.13 152.62,48.2 152.37,47.94 152.37,47.47 152.1,47.2 152.1,46.95 v1(151.79,46.63)
DDR_A_D2_6: length 21.5
  IN1 w0.099: v1(151.79,45.98) 151.52,46.25 151.52,48.08 151.87,48.42 151.87,49.48 154.15,51.76 154.72,51.76 156.57,53.62 160.06,53.62 160.15,53.72 160.15,55.24 160.65,55.73 160.65,56.45 160.94,56.74 160.94,56.86 161.35,57.27 161.35,57.81 161.92,58.39 163.02,58.39 163.12,58.29 163.68,58.29 v1(164.01,57.96)
DDR_A_D2_7: length 17.6
  TOP w0.102: v1(162.08,57.69) 162.35,57.96 UD1.F4
  IN1 w0.099: v1(162.08,57.69) 162.16,57.62 162.16,57.2 161.13,56.16 161.13,55.54 160.66,55.08 160.66,53.5 160.26,53.1 159.39,53.1 159.39,53.1 156.77,53.1 154.91,51.24 154.35,51.24 152.37,49.27 152.37,48.27 152.12,48.02 152.12,47.62 v1(151.79,47.29)
DDR_A_D3_0: length 15.2
  IN1 w0.081: v1(156.81,55.36) v2(156.36,55.04)
  IN1 w0.099: v1(153.93,44.26) v2(153.48,44.45)
  IN3 w0.099: v2(153.48,44.45) 153.48,44.64 152.88,45.24 152.88,46.59 152.84,46.63 152.84,49.99 155.06,52.22 155.06,55 155.22,55.15 155.76,55.15 155.87,55.05 155.87,54.54 155.98,54.42 156.16,54.42 156.27,54.54 156.27,54.96 156.35,55.04 v2(156.36,55.04)
DDR_A_D3_1: length 17
  IN1 w0.081: v1(156.81,57.31) v2(156.36,56.99)
  IN1 w0.099: v1(153.93,42.96) 153.69,42.96 153.47,43.18 v2(153.46,43.18)
  IN3 w0.099: v2(156.36,56.99) 156.15,56.99 154.81,55.65 154.81,52.32 152.59,50.1 152.59,46.49 152.66,46.42 152.66,45.15 153.14,44.67 153.14,43.46 153.42,43.18 v2(153.46,43.18)
DDR_A_D3_2: length 13.9
  IN1 w0.081: v1(153.93,44.91) v2(153.48,45.16) ; v1(156.81,56.01) v2(157.12,55.87)
  IN3 w0.099: v2(153.48,45.16) 153.15,45.49 153.15,46.68 153.09,46.74 153.09,49.89 155.77,52.57 155.77,52.87 155.66,52.99 155.48,52.99 155.37,53.11 155.37,53.27 155.48,53.39 155.66,53.39 155.77,53.5 155.77,53.69 156.61,54.52 156.61,54.53 156.69,54.61 156.69,55.26 157.12,55.69 v2(157.12,55.87)
DDR_A_D3_3: length 20.1
  TOP w0.102: UD1.F9 v1(158.84,57.82)
  IN1 w0.081: v1(158.84,57.82) v2(159.34,57.73)
  IN1 w0.099: v2(154.43,42) 154.53,42 v1(154.85,42.31)
  IN3 w0.099: v2(154.43,42) 154.96,42.54 154.96,44.51 155.18,44.72 155.18,46.93 155.64,47.38 155.64,49.53 160.34,54.24 160.34,55.88 159.34,56.89 v2(159.34,57.73)
DDR_A_D3_4: length 19.5
  IN1 w0.081: v2(156.06,57.9) 156.12,57.96 v1(156.81,57.96)
  IN1 w0.099: v2(153.44,42.14) 153.76,42.14 v1(153.93,42.31)
  IN3 w0.099: v2(153.44,42.14) 152.9,42.67 152.9,44.58 152.43,45.06 152.43,46.28 152.33,46.38 152.33,50.2 154.56,52.43 154.56,57.13 155.33,57.9 v2(156.06,57.9)
DDR_A_D3_5: length 18.4
  IN1 w0.081: v2(158.79,56.89) 158.79,56.89 v1(158.41,57.31)
  IN1 w0.099: v1(154.85,42.96) v2(154.4,42.59)
  IN3 w0.099: v2(158.79,56.89) 158.86,56.82 158.87,56.82 160.09,55.6 160.09,54.35 154.88,49.14 154.88,46.48 154.96,46.4 154.96,44.91 154.74,44.7 154.74,42.93 v2(154.4,42.59)
DDR_A_D3_6: length 16.1
  TOP w0.102: UD1.C9 v1(158.02,55.79)
  IN1 w0.081: v2(158.39,55.85) 158.39,55.85 158.38,55.85 158.09,55.85 v1(158.02,55.79)
  IN1 w0.099: v1(154.85,44.26) v2(154.4,44.45)
  IN3 w0.099: v2(158.39,55.85) 158.39,55.86 158.69,56.15 159.06,56.15 159.29,55.92 159.29,53.94 154.61,49.26 154.61,46.36 154.73,46.24 154.73,45.01 154.4,44.67 v2(154.4,44.45)
DDR_A_D3_7: length 12.9
  IN1 w0.081: v1(158.41,55.36) 158.41,55.29 v2(158.64,55.07) ; v2(154.4,45.18) 154.43,45.19 v1(154.85,44.91)
  IN3 w0.099: v2(154.4,45.18) 154.4,45.42 154.49,45.52 154.49,46.05 154.35,46.19 154.35,49.39 157.87,52.91 157.87,54.35 158.2,54.68 158.49,54.68 158.64,54.83 v2(158.64,55.07)
DDR_A_DQS0: length 32
  IN1 w0.102: v1(163.21,66.41) 163.26,66.36 165.09,66.36 165.21,66.24 165.72,66.24 166.08,65.88 166.39,65.88 166.39,65.88 166.43,65.88 166.43,65.88 166.56,65.88 167.62,64.82 167.62,59.74 167.04,59.16 167.04,56.73 166.25,55.95 166.25,53.38 166.09,53.21 166.09,52.67 164.77,51.36 164.24,51.36 161.78,48.9 161.63,48.9 161.56,48.84 160.63,48.84 160.41,49.06 157.7,49.06 156.04,47.41 155.77,47.41 155.61,47.25 155.61,47.06 154.92,46.36 v1(154.92,46.31)
DDR_A_DQS1: length 37.9
  IN1 w0.102: v1(157.59,43.61) v2(157.13,43.71) ; v1(157.61,66.41) v2(157.32,66.08)
  IN3 w0.102: v2(157.32,66.08) 157.44,66.2 157.44,66.55 157.62,66.73 158.14,66.73 158.19,66.78 159.19,66.78 159.47,66.5 161.71,66.5 161.82,66.38 162.09,66.38 162.49,66.78 163.73,66.78 166.85,63.66 166.85,59.66 165.79,58.61 165.79,55.66 163.62,53.49 162.64,53.49 160.37,51.22 160.11,51.22 157.93,49.04 157.62,49.04 157.14,48.56 157.14,47 156.59,46.45 156.59,45.43 156.76,45.26 156.76,44.03 157.08,43.71 v2(157.13,43.71)
DDR_A_DQS2: length 17.6
  IN1 w0.081: v1(152.42,46.31) 152.42,46.58 152.8,46.97 152.8,47.79 153.34,48.33 153.34,48.38
  IN1 w0.102: v1(163.21,56.66) 163.17,56.71 162.62,56.71 162.1,56.19 162.1,55.07 161.63,54.6 161.63,53.11 160.66,52.14 159.88,52.14 157.17,52.14 155.29,50.26 154.77,50.26 153.34,48.83 153.34,48.38
DDR_A_DQS3: length 16.4
  IN1 w0.081: v2(157.86,56.92) 157.74,56.92 157.72,56.92 157.61,56.8 v1(157.61,56.66)
  IN1 w0.102: v1(154.85,43.61) v2(154.4,43.71)
  IN3 w0.102: v2(157.86,56.92) 157.81,56.97 157.72,56.97 157.66,56.91 157.66,55.36 157.32,55.02 157.32,54.23 156.48,53.39 156.48,52.28 153.81,49.6 153.81,46.87 153.7,46.76 153.7,45.69 154.05,45.34 154.05,43.77 154.12,43.71 v2(154.4,43.71)
DDR_A_DQS#0: length 32
  IN1 w0.102: v1(154.92,46.96) 154.91,46.95 154.91,46.87 154.95,46.83 155.09,46.83 155.41,47.14 155.41,47.34 155.68,47.61 155.96,47.61 157.61,49.27 160.49,49.27 160.72,49.04 161.48,49.04 161.54,49.11 161.7,49.11 164.15,51.56 164.69,51.56 165.88,52.76 165.88,53.29 166.05,53.46 166.05,56.03 166.83,56.82 166.83,59.24 167.42,59.83 167.42,64.73 166.48,65.68 166,65.68 165.64,66.04 165.12,66.04 165,66.16 163.86,66.16 163.79,66.09 163.79,65.96 163.73,65.9 163.55,65.9 163.49,65.96 163.49,66.08 163.43,66.14 163.27,66.14 163.2,66.08 163.2,65.77 v1(163.21,65.76)
DDR_A_DQS#1: length 37.9
  IN1 w0.102: v1(156.68,43.61) v2(156.23,43.71) ; v1(157.61,65.76) v2(157.91,66.09)
  IN3 w0.102: v2(157.91,66.09) 157.83,66.09 157.64,66.3 157.64,66.46 157.71,66.53 158.23,66.53 158.28,66.58 159.11,66.58 159.39,66.29 161.62,66.29 161.74,66.18 162.18,66.18 162.58,66.58 163.65,66.58 166.64,63.58 166.64,59.75 165.59,58.69 165.59,55.75 163.54,53.69 162.56,53.69 160.28,51.42 160.03,51.42 157.85,49.24 157.53,49.24 156.94,48.64 156.94,47.08 156.38,46.53 156.38,45.35 156.56,45.18 156.56,43.94 156.67,43.83 156.67,43.62 156.55,43.5 156.33,43.5 156.23,43.6 v2(156.23,43.71)
DDR_A_DQS#2: length 17.6
  IN1 w0.081: v1(152.42,46.96) 152.53,46.96 152.54,46.96 152.62,47.04 152.62,47.87 153.09,48.34
  IN1 w0.102: 153.09,48.34 153.13,48.38 153.13,48.91 154.69,50.47 155.21,50.47 157.09,52.34 159.79,52.34 159.79,52.35 160.58,52.35 161.42,53.19 161.42,54.68 161.89,55.15 161.89,56.27 162.53,56.91 163.1,56.91 163.21,57.02 v1(163.21,57.31)
DDR_A_DQS#3: length 16.5
  IN1 w0.081: v2(157.28,57.28) 157.59,57.29 v1(157.61,57.31)
  IN1 w0.102: v1(153.93,43.61) v2(153.48,43.71)
  IN3 w0.102: v2(153.48,43.71) 153.64,43.71 153.85,43.91 153.85,45.26 153.5,45.61 153.5,46.85 153.6,46.95 153.6,49.69 156.28,52.36 156.28,53.48 157.12,54.31 157.12,55.11 157.45,55.44 157.45,57.11 v2(157.28,57.28)
DDR_A_ODTA: length 6.2
  TOP w0.081: v3(169.06,57.82) 168.9,57.98 168.9,58.02 168.53,58.39 RD25.1 167.65,58.34 RD26.1 166.73,57.76 166.6,57.89 166.21,57.89 165.17,58.92 164.33,58.92 164.02,58.61 UD1.G2
DDR_A_ODTB: length 5
  TOP w0.081: UD1.T2 164.32,64.46 164.65,64.13 166.91,64.13 RD28.1 167.06,63.93 RD27.1 v3(168.56,63.35)
DDR_B_CA0: length 34.6
  IN1 w0.081: v1(151.19,42.96) 151.17,43.01 v2(150.71,43.26)
  IN1 w0.099: v1(150.43,59.26) 151.01,59.26 151.52,59.76 151.52,60.37 151.43,60.55 151.02,61.42 v2(150.97,61.44) 150.82,61.44 150.6,61.66 150.6,62.18 150.97,62.55 150.97,63.47 150.64,63.81 v1(150.43,63.81)
  IN3 w0.099: v2(150.97,61.44) 150.97,61.47 151.68,62.18 151.82,62.18 151.96,62.04 151.96,61.9 151.37,61.3 151.37,61.14 151.48,61.02 151.65,61.02 152.25,61.62 152.39,61.62 152.53,61.49 152.53,61.35 151.85,60.67 151.85,60.53 152.95,59.44 152.95,59.25 153.06,59.14 153.25,59.14 153.36,59.02 153.36,58.86 153.25,58.74 153.06,58.74 152.95,58.62 152.95,58.46 153.06,58.34 153.35,58.34 153.45,58.24 153.45,58.09 153.31,57.95 153.06,57.95 152.95,57.83 152.95,52.38 151.22,50.66 151.22,45.38 151.25,45.36 151.25,44.89 151.13,44.77 150.94,44.77 150.82,44.66 150.82,44.49 150.94,44.38 151.13,44.38 151.25,44.26 151.25,43.46 151.2,43.41 151.2,43.07 151.04,42.91 150.27,42.91 150.16,43.02 150.16,43.26 150.24,43.34 150.63,43.34 v2(150.71,43.26)
DDR_B_CA1: length 34.6
  IN1 w0.081: v1(150.27,44.26) v2(149.8,44.55)
  IN1 w0.099: v1(150.43,63.16) 150.43,63.37 150.53,63.47 150.62,63.47 150.73,63.36 150.73,63 150.53,62.8 150.34,62.8 150.17,62.63 150.17,62.1 150.05,61.98 v2(150.05,61.12) 150.19,60.98 150.81,60.98 151.06,60.73 151.06,60.18 150.92,60.04 150.92,59.6 150.82,59.51 150.55,59.51 150.43,59.63 v1(150.43,59.91)
  IN3 w0.099: v2(149.8,44.55) 149.53,44.55 149.44,44.45 149.44,43.68 149.53,43.58 150.24,43.58 150.34,43.69 150.34,45.55 150.22,45.67 150,45.67 149.89,45.79 149.89,45.95 150,46.07 150.31,46.07 150.43,46.18 150.43,46.35 150.31,46.46 150,46.46 149.88,46.58 149.88,46.74 150,46.86 150.27,46.86 150.39,46.97 150.39,47.09 149.89,47.59 149.89,48.06 150.47,48.64 150.47,50.98 152.19,52.7 152.19,53.84 152.07,53.97 151.63,53.97 151.51,54.08 151.51,54.25 151.63,54.36 152.08,54.36 152.19,54.47 152.19,54.64 152.07,54.76 151.63,54.76 151.51,54.87 151.51,55.04 151.62,55.15 152.07,55.15 152.19,55.27 152.19,56.93 152.07,57.04 151.58,57.04 151.47,57.16 151.47,57.32 151.58,57.44 152.07,57.44 152.19,57.56 152.19,58.23 152.07,58.34 151.62,58.34 151.51,58.46 151.51,58.62 151.62,58.74 152.07,58.74 152.19,58.85 152.19,58.98 v2(150.05,61.12)
DDR_B_CA2: length 32.7
  IN1 w0.099: v1(149.36,44.91) 149.35,44.92 v2(149.01,44.92) ; v1(144.83,63.81) 144.78,63.85 144.64,63.85 144.56,63.77 144.56,63.29 144.38,63.12 144.38,62.25 144.54,62.09 144.85,62.09 144.95,61.99 144.95,61.58 v2(144.98,61.56) 145.21,61.56 145.36,61.4 145.36,60.74 144.9,60.27 144.83,60.27 144.57,60.01 144.57,59.51 v1(144.83,59.26)
  IN3 w0.099: v2(144.98,61.56) 144.98,61.55 144.66,61.24 144.45,61.24 144.37,61.33 144.37,62.06 144.44,62.13 144.54,62.13 144.7,61.98 144.84,61.98 144.94,62.08 144.94,62.25 144.83,62.36 144.83,62.53 144.98,62.68 147,62.68 147.4,62.28 147.4,61.52 148.26,60.66 148.39,60.66 148.59,60.85 148.73,60.85 148.87,60.71 148.87,60.57 148.68,60.38 148.68,60.22 148.86,60.03 149.03,60.03 149.16,60.17 149.33,60.17 149.44,60.05 149.44,59.89 149.31,59.75 149.31,59.59 149.33,59.56 149.33,59.55 149.58,59.31 149.58,58.21 150.33,57.46 150.33,55.54 150.73,55.14 150.73,51.95 149.89,51.11 149.89,49.12 149.39,48.62 149.39,46.85 149.29,46.74 149.29,45.35 149.01,45.07 v2(149.01,44.92)
DDR_B_CA3: length 36.4
  IN1 w0.081: v1(151.19,43.61) v2(150.74,43.86)
  IN1 w0.099: v1(144.02,59.26) 144.23,59.26 144.33,59.36 144.33,60.2 143.62,60.91 143.62,61.1 143.72,61.2 143.91,61.2 144.21,60.9 v2(144.41,60.9) 144.41,61.48 144.41,61.77 143.68,62.49 143.68,63.07 143.97,63.36 143.97,63.76 v1(144.03,63.81)
  IN3 w0.099: v2(144.41,60.9) 144.13,61.18 144.13,62.19 144.85,62.91 147.11,62.91 147.64,62.38 147.64,61.68 148.19,61.13 148.66,61.13 149.1,61.57 149.1,61.79 149.29,61.98 150.08,61.98 150.36,61.7 150.36,61.23 152.44,59.14 152.44,52.59 150.72,50.87 150.72,45.51 150.58,45.37 150.58,44.02 v2(150.74,43.86)
DDR_B_CA4: length 35.8
  IN1 w0.081: v1(151.19,44.91) v2(150.92,45.18)
  IN1 w0.099: v1(143.23,59.26) 143.28,59.31 143.28,59.57 143.2,59.65 142.77,59.65 142.68,59.74 142.68,60.02 142.52,60.17 142.3,60.17 142.21,60.27 142.21,60.47 142.3,60.57 142.62,60.57 142.89,60.84 v2(142.89,61.01) 142.89,61.14 142.73,61.3 142.73,63.31 v1(143.23,63.81)
  IN3 w0.099: v2(150.92,45.18) 150.97,45.24 150.97,50.77 152.69,52.49 152.69,59.33 151.05,60.98 150.95,60.98 150.62,61.31 150.62,61.8 150.19,62.23 149.2,62.23 148.82,61.85 148.82,61.66 148.53,61.37 148.28,61.37 147.87,61.78 147.87,62.5 147.22,63.14 144.74,63.14 144.13,62.53 143.41,62.53 143.15,62.28 143.15,61.9 143.2,61.85 143.2,61.32 v2(142.89,61.01)
DDR_B_CA5: length 37.2
  IN1 w0.099: v1(143.23,63.16) 142.97,62.91 142.97,62.16 143.36,61.77 143.69,61.77 v2(143.8,61.66) 143.61,61.47 143.54,61.47 143.38,61.31 143.38,60.79 143.5,60.67 143.5,60.19 v1(143.23,59.91) ; v1(149.36,42.31) v2(149.01,42.6)
  IN3 w0.099: v2(149.01,42.6) 148.63,42.98 148.63,45.03 149.05,45.45 149.05,46.84 149.14,46.93 149.14,48.73 149.64,49.23 149.64,51.21 150.48,52.05 150.48,54.96 149.59,55.85 149.59,57.63 149.27,57.95 149.27,58.41 148.8,58.87 148.8,59.71 148.56,59.96 148.25,59.96 147.97,60.24 147.97,60.6 147.17,61.4 147.17,62.18 146.91,62.44 145.67,62.44 145.6,62.37 145.6,61.18 144.86,60.45 144.86,58.84 144.63,58.61 144.23,58.61 143.97,58.87 143.97,60.62 143.85,60.74 143.51,60.74 143.45,60.8 143.45,61.74 143.52,61.81 143.7,61.81 143.8,61.71 v2(143.8,61.66)
DDR_B_CKE0: length 36.8
  IN1 w0.099: v1(148.83,59.91) 148.65,59.91 148.08,60.49 148.08,62.1 v2(148.2,62.23) 148.27,62.3 148.27,62.44 148.08,62.63 148.08,62.77 148.22,62.91 148.36,62.91 148.7,62.57 148.99,62.57 149.22,62.8 149.22,63.04 149.1,63.16 v1(148.83,63.16) ; v1(148.44,42.31) v2(147.99,42.38)
  IN3 w0.099: v2(148.2,62.23) 148.27,62.23 148.84,62.8 152.31,62.8 153.2,61.91 153.2,60.58 154.25,59.53 154.25,58.4 153.95,58.1 153.95,52.68 151.73,50.45 151.73,46.46 152.19,46 152.19,44.07 151.86,43.27 151.86,42.52 151.59,42.25 148.13,42.25 v2(147.99,42.38)
DDR_B_CKE1: length 35.5
  IN1 w0.081: v1(148.44,43.61) v2(147.99,43.65)
  IN1 w0.099: v1(148.03,59.91) 146.75,59.91 146.54,60.12 146.54,60.39 v2(147.11,60.96) 147.2,60.96 147.39,61.15 147.39,62.55 147.99,63.16 v1(148.03,63.16)
  IN3 w0.099: v2(147.11,60.96) 147.11,60.4 147.28,60.23 147.28,60.05 146.98,59.75 146.98,59.61 147.12,59.47 147.26,59.47 147.61,59.82 147.75,59.82 148.07,59.51 148.07,58.39 148.2,58.25 148.82,58.25 148.97,58.11 148.97,57.97 148.87,57.87 148.62,57.87 148.56,57.81 148.56,57.54 148.62,57.47 149.12,57.47 149.23,57.36 149.23,57.19 149.12,57.08 148.01,57.08 147.87,56.94 147.87,56.78 147.97,56.68 148.7,56.68 148.82,56.56 148.82,56.39 148.69,56.26 147.93,56.26 147.8,56.12 147.8,55.96 147.9,55.86 148.69,55.86 148.82,55.73 148.82,55.57 148.9,55.49 148.9,55.32 148.64,55.06 148.64,54.9 148.76,54.78 148.92,54.78 149.18,55.04 149.35,55.04 149.49,54.9 149.49,54.74 149.24,54.49 149.24,54.32 149.35,54.21 149.52,54.21 149.77,54.46 149.93,54.46 150.2,54.19 150.2,54.02 150.08,53.9 149.59,53.9 149.49,53.8 149.49,53.61 149.59,53.51 150.08,53.51 150.2,53.39 150.2,53.18 150.08,53.06 149.65,53.06 149.55,52.97 149.55,52.78 149.66,52.67 150.08,52.67 150.2,52.55 150.2,52.13 149.39,51.32 149.39,49.33 148.89,48.83 148.89,47.01 148.82,46.94 148.82,45.57 148.39,45.14 148.39,44.05 v2(147.99,43.65)
DDR_B_CLK: length 31.7
  IN1 w0.081: v2(148.01,45.5) 147.99,45.41 148.35,44.92 v1(148.44,44.91)
  IN1 w0.089: v1(145.63,63.16) 145.51,63.16 145.4,63.05 145.4,62.89 145.49,62.8 146.27,62.8 146.51,62.57 146.51,61.78 v2(146.74,61.54) 146.54,61.34 146.54,60.74 146.1,60.3 145.52,60.3 145.35,60.13 145.35,59.95 145.41,59.89 145.61,59.89 v1(145.63,59.91)
  IN3 w0.102: v2(146.74,61.54) 146.63,61.54 146.46,61.38 146.46,60.68 146.24,60.46 145.63,60.46 145.53,60.36 145.53,60.05 145.63,59.95 146.43,59.95 146.67,59.71 146.67,58.41 146.82,58.26 147.68,58.26 147.87,58.06 147.87,57.55 147.67,57.34 146.73,57.34 146.67,57.28 146.67,56.75 148.07,55.35 148.07,54.64 148.42,54.29 148.42,53.69 148.2,53.47 147.96,53.47 147.85,53.36 147.85,53.06 147.95,52.96 148.25,52.96 148.62,52.59 149.02,52.59 149.25,52.36 149.25,51.9 149.02,51.67 148.47,51.67 148.29,51.49 148.29,51.05 148.39,50.95 148.66,50.95 148.88,50.72 148.88,50.26 148.66,50.03 148.57,50.03 148.47,49.93 148.47,49.12 148.38,49.03 148.38,48.27 148.16,48.05 147.98,48.05 147.83,47.9 147.83,47.69 147.98,47.54 148.16,47.54 148.38,47.32 148.38,46.68 147.63,45.93 147.63,45.3 147.73,45.2 147.9,45.2 148.01,45.3 v2(148.01,45.5)
DDR_B_CLK#: length 31.7
  IN1 w0.081: v1(148.44,44.26) v2(147.99,44.88)
  IN1 w0.089: v1(144.83,63.16) 144.86,63.16 145.41,62.61 146.19,62.61 146.32,62.49 146.32,61.72 v2(146.14,61.54) 146.35,61.33 146.35,60.82 146.02,60.49 145.44,60.49 145.16,60.21 145.16,59.97 145.09,59.91 v1(144.83,59.91)
  IN3 w0.102: v2(147.99,44.88) 147.87,44.99 147.65,44.99 147.43,45.22 147.43,46.02 148.18,46.77 148.18,47.23 148.08,47.33 147.89,47.33 147.62,47.6 147.62,47.98 147.89,48.25 148.08,48.25 148.18,48.35 148.18,49.11 148.27,49.2 148.27,50.02 148.49,50.24 148.57,50.24 148.68,50.34 148.68,50.64 148.57,50.74 148.31,50.74 148.09,50.97 148.09,51.58 148.38,51.87 148.94,51.87 149.05,51.98 149.05,52.27 148.94,52.38 148.54,52.38 148.17,52.76 147.86,52.76 147.64,52.98 147.64,53.44 147.87,53.67 148.11,53.67 148.22,53.77 148.22,54.21 147.87,54.56 147.87,55.26 146.46,56.67 146.46,57.36 146.65,57.55 147.58,57.55 147.67,57.63 147.67,57.98 147.59,58.05 146.73,58.05 146.46,58.32 146.46,59.63 146.35,59.75 145.55,59.75 145.33,59.97 145.33,60.44 145.55,60.66 146.16,60.66 146.26,60.76 146.26,61.42 v2(146.14,61.54)
DDR_B_CS#0: length 32.8
  IN1 w0.099: v1(148.83,63.81) 148.78,63.76 148.78,63.48 148.84,63.42 149.04,63.42 149.1,63.48 149.1,63.57 149.17,63.63 149.36,63.63 149.44,63.55 149.44,63.15 149.63,62.96 149.63,62.37 149.49,62.23 v2(148.73,62.23) 148.73,61.62 148.52,60.69 148.52,60.4 148.7,60.22 148.95,60.22 149.08,60.09 149.08,59.85 v1(148.83,59.26) ; v2(151.66,43.96) 152.06,44.23 v1(152.1,44.26)
  IN3 w0.099: v2(151.66,43.96) 151.67,43.96 151.77,44.06 151.77,44.24 151.95,44.41 151.95,45.78 151.48,46.26 151.48,50.56 153.7,52.78 153.7,56.23 153.59,56.35 153.34,56.35 153.22,56.47 153.22,56.63 153.34,56.75 153.59,56.75 153.7,56.86 153.7,57.03 153.59,57.14 153.34,57.14 153.22,57.26 153.22,57.42 153.34,57.54 153.59,57.54 153.7,57.65 153.7,59.03 152.95,59.79 152.95,61.8 152.21,62.54 149.05,62.54 v2(148.73,62.23)
DDR_B_CS#1: length 34.7
  IN1 w0.099: v1(149.63,59.26) 149.51,59.26 149.32,59.45 149.32,60.02 149.54,60.23 149.93,60.23 150.06,60.36 150.06,60.59 149.61,61.03 149.3,61.03 v2(149.22,61.11) 149.22,61.58 149.92,62.28 149.92,63.11 149.68,63.35 149.68,63.75 v1(149.63,63.81) ; v1(149.36,44.26) v2(149,44.41)
  IN3 w0.099: v2(149,44.41) 149.06,44.41 149.38,44.74 149.38,45.11 149.52,45.25 149.52,46.63 149.64,46.76 149.64,48.52 149.7,48.58 149.85,48.58 149.88,48.54 150.02,48.54 150.12,48.65 150.12,48.79 150.1,48.81 150.1,48.97 150.22,49.09 150.22,51.08 150.98,51.85 150.98,52.4 151.08,52.5 151.64,52.5 151.74,52.6 151.74,52.77 151.62,52.89 151.08,52.89 150.98,52.99 150.98,53.16 151.1,53.27 151.84,53.27 151.94,53.38 151.94,53.54 151.8,53.68 151.11,53.68 150.98,53.81 150.98,54.18 151.1,54.29 151.2,54.29 151.32,54.41 151.32,54.57 151.2,54.69 151.1,54.69 150.98,54.81 150.98,54.97 151.1,55.09 151.14,55.09 151.26,55.2 151.26,56.02 151.14,56.14 150.77,56.14 150.64,56.27 150.64,56.43 150.74,56.54 151.11,56.54 151.22,56.65 151.22,57.92 151.11,58.04 150.35,58.04 150.25,58.14 150.25,58.3 150.38,58.43 151.15,58.43 151.26,58.55 151.26,58.71 151.15,58.83 150.47,58.83 150.35,58.95 150.35,59.11 150.47,59.23 151.14,59.23 151.26,59.34 151.26,59.45 150.82,59.89 150.65,59.89 150.5,59.74 150.34,59.74 150.22,59.85 150.22,60.02 150.37,60.17 150.37,60.33 150.26,60.45 150.09,60.45 149.82,60.17 149.67,60.17 149.55,60.29 149.55,60.46 149.81,60.73 149.81,60.89 149.59,61.11 v2(149.22,61.11)
DDR_B_D0_0: length 11.1
  IN1 w0.099: v1(148.82,55.36) 148.98,55.21 148.98,55.07 148.81,54.9 148.64,54.9 148.46,55.08 148.3,55.08 148.18,54.97 148.18,54.8 148.36,54.62 148.36,54.37 146.92,52.92 146.92,49.58 146.07,48.73 146.07,47.14 145.87,46.95 145.64,46.95 145.54,47.05 v1(145.54,47.29)
DDR_B_D0_1: length 12.2
  IN1 w0.099: v1(150.43,56.01) 150.43,55.72 150.16,55.46 150,55.46 149.96,55.5 149.79,55.5 149.68,55.38 149.68,55.07 149.58,54.96 149.26,54.96 149.12,54.82 149.12,54.66 149.28,54.49 149.28,53.6 147.17,51.48 147.17,49.48 146.29,48.6 146.29,47.02 145.9,46.63 v1(145.54,46.63)
DDR_B_D0_2: length 9.6
  IN1 w0.099: v1(148.83,56.01) 148.52,56.01 147.95,55.43 147.95,54.31 146.66,53.02 146.66,49.68 145.83,48.85 145.83,48.22 v1(145.55,47.94)
DDR_B_D0_3: length 14.1
  IN1 w0.081: 145.19,48.56 144.79,48.17 144.79,47.36 144.52,47.09 144.52,46.31 144.77,46.06 144.77,45.94 144.69,45.86 144.41,45.86 v1(144.28,45.98)
  IN1 w0.099: v1(148.83,57.31) 148.28,56.77 147.88,56.77 147.3,56.18 147.3,56.08 146.72,55.5 146.72,54.81 145.19,53.28 145.19,48.56
DDR_B_D0_4: length 14
  IN1 w0.099: v1(150.43,55.36) 150.52,55.27 150.84,55.27 150.98,55.13 150.98,54.78 150.81,54.61 150.63,54.61 150.49,54.75 150.35,54.75 150.21,54.61 150.21,54.48 150.29,54.4 150.29,54.24 150.18,54.12 150.01,54.12 149.9,54.23 149.73,54.23 149.62,54.12 149.62,53.95 149.76,53.81 149.76,53.72 147.42,51.38 147.42,49.37 146.53,48.48 146.53,46.94 146.4,46.81 146.4,46.72 146.64,46.48 146.64,46.32 146.53,46.2 146.36,46.2 146.17,46.39 145.89,46.39 145.54,46.04 v1(145.54,45.98)
DDR_B_D0_5: length 16
  IN1 w0.081: 144.43,48.74 144.04,48.34 144.04,46.88 v1(144.28,46.63)
  IN1 w0.099: v1(150.43,57.96) 149.69,58.32 147.94,58.32 146.48,56.86 146.48,56.6 145.95,56.06 145.95,55.11 144.43,53.6 144.43,48.74
DDR_B_D0_6: length 14.5
  IN1 w0.081: 144.92,48.61 144.92,48.59 144.58,48.26 144.58,47.6 144.51,47.52 144.51,47.51 v1(144.28,47.29)
  IN1 w0.099: v1(150.43,57.31) 149.83,57.91 149.49,57.91 149.22,57.64 148.73,57.64 148.1,57.01 147.64,57.01 147.02,56.39 147.02,56.18 146.47,55.63 146.47,54.92 144.94,53.39 144.94,48.63 144.92,48.61
DDR_B_D0_7: length 12.4
  IN1 w0.099: v1(148.83,57.96) 148.06,57.96 147.61,57.5 147.61,57.34 146.74,56.48 146.74,56.35 146.21,55.81 146.21,55.01 144.69,53.49 144.69,48.87 144.67,48.85 144.67,48.65 144.28,48.26 v1(144.28,47.94)
DDR_B_D1_0: length 12.7
  IN1 w0.081: v1(143.23,55.36) 143.02,55.15 v2(142.84,55.15)
  IN1 w0.099: v1(145.7,44.26) v2(145.25,44.45)
  IN3 w0.099: v2(145.25,44.45) 145.25,44.84 144.92,45.16 144.92,46.77 144.78,46.92 144.78,53.04 143.22,54.6 143.21,54.6 142.84,54.96 v2(142.84,55.15)
DDR_B_D1_1: length 18.9
  IN1 w0.081: v1(143.23,57.96) 142.95,58.23 v2(142.77,58.23)
  IN1 w0.099: v2(145.23,42.05) 145.44,42.05 v1(145.7,42.31)
  IN3 w0.099: v2(145.23,42.05) 145.05,42.05 144.91,42.18 144.91,42.58 144.68,42.82 144.68,44.66 144.46,44.88 144.46,46.51 144.27,46.7 144.27,52.83 142.28,54.83 142.28,56.14 142.41,56.27 142.41,57.87 v2(142.77,58.23)
DDR_B_D1_2: length 12.5
  IN1 w0.081: v2(143.53,55.87) 143.4,56.01 v1(143.23,56.01) ; v1(145.7,44.91) v2(145.28,45.3)
  IN3 w0.099: v2(145.28,45.3) 145.28,46.86 145.03,47.11 145.03,53.2 143.21,55.02 143.21,55.55 v2(143.53,55.87)
DDR_B_D1_3: length 16.9
  IN1 w0.081: v2(145.21,56.88) 145.21,56.93 v1(144.83,57.31)
  IN1 w0.099: v1(146.61,42.96) v2(146.16,42.59)
  IN3 w0.081: 146.78,54.51 146.78,55.18
  IN3 w0.099: v2(146.16,42.59) 146.51,42.94 146.51,44.62 146.95,45.05 146.95,46.58 146.76,46.76 146.76,48.89 147.28,49.41 147.28,50.61 146.78,51.11 146.78,54.51 ; 146.78,55.18 145.21,56.75 v2(145.21,56.88)
DDR_B_D1_4: length 17
  IN1 w0.081: v1(143.23,57.31) 142.9,56.99 v2(142.77,56.99)
  IN1 w0.099: v1(145.7,42.96) v2(145.25,42.59)
  IN3 w0.099: v2(145.25,42.59) 145.25,42.62 144.9,42.96 144.9,44.79 144.69,45 144.69,46.63 144.52,46.8 144.52,52.94 142.5,54.96 142.5,55.97 143,56.47 143,56.76 v2(142.77,56.99)
DDR_B_D1_5: length 17.9
  IN1 w0.081: v1(144.83,57.96) 145.17,57.96 v2(145.19,57.93)
  IN1 w0.099: v1(146.61,42.31) 147.07,42.58 v2(147.09,42.65)
  IN3 w0.081: 147.04,54.51 147.04,55.35 146.91,55.47
  IN3 w0.099: v2(145.19,57.93) 145.59,57.54 145.59,56.79 146.91,55.47 ; v2(147.09,42.65) 147.02,42.65 146.74,42.92 146.74,44.49 147.18,44.93 147.18,46.74 147.01,46.91 147.01,48.79 147.53,49.3 147.53,50.72 147.04,51.21 147.04,54.51
DDR_B_D1_6: length 14.7
  IN1 w0.081: v1(144.83,56.01) v2(144.52,56.32)
  IN1 w0.099: v1(146.61,44.26) v2(146.16,44.45)
  IN3 w0.099: v2(146.16,44.45) 146.16,44.59 146.72,45.15 146.72,46.29 146.51,46.5 146.51,48.99 147.03,49.51 147.03,50.51 146.49,51.04 146.49,54.91 145.32,56.08 144.8,56.08 144.56,56.32 v2(144.52,56.32)
DDR_B_D1_7: length 12.3
  IN1 w0.081: v2(145.22,55.03) 144.89,55.36 v1(144.83,55.36)
  IN1 w0.099: v1(146.61,44.91) 146.5,44.9 v2(146.24,45.14)
  IN3 w0.099: v2(146.24,45.14) 146.5,45.39 146.5,46.12 146.24,46.38 146.24,49.08 146.78,49.61 146.78,50.4 146.24,50.94 146.24,54.6 145.8,55.04 145.23,55.04 v2(145.22,55.03)
DDR_B_D2_0: length 26.6
  IN1 w0.099: v1(144.82,65.76) 144.85,65.78 145.29,65.78 145.41,65.9 145.41,66.24 145.32,66.33 145.11,66.33 145.04,66.27 145.04,66.11 144.98,66.05 144.7,66.05 144.58,65.93 144.38,65.93 144.31,65.86 144.31,65.69 144.28,65.66 144.28,65.65 144.18,65.55 144.18,65.3 144.04,65.16 143.54,65.16 143.29,65.42 142.64,65.42 142.61,65.38 141.82,65.38 141.79,65.35 141.15,65.35 141.07,65.26 141.07,65.05 141.29,64.83 141.29,64.68 141.09,64.49 141.09,60.55 141.02,60.49 141.02,56.49 141.67,55.84 141.67,55.15 142.53,54.29 143.31,54.29 143.58,54.03 143.58,48.86 143.36,48.64 143.36,47.88 143.23,47.75 143.23,47.55 143.36,47.42 143.36,47.28 143.29,47.22 143.11,47.22 v1(143.04,47.29)
DDR_B_D2_1: length 27.1
  IN1 w0.099: v1(143.23,65.11) 143.21,65.1 143.17,65.1 142.85,64.78 142.6,64.78 142.5,64.88 142.5,65.03 142.4,65.12 142.01,65.12 141.92,65.04 141.92,64.88 142.17,64.63 142.17,64.38 142.07,64.28 141.93,64.28 141.66,64.55 141.52,64.55 141.38,64.41 141.38,64.27 141.69,63.96 141.69,63.85 141.35,63.51 141.35,62.56 141.54,62.36 141.54,62.19 141.35,61.99 141.35,61.76 141.55,61.56 141.55,61.42 141.36,61.23 141.36,61.02 141.58,60.79 141.58,60.65 141.3,60.37 141.3,60.23 141.55,59.98 141.55,59.84 141.31,59.61 141.31,59.47 141.58,59.2 141.58,59.06 141.29,58.77 141.29,58.63 141.54,58.38 141.54,58.24 141.28,57.98 141.28,57.83 141.54,57.56 141.54,57.4 141.33,57.19 141.33,56.64 141.92,56.05 141.92,55.25 142.6,54.57 143.41,54.57 143.83,54.16 143.83,48.76 143.59,48.52 143.59,47.07 143.52,47.01 143.4,47.01 143.3,46.91 143.3,46.73 143.4,46.63 143.55,46.63 143.66,46.51 143.66,45.98 143.55,45.86 143.43,45.86 143.31,45.98 143.31,46.14 143.16,46.3 142.94,46.3 142.88,46.36 142.88,46.49 143,46.62 143.02,46.62 v1(143.04,46.63)
DDR_B_D2_2: length 26
  IN1 w0.099: v1(143.23,65.76) 143.23,65.82 143.01,66.04 142.71,66.04 142.57,66.18 140.62,66.18 140.51,66.06 140.51,65.82 140.61,65.72 140.7,65.72 140.8,65.62 140.8,65.42 140.7,65.32 140.61,65.32 140.51,65.22 140.51,65 140.84,64.67 140.84,63.2 140.72,63.08 140.62,63.08 140.51,62.97 140.51,62.8 140.62,62.69 140.72,62.69 140.84,62.57 140.84,62.41 140.72,62.29 140.62,62.29 140.51,62.17 140.51,62.01 140.62,61.89 140.72,61.89 140.84,61.78 140.84,60.72 140.66,60.54 140.63,60.54 140.53,60.44 140.53,60.24 140.63,60.15 140.66,60.15 140.76,60.05 140.76,59.85 140.66,59.75 140.63,59.75 140.53,59.65 140.53,59.45 140.63,59.35 140.66,59.35 140.76,59.25 140.76,59.06 140.66,58.96 140.63,58.96 140.53,58.86 140.53,58.66 140.63,58.56 140.66,58.56 140.76,58.46 140.76,58.26 140.66,58.16 140.63,58.16 140.53,58.07 140.53,57.87 140.63,57.77 140.66,57.77 140.76,57.67 140.76,56.4 141.13,56.03 141.13,55.82 141.24,55.7 141.32,55.7 141.42,55.6 141.42,55.4 141.32,55.31 141.29,55.31 141.2,55.21 141.2,55.09 141.47,54.81 141.65,54.81 141.77,54.69 141.77,54.52 142.03,54.25 142.21,54.25 142.33,54.13 142.33,53.96 142.57,53.71 142.71,53.71 143.04,54.04 143.2,54.04 143.32,53.92 143.32,53.76 143,53.44 143,53.3 143.33,52.97 143.33,48.96 143.12,48.76 143.12,48.18 143.03,48.09 143.03,47.95 v1(143.04,47.94)
DDR_B_D2_3: length 27.5
  IN1 w0.081: 142.16,67.68 142.18,67.7 142.88,67.7 143.22,67.36 v1(143.22,67.06) ; v1(141.78,45.98) 142.03,46.24 142.03,46.73 141.99,46.77 141.99,47.16 142.07,47.23 142.07,47.43
  IN1 w0.099: 142.16,67.68 140.09,67.68 138.9,66.49 138.9,60.17 139.04,60.03 139.04,56.09 139.26,55.87 139.26,55.3 142.11,52.45 142.11,49.23 142.2,49.14 142.2,48.58 142.34,48.44 142.34,47.7 142.07,47.43
DDR_B_D2_4: length 28.9
  IN1 w0.099: v1(144.83,65.11) 144.85,65.09 144.85,65 144.78,64.93 144.54,64.93 144.42,65.05 144.25,65.05 144.14,64.93 143.77,64.93 143.61,64.77 143.16,64.77 142.88,64.49 142.88,64.29 143.04,64.13 143.04,63.99 142.9,63.85 142.78,63.85 142.54,64.09 142.28,64.09 141.83,63.64 141.83,62.96 141.95,62.84 142.26,62.84 142.37,62.72 142.37,62.56 142.26,62.44 141.95,62.44 141.83,62.33 141.83,61.79 141.95,61.68 142.24,61.68 142.34,61.58 142.34,61.38 142.24,61.28 141.95,61.28 141.83,61.16 141.83,58.37 141.79,58.33 141.79,57.29 141.58,57.08 141.58,56.75 142.17,56.15 142.17,55.36 142.71,54.83 143.54,54.83 144.08,54.29 144.08,48.69 143.82,48.43 143.82,46.74 143.91,46.65 143.91,45.87 143.67,45.63 142.13,45.63 142.05,45.71 142.05,45.94 142.17,46.06 142.97,46.06 v1(143.04,45.98)

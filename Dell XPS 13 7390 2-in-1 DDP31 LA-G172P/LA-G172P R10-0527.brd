# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IMVP_VR_ON_EN: length 4.1
  TOP w0.081: RE489.2 96.3,51.91 v3(95.66,52.55)
  TOP w0.203: PU1100.21 97.21,49.8 97.06,49.95 96.55,49.95 96.31,50.19 CE430.1 96.3,50.72 RE489.2
IMVP_VR_ON_P: length 174.7
  TOP w0.081: UH6.2 176.13,57.68 175.99,57.82 175.99,58.84 176.5,59.35 v1(176.75,59.35) ; v1(95.39,51.57) v3(94.43,51.57) ; UE8.2 174.86,19.91 175.2,20.25 RE29.1 RE10.2 175.65,19.57 176.01,19.93 U15.4 177.15,19.93 177.58,20.36 179,20.36 179.26,20.61 180.44,20.61 181.2,21.37 189.41,21.37 v1(190.01,20.77)
  IN1 w0.064: v2(198.94,57.78) 198.94,56.11 198.17,55.34 198.17,54.03 196.57,52.43 196.57,50.39 196.8,50.16 196.8,49.67 193.04,45.91 193.04,34.01 193.14,33.9 193.14,32.41 193.45,32.1 193.45,31.85 193.14,31.54 193.14,30.78 192.77,30.4 v2(192.77,26.63) ; v1(176.75,59.35) 177.02,59.61 v2(177.06,59.61) ; v2(101,50.84) 96.12,50.84 v1(95.39,51.57) ; v2(190.82,22.76) 190.77,22.76 190.32,22.3 190.32,20.94 190.15,20.77 v1(190.01,20.77)
  IN2 w0.051: v2(198.94,57.78) 198.16,58.56 192.84,58.56 190.95,56.68 189.04,56.68 188.12,57.6 183.06,57.6 181.95,58.71 180.5,58.71 179.62,59.59 177.09,59.59 v2(177.06,59.61) 177.04,59.59 172.34,59.59 171.45,58.7 170.23,58.7 169.03,57.5 167.86,57.5 166.27,55.91 166.27,55.7 163.66,53.1 156.1,53.1 155.59,53.61 150.34,53.61 150.28,53.55 144.56,53.55 144.5,53.61 135.64,53.61 134.76,54.48 132.91,54.48 132.04,53.61 128.24,53.61 127.96,53.33 115.22,53.33 114.86,53.68 114.74,53.68 113.91,53.68 113.23,53.01 109.14,53.01 108.18,52.05 101.89,52.05 101,51.15 v2(101,50.84)
  IN3 w0.064: v2(192.77,26.63) 191.9,25.76 191.9,23.83 v2(190.82,22.76)
INPUT3VSEL: length 10.4
  TOP w0.081: RH298.1 RH301.1 173.38,56.46 173.38,54.47 172.99,54.08 172.99,52.02 v3(172.69,51.73) 172.3,51.34 172.3,49.65 171.97,49.32 171.97,48.51 171.71,48.24 UC1.DN49
INTRUDER#: length 11.6
  TOP w0.081: UC1.DR47 172.36,46.66 172.01,47 172.01,48.19 172.24,48.42 172.7,48.42 173.27,49 v1(173.68,49) ; RH671.1 177.63,51.57 v1(177.08,51.57)
  TOP w0.097: UC1.DR47 v1(172.68,46.3)
  IN1 w0.064: v1(173.68,49) 174.05,49 174.64,49.59 174.64,49.72 175.71,50.79 176.3,50.79 v1(177.08,51.57) ; v1(172.68,46.3) 172.85,46.46 v2(172.85,46.94)
  IN3 w0.064: v2(172.85,46.94) 172.85,46.91 172.73,46.79 v4(172.47,46.79)
  BOTTOM w0.081: v3(172.47,47.38) v4(172.47,46.79) 172.65,46.6 RH64.1
ISH_I2C0_SCL: length 132.9
  TOP w0.081: JIO1.46 257.15,9.36 256.51,10.01 v1(256.38,10.01)
  IN1 w0.064: v1(256.38,10.01) 256.38,9.88 256.57,9.69 256.57,9.42 256.4,9.24 254.98,9.24 254.48,9.75 254.48,12.1 253.11,13.47 247.72,13.47 244.96,10.7 239.08,10.7 238.37,11.41 231.87,11.41 231.45,11.83 228.53,11.83 223.29,17.08 223.29,22.14 220.69,24.74 216.92,24.74 214.45,27.21 212.3,27.21 211.1,28.41 211.1,30.66 211.43,30.98 211.43,34.05 211.28,34.2 211.02,34.2 v2(210.85,34.03) ; v1(161.5,44.26) 161.67,44.42 162.36,44.42 v2(162.66,44.72)
  IN2 w0.051: v2(162.66,44.72) 162.47,44.9 162.47,45.19 162.62,45.34 163.88,45.34 164.39,45.86 165.38,45.86 167.38,47.86 168.75,47.86 169.4,47.22 172.5,47.22 173.21,47.93 178.35,47.93 179.69,46.59 179.69,46.25 181.51,44.42 184.62,44.42 185.51,45.31 188.76,45.31 188.93,45.14 188.93,44.92 v2(188.75,44.74) 188.93,44.56 188.93,44.38 189.14,44.17 190.37,44.17 191.13,43.41 191.13,42.18 192.97,40.34 196.6,40.34 197.31,39.62 203.98,39.62 208.23,35.38 208.38,35.38 209.55,34.21 210.67,34.21 v2(210.85,34.03)
  IN3 w0.064: v2(188.75,44.74) 188.95,44.55 188.95,44.23 188.82,44.11 188.37,44.11 187.8,44.68 v4(187.8,44.8)
  BOTTOM w0.081: v4(187.8,44.8) 187.68,44.8 186.83,45.65 186.83,46.14 RC666.2
ISH_I2C0_SDA: length 132.6
  TOP w0.081: JIO1.44 256.55,9.58 256.45,9.69 v1(256.13,9.69)
  IN1 w0.064: v1(256.13,9.69) 256.3,9.69 256.38,9.61 256.38,9.5 256.32,9.43 255.06,9.43 254.67,9.83 254.67,12.18 253.19,13.66 247.64,13.66 244.88,10.9 239.16,10.9 238.45,11.61 231.95,11.61 231.53,12.03 228.61,12.03 223.48,17.16 223.48,22.22 220.77,24.93 217,24.93 214.53,27.41 212.38,27.41 211.29,28.49 211.29,30.58 211.62,30.9 211.62,34.13 211.36,34.39 211.02,34.39 v2(210.85,34.56) ; v1(161.5,44.91) 161.5,44.68 161.57,44.61 161.95,44.61 v2(162.12,44.78)
  IN2 w0.051: v2(162.12,44.78) 162.28,44.94 162.28,45.27 162.54,45.53 163.8,45.53 164.3,46.04 165.3,46.04 167.31,48.04 168.83,48.04 169.47,47.39 172.42,47.39 173.13,48.11 178.42,48.11 179.86,46.67 179.86,46.32 181.59,44.6 184.55,44.6 185.44,45.49 188.83,45.49 189.11,45.21 189.11,44.92 v2(189.29,44.74) 189.11,44.56 189.11,44.45 189.21,44.35 190.44,44.35 191.31,43.48 191.31,42.25 193.05,40.52 196.67,40.52 197.39,39.8 204.06,39.8 208.3,35.56 208.45,35.56 209.62,34.39 210.68,34.39 v2(210.85,34.56)
  IN3 w0.064: v4(187.53,44.53) 187.68,44.53 188.29,43.92 188.9,43.92 189.14,44.15 189.14,44.59 v2(189.29,44.74)
  BOTTOM w0.081: v4(187.53,44.53) 187.53,44.65 186.62,45.57 186.62,46.14 RC665.2
ISH_I2C1_SCL: length 56.3
  IN1 w0.064: v1(160.59,44.91) 160.48,44.91 v2(160.05,44.49)
  IN3 w0.064: v2(160.05,44.49) 160.33,44.32 160.5,44.34 160.62,44.54 160.62,44.81 161.74,45.93 161.74,49.14 163.12,50.52 165.22,50.52 167.2,52.51 172.29,52.51 v4(172.44,52.65) 172.63,52.84 172.63,54 172.44,54.19 172.44,54.97 172.13,55.28 171.16,55.28 170.7,55.73 169.9,55.73 169.52,56.1 169.52,61.67 168.84,62.35 168.84,65.4 166.99,67.25 166.99,67.82 164.24,70.57 164.24,71.01 161.26,74 158.65,74 158.17,74.48 158.17,74.83 v9(158.11,74.89)
  BOTTOM w0.081: v9(158.11,74.89) 158.2,74.98 158.2,76.21 v7(156.26,78.16) 155.75,78.66 155.75,79.85 155.53,80.07 R6116.1 ; RC668.2 172.56,52.77 v4(172.44,52.65)
ISH_I2C1_SCL_R: length 12.6
  TOP w0.081: JUFC1.21 159.5,83.63 159.4,83.54 159.4,83.25 159.16,83.01 159.16,82.7 v5(159.35,82.51)
  IN1 w0.064: v5(159.35,82.51) 159.15,82.31 159.15,81.25 158.91,81 158.91,78.82 158.67,78.59 158.4,78.59 158.34,78.52 v1(158.34,78.01)
  IN3 w0.064: v4(155.53,80.67) 155.77,80.91 155.77,81.69 156.56,82.47 156.71,82.47 157.53,83.29 158.87,83.29 159.15,83 159.15,82.71 v5(159.35,82.51)
ISH_I2C1_SDA: length 56.5
  IN1 w0.064: v2(161.22,43.79) 161.32,43.79 v1(161.5,43.61)
  IN3 w0.064: v9(158.49,74.89) 158.36,74.76 158.36,74.56 158.73,74.19 161.34,74.19 164.43,71.09 164.43,70.65 167.18,67.9 167.18,67.33 169.03,65.48 169.03,62.43 169.71,61.75 169.71,56.18 169.97,55.92 170.78,55.92 171.23,55.47 172.21,55.47 172.63,55.05 172.63,54.27 172.82,54.08 172.82,52.59 v4(172.81,52.58) 172.55,52.32 167.28,52.32 165.3,50.33 163.19,50.33 161.93,49.06 161.93,45.85 160.81,44.73 160.81,44.49 160.71,44.33 160.78,44.05 v2(161.22,43.79)
  BOTTOM w0.081: R6117.1 155.96,79.88 155.96,78.74 158.41,76.3 v7(158.41,75.41) 158.41,74.98 v9(158.49,74.89) ; RC667.2 173.13,52.9 v4(172.81,52.58)
ISH_I2C1_SDA_R: length 11.6
  TOP w0.081: v5(158.77,82.51) 158.95,82.7 158.95,83.1 159.2,83.34 159.2,83.55 159.1,83.64 JUFC1.22
  IN1 w0.064: v1(158.34,79.35) 158.34,78.84 158.4,78.78 158.59,78.78 158.72,78.9 158.72,81.08 158.96,81.32 158.96,82.31 v5(158.77,82.51)
  IN3 w0.064: v4(156.17,80.67) 155.96,80.87 155.96,81.61 156.64,82.28 156.79,82.28 157.61,83.1 158.79,83.1 158.96,82.92 158.96,82.71 v5(158.77,82.51)
ISH_LID_CL_NB#: length 64.3
  TOP w0.089: v1(175.08,40.34) 174.92,40.5 UC1.DW34
  IN1 w0.064: v2(175.54,40.25) 175.46,40.34 v1(175.08,40.34) ; v1(213.46,46.46) 213.33,46.46 213.25,46.37 213.25,42.06 213.25,41.38 212.23,40.36 210,40.36 207.75,38.12 207.75,33.54 209.61,31.68 209.61,29.63 209.11,29.13 v2(209.11,28.9)
  IN2 w0.051: v2(209.11,28.9) 208.89,29.13 208.42,29.13 208.32,29.22 207.5,29.22 207.46,29.26 206.64,29.26 206.28,29.61 204.17,29.61 203.16,30.62 192.94,30.62 192.06,31.51 192.06,31.73 192.04,31.75 v2(192.04,31.76) 191.82,31.98 191.59,31.98 185.68,37.88 184.89,37.88 184.43,38.34 182.19,38.34 181.95,38.58 180.75,38.58 180.07,39.26 180.07,39.83 179.8,40.11 176.87,40.11 176.52,39.76 175.91,39.76 175.54,40.12 v2(175.54,40.25)
  IN3 w0.064: v4(191.55,31.91) 191.93,31.91 192.04,31.8 v2(192.04,31.76)
  BOTTOM w0.081: RC751.2 190.75,31.68 190.98,31.91 v4(191.55,31.91)
ISH_LID_CL_TAB#: length 90.3
  TOP w0.081: DE4.2 221.2,50.33 v1(220.44,49.57)
  IN1 w0.064: v1(220.44,49.57) 220.44,45.76 219.93,45.25 219.93,44.49 v2(220.38,44.04) ; v1(172.81,30.67) 172.25,30.67 171.99,30.41 171.99,29.53 172.7,28.82 174.06,28.82 174.2,28.69 v2(174.41,28.69)
  IN2 w0.051: v2(220.38,44.04) 220.38,43.31 221.1,42.58 221.1,38.22 221.86,37.46 221.86,27.66 221.09,26.89 v2(221.09,26.22)
  IN3 w0.064: v2(221.09,26.22) 220.7,25.83 217.43,25.83 216.87,25.28 212.68,25.28 212.48,25.08 211.98,25.08 211.38,25.67 211.38,26.44 209.82,28 209.82,29.68 209.26,30.25 207.6,30.25 207.28,29.92 207.28,29.76 207.08,29.56 205.95,29.56 205.4,30.11 192.73,30.11 191.71,29.09 v4(190.88,29.09) 189.24,27.45 186.66,27.45 186.05,26.84 185.22,26.84 184.09,27.97 179.82,27.97 178.4,29.39 174.88,29.39 174.41,28.91 v2(174.41,28.69)
  BOTTOM w0.081: RC752.2 190.75,29.22 v4(190.88,29.09)
IST_TP_0: length 1.1
  TOP w0.081: v5(148.73,29.56) 148.44,29.27 UC1.BF11
  BOTTOM w0.081: v5(148.73,29.56) 148.55,29.38 TP62.1
IST_TP_1: length 1.3
  TOP w0.081: v5(147.56,29.77) 147.52,29.73 UC1.BD11
  BOTTOM w0.081: TP61.1 147.59,29.74 v5(147.56,29.77)
IST_TRIG_0: length 2
  TOP w0.081: v5(148.17,29.61) 148.17,29.33 147.98,29.14 UC1.BE10
  BOTTOM w0.081: TP64.1 148.05,29.49 v5(148.17,29.61)
IST_TRIG_1: length 2.2
  TOP w0.081: UC1.BF10 148.9,29.21 v5(149.33,29.64)
  BOTTOM w0.081: TP63.1 149.19,29.5 v5(149.33,29.64)
JACK_PLUG#: length 5.1
  TOP w0.081: UA1.48 26.53,14.03 26.39,13.88 26.39,12.8 25.98,12.39 CA40.1 RA14.1 26.61,11.21 RA13.1 26.64,10.51 v3(26.45,10.32)
JTAG_CLK: length 88.6
  IN1 w0.064: v1(230.77,9.83) 230.77,9.63 231.43,8.98 231.88,8.98 v2(231.96,8.9) 231.97,8.9 231.97,8.89 232.28,8.58 232.28,6.29 v1(230.8,4.81) ; v2(212.79,68.52) 212.97,68.34 212.97,66.55 213.32,66.2 213.32,65.11 212.7,64.49 v1(212.7,64.36)
  IN2 w0.051: v2(231.96,8.9) 231.89,8.97 231.26,8.97 231.07,9.16 231.07,10.01 223.65,17.43 223.65,18.17 222.09,19.73 222.09,22.77 221.65,23.21 221.65,24.38 221.11,24.92 220.52,24.92 219.78,25.66 219.78,27.11 220.78,28.11 220.78,37.03 219.86,37.95 v2(219.86,39.09)
  IN3 w0.064: v2(212.79,68.52) 212.89,68.62 212.96,68.62 214.31,69.97 v4(217.65,69.97) 218.27,69.97 219.49,68.76 220.3,68.76 222.52,66.53 222.52,45.6 221.53,44.6 221.53,43.31 219.98,41.76 219.98,39.21 v2(219.86,39.09)
  BOTTOM w0.081: v4(217.65,69.97) v3(218.03,69.97)
JTAG_RST#: length 13.7
  TOP w0.081: UE1.G13 217.95,61.16 v1(218.12,61.33) ; v1(219.01,53.44) 218.82,53.25 JTAG2.1 218.84,52.4 CE63.1 218.88,51.24 RE164.1
  IN1 w0.064: v1(219.01,53.44) 219.32,53.44 219.85,53.97 219.85,57.14 219.01,57.98 219.01,59.72 218.48,60.25 218.48,60.96 v1(218.12,61.33)
JTAG_TDI: length 90.1
  TOP w0.081: JDEG1.2 231.34,3.81 231.86,4.34 v1(231.86,4.99)
  IN1 w0.064: v1(231.91,9.55) 232.06,9.4 232.41,9.4 v2(232.44,9.37) 232.63,9.18 232.63,5.76 v1(231.86,4.99) ; v2(213.7,68.41) 213.3,68.01 213.3,66.69 213.65,66.34 213.65,64.97 213.31,64.63 213.31,63.97 212.95,63.61 212.95,63.03 213.22,62.76 v1(213.5,62.76)
  IN2 w0.051: v2(232.44,9.37) 231.58,10.23 231.28,10.23 223.96,17.56 223.96,18.29 222.4,19.85 222.4,22.9 221.95,23.34 221.95,24.51 221.23,25.23 220.65,25.23 220.09,25.79 220.09,26.99 221.08,27.98 221.08,37.16 220.34,37.9 220.34,39.64 219.62,40.36 v2(218.92,40.36)
  IN3 w0.064: v2(218.92,40.36) 219.65,41.09 219.65,42.07 221.01,43.44 221.01,44.55 222.19,45.73 222.19,65.59 v4(220.63,67.16) 218.39,69.39 214.31,69.39 213.7,68.78 v2(213.7,68.41)
  BOTTOM w0.081: v4(220.63,67.16) v6(220.63,67.59)
JTAG_TDO: length 86.8
  TOP w0.081: UE1.F6 v1(210.88,62.29)
  IN1 w0.064: v1(230.8,5.31) 231.85,6.36 231.85,8.25 231.49,8.61 v2(231.49,8.64) 231.49,8.68 230.34,9.83 v1(230.21,9.83) ; v1(210.88,62.29) 210.88,62.59 v2(211.02,62.74)
  IN2 w0.051: v2(217.39,39.09) 217.88,39.57 219.07,39.57 219.53,39.11 219.53,38.07 220.63,36.97 220.63,28.17 219.63,27.17 219.63,25.6 220.46,24.77 221.04,24.77 221.5,24.32 221.5,23.15 221.94,22.71 221.94,19.67 223.5,18.1 223.5,17.37 230.92,9.95 230.92,8.88 231.16,8.64 v2(231.49,8.64)
  IN3 w0.064: v2(211.02,62.74) 210.73,63.04 210.73,64.17 210.15,64.74 210.15,65.63 210.61,66.09 213.13,66.09 v4(213.27,65.95) 214.28,65.95 215.87,64.36 218.54,64.36 220.12,62.78 220.12,61.01 220.29,60.84 220.76,60.37 220.76,47.79 217.04,44.07 217.04,39.44 v2(217.39,39.09)
  BOTTOM w0.081: v4(213.27,65.95) v6(213.27,65.52)
JTAG_TMS: length 86
  TOP w0.081: v1(231.51,4.99) 231.51,4.48 231.34,4.31 JDEG1.3
  IN1 w0.064: v2(210.34,63.92) 210.34,64.31 v1(210.3,64.36) ; v1(231.51,4.99) 231.51,5 232.44,5.94 232.44,8.89 232.1,9.23 231.64,9.23 v2(231.52,9.36) 231.34,9.54 v1(231.34,9.83)
  IN2 w0.051: v2(231.52,9.36) 231.52,9.78 223.81,17.49 223.81,18.23 222.24,19.79 222.24,22.83 221.8,23.28 221.8,24.44 221.17,25.08 220.59,25.08 219.94,25.73 219.94,27.05 220.93,28.05 220.93,37.09 220.19,37.84 220.19,39.47 219.93,39.72 v2(217.46,39.72)
  IN3 w0.064: v2(217.46,39.72) 217.2,39.98 217.2,44 220.92,47.72 220.92,60.44 220.45,60.91 220.28,61.08 220.28,62.85 218.61,64.53 216.21,64.53 v4(214.73,66.01) 214.49,66.25 210.54,66.25 209.98,65.69 209.98,64.28 v2(210.34,63.92)
  BOTTOM w0.081: v4(214.73,66.01) v6(215.16,66.01)
JUSBC1_GND:
  vias: v5(9.11,56.33) v5(9.54,55.98) v5(10.13,56.62) v5(10.13,55.98) v5(10.71,56.62) v6(8.99,55.79)
JUSBC2_GND: length 0.6
  BOTTOM w0.081: v5(287.18,67.03) v6(287.18,66.46)
  vias: v5(286.01,67.03) v5(286.3,66.53) v5(286.6,67.03) v5(287.76,67.03) v5(287.76,66.44)
KB_DET#: length 109.8
  TOP w0.081: v1(239.44,8.92) v3(241.49,6.86) 241.76,6.59 241.76,5.14 242.6,4.31 244.91,4.31 245.45,4.85 JIO1.7
  IN1 w0.064: v2(239.72,9.08) 239.56,8.92 v1(239.44,8.92)
  IN1 w0.081: v2(164.31,43.93) 164.25,43.87 v1(164.25,43.61)
  IN2 w0.051: v2(164.31,43.93) 164.86,43.93 165.32,43.48 165.32,41.24 165.52,41.05 165.52,40.45 166.4,39.57 167.29,39.57 167.5,39.78 168.49,39.78 168.86,39.41 169.94,39.41 171.05,40.51 172.05,40.51 172.41,40.16 174.65,40.16 175.27,40.77 176.72,40.77 176.93,40.56 179.99,40.56 180.29,40.26 183.37,40.26 185.12,38.52 185.99,38.52 189.21,35.3 189.65,35.3 192.31,32.64 193.15,32.64 193.52,32.26 197.1,32.26 197.98,31.38 203.48,31.38 204.46,30.4 205.61,30.4 205.73,30.53 209.38,30.53 213.61,26.31 213.61,20.87 217.3,17.17 217.3,15.65 218.92,14.03 222.61,14.03 229.61,7.03 231.2,7.03 231.52,7.35 232.18,7.35 233.56,8.74 233.69,8.74 233.69,8.74 239.38,8.74 v2(239.72,9.08)
  IN3 w0.064: v4(164.31,43.57) v2(164.31,43.93)
LAN_WAKE#: length 57.6
  TOP w0.081: UE1.L3 208.34,57.96 207.94,58.36 v1(207.37,58.36)
  IN1 w0.064: v2(207.04,57.38) 207.04,58.03 v1(207.37,58.36)
  IN3 w0.064: v4(200.31,59.16) 201.11,58.35 205.19,58.35 206.17,57.38 v2(207.04,57.38)
  BOTTOM w0.081: RH601.1 RH600.2 168.52,48.19 169.07,48.74 176.19,48.74 182.02,54.57 185.93,54.57 v3(186.51,53.99) 191.84,48.66 195.36,48.66 195.79,49.1 196.34,49.1 197.09,49.85 197.09,52.67 196.83,52.93 196.83,55.29 198.41,56.87 198.41,58.24 199.33,59.16 v4(200.31,59.16)
LAN_WAKE#_R: length 3.9
  TOP w0.081: v5(167.56,49.39) 167.56,49.38 167.16,48.98 167.16,47.41 167.43,47.14 UC1.DE47
  BOTTOM w0.081: v3(167.56,49.93) v5(167.56,49.39) 167.56,49.38 167.48,49.3 RH600.1
LCD_TST: length 105.8
  TOP w0.081: JEDP1.19 v1(133.7,83.41) ; UE1.M2 207.59,57.16 207.17,56.74 206.92,56.74 206.66,56.49 206.66,55.79 v1(206.22,55.35) 206.22,55.03 205.77,54.58 RE160.2
  IN1 w0.064: v1(134.91,77.95) 134.61,78.24 134.61,79.28 134.28,79.61 134.28,80.87 133.91,81.24 133.91,81.62 133.49,82.05 133.49,82.26 133.52,82.29 v2(133.52,83.02) 133.52,83.23 v1(133.7,83.41) ; v1(206.22,55.35) 205.93,55.63 205.93,57.17 205.78,57.32 205.78,58.2 205.59,58.38 205.59,58.4 205.58,58.41 205.58,60.41 205.94,60.78 205.94,62.91 205.75,63.11 205.75,64.21 206.34,64.8 206.34,66.96 205.6,67.7 v2(205.6,68.51)
  IN2 w0.051: v2(205.6,68.51) 205.5,68.6 201.16,68.6 200.32,69.44 198.43,69.44 197.77,68.78 196.63,68.78 196.45,68.6 194.84,68.6 194.31,68.08 189.84,68.08 189.62,68.3 179.6,68.3 176.66,71.25 174.86,71.25 174.02,72.08 171.73,72.08 165.93,77.87 163.95,77.87 163.75,77.67 162.39,77.67 162.19,77.87 155.57,77.87 155.31,77.62 150.83,77.62 150.81,77.64 150.5,77.76 150.18,77.83 146.82,77.83 146.5,77.76 146.19,77.64 146.17,77.62 145.75,77.62 143.81,79.56 135.45,79.56 133.33,81.69 133.33,82.24 133.52,82.43 v2(133.52,83.02)
LCD_VCC_TEST_EN: length 117
  TOP w0.081: v5(105.4,65.08) 104.39,65.08 104.22,64.92 D1.2 ; UE1.E1 v1(206.74,62.76)
  IN1 w0.064: v2(206.74,62.03) v1(206.74,62.76)
  IN2 w0.051: v5(105.4,65.08) 105.4,67.9 105.68,68.18 108.84,68.18 109.96,69.3 125.41,69.3 125.58,69.13 128.8,69.13 129.32,68.62 133.7,68.62 134.03,68.29 143.64,68.29 143.94,67.99 144.97,67.99 145.41,67.55 146.92,67.55 147.08,67.7 148.02,67.7 148.31,67.99 149.41,67.99 149.76,67.64 150.03,67.64 150.28,67.88 150.28,68.1 150.48,68.31 150.84,68.31 151.14,68 152.33,68 152.5,68.18 154.56,68.18 155.74,69.36 156.9,69.36 157.25,69.01 158.52,69.01 158.75,68.78 162.08,68.78 162.48,68.39 163.63,68.39 164.49,67.52 166.1,67.52 168.92,64.7 168.92,62.74 169.8,61.86 171.45,61.86 171.93,62.35 177.85,62.35 177.94,62.25 181.3,62.25 181.88,61.67 189.29,61.67 189.97,62.35 190.98,62.35 191.07,62.27 191.13,62.27 191.38,62.01 192.36,62.01 193.09,61.29 197.03,61.29 197.83,60.49 201.04,60.49 201.12,60.58 203.33,60.58 204.78,62.03 v2(206.74,62.03)
  BOTTOM w0.081: v5(105.4,65.08) v6(105.4,65.62)
LCDVDD_MONITOR: length 1.5
  BOTTOM w0.081: R628.1 127.82,77.74 127.82,78.56 QV21.2
LDO2_CAP: length 3
  TOP w0.203: UA1.21 34.05,17.23 34.26,17.44 v3(34.26,17.78) 34.26,17.87 34.91,18.52 CA51.1
LDO3_CAP: length 2.6
  TOP w0.203: UA1.19 33.55,16.43
  TOP w0.254: CA32.1 35.21,15.72 34.45,16.48 v3(34.26,16.48) 34.2,16.43 33.55,16.43
LID_CL_SIO#: length 16.2
  TOP w0.081: RE122.2 216.55,54.34 216.29,54.61 v1(215.56,54.61) 215.56,55.36 215.1,55.83 UE1.N11
  IN1 w0.064: v1(215.56,54.61) 215.38,54.61 215.08,54.31 215.08,53.9 215.29,53.7 215.29,52.94 214.71,52.36 214.71,51.72 216.08,50.34 216.08,48.88 216.85,48.12 216.85,47.03 216.68,46.86 216.28,46.86 215.48,47.66 v1(213.47,47.66)
LID_CL_SIO_TAB#: length 5.1
  TOP w0.081: UE1.E12 216.28,62.38 216.82,62.38 217.02,62.18 218.9,62.18 218.98,62.25 DE2.2 218.82,63.21 218.82,63.86 RE123.2
LID_CL_TS_FP#: length 221.1
  TOP w0.081: v5(64.89,17.23) 64.89,16.56 64.29,15.96 63.82,15.96 63.63,15.77 RE237.2 R808.2 ; RH743.1 219.18,47.93 DE3.2 218.82,47.56 v1(217.13,47.56)
  IN1 w0.064: v1(217.13,47.56) 217.13,46.99 216.83,46.7 216.06,46.7 215.48,47.28 214.03,47.28 213.77,47.03 213.77,44.87 213.41,44.51 213.41,42.13 213.41,42.13 213.41,41.31 212.3,40.19 210.07,40.19 207.92,38.05 207.92,33.61 209.77,31.75 209.77,28.84 209.56,28.63 209.32,28.63 209,28.31 v2(209,28.01)
  IN2 w0.051: v2(209,28.01) 208.49,28.01 207.95,28.55 206.2,28.55 205.35,29.4 204.16,29.4 203.1,30.47 192.88,30.47 191.99,31.35 191.98,31.35 185.63,37.7 185.5,37.7 185.48,37.73 184.83,37.73 184.37,38.19 182.13,38.19 181.88,38.43 180.69,38.43 179.92,39.2 179.92,39.74 179.71,39.96 176.93,39.96 176.58,39.6 175.77,39.6 175.52,39.85 172.28,39.85 171.93,40.21 171.17,40.21 170.66,39.69 170.66,39.13 170.36,38.84 169.09,38.84 168.31,39.62 167.56,39.62 167.3,39.36 166.4,39.36 165.36,40.39 165.36,40.98 165.17,41.17 165.17,42.22 164.03,43.37 162.38,43.37 162.01,43.73 162.01,44.11 161.36,44.77 161.36,45.26 160.69,45.93 160.69,46.52 160.54,46.68 160.54,47.08 160.06,47.55 159.25,47.55 158.79,48.01 158.79,48.79 158.12,49.46 156.62,49.46 156.21,49.05 154.05,49.05 153.09,50.02 147.53,50.02 146.43,48.93 144.45,48.93 143.22,50.15 139.53,50.15 139.2,49.82 135.32,49.82 134.62,49.13 126.05,49.13 125.36,49.81 117.02,49.81 115.69,48.47 104.28,48.47 102.91,47.11 101.66,47.11 99.86,45.3 95.42,45.3 93.43,43.31 93.43,21.89 v5(93.63,21.69)
  BOTTOM w0.081: v5(64.89,17.23) 65.08,17.04 84.91,17.04 89.8,21.93 92.06,21.93 92.3,21.69 v3(92.62,21.69) v5(93.63,21.69)
LID_POWER_ON#: length 197.5
  TOP w0.081: v1(209.5,63.56) 209.16,63.9 209.16,65.02 209.16,65.3 209.16,65.3 209.16,67.9 RE142.1 ; v5(216.2,52.37) 216.47,52.1 QE19.1
  TOP w0.254: PD601.1 84.44,8.98 v1(84.44,8.43)
  IN1 w0.064: v1(209.5,63.56) 209.5,62.92 209.55,62.86 209.55,62.38 209.2,62.03 209.2,61.28 209.24,61.24 209.24,60.53 208.77,60.07 208.77,59.77 209.26,59.28 210.14,59.28 210.6,58.83 210.6,58.05 210.4,57.85 209.93,57.85 209.35,57.27 v2(209.35,55.8) 209.26,55.7 209.26,53.03 v2(209.35,52.93) ; v2(86.62,8.8) 86.33,8.8 85.87,8.33 84.53,8.33 v1(84.44,8.43)
  IN2 w0.051: v2(209.35,55.8) 206.82,55.8 205.77,56.85 204.76,56.85 204.55,56.64 195.14,56.64 194.47,57.31 192.88,57.31 191.33,55.76 178.16,55.76 176.35,57.58 174.8,57.58 174.65,57.43 172.94,57.43 172.38,56.87 171.28,56.87 169.49,55.08 168.56,55.08 168.08,54.59 168.08,53.77 165.12,50.81 159.51,50.81 158.92,51.4 155.52,51.4 154.99,51.93 138.79,51.93 138.77,51.9 131.04,51.9 130.75,51.61 130.6,51.47 130.48,51.47 130.47,51.47 127.84,51.47 127.72,51.59 116.29,51.59 115.1,50.4 105.25,50.4 104.88,50.77 102.64,50.77 99.74,47.87 98.18,47.87 97.64,47.33 92.96,47.33 91.42,45.8 91.42,43.47 91.89,43 91.89,13.69 89.05,10.84 89.05,9.81 88.01,8.77 87.49,8.77 87.25,9.01 86.83,9.01 v2(86.62,8.8)
  IN3 w0.064: v2(209.35,52.93) 212.62,52.93 213,52.55 214.6,52.55 214.73,52.68 215.89,52.68 v5(216.2,52.37)
  BOTTOM w0.081: v3(216.12,52.93) 216.12,52.45 v5(216.2,52.37)
LINE2-L: length 6.8
  TOP w0.102: CA12.1 25.81,23.85 v3(24.86,24.8)
  TOP w0.203: UA1.36 27.74,19.64 27.46,19.91
  TOP w0.381: 27.46,19.91 26.91,20.47 26.91,22.56 26,23.47 CA12.1
LINE2-R: length 6.1
  TOP w0.102: v3(27.85,24.8) 28.23,24.42 CA10.1
  TOP w0.203: UA1.35 28.14,19.98
  TOP w0.381: CA10.1 28.23,23.15 27.63,22.55 27.63,20.64 28.14,20.12 28.14,19.98
LX_1.8V: length 9.3
  TOP w0.254: PC500.2 206.38,19.38 206.03,19.02 206.03,17.37 206.28,17.12 207.61,17.12 207.86,16.87 211.73,16.87 PR510.1
LX_5V: length 2.6
  IN1 w0.254: v1(20.29,3.73) 20.8,3.73 21.31,3.22 v1(22.7,3.22)
LX_5VB: length 4.1
  IN1 w0.254: v1(271.89,10.51) 272.13,10.51 272.38,10.26 v2(272.38,10.13) ; v2(272.13,7.91) 272.13,7.8 v1(272.77,7.16)
  IN2 w0.254: v2(272.38,10.13) 272.13,9.88 v2(272.13,7.91)
M_0_ALERT_N: length 4.1
  TOP w0.081: RH11.1 147.8,50.06 147.8,48.41
  TOP w0.089: UC1.BD46 147.68,46.57 147.68,46.84 147.8,46.96 147.8,48.41
M_1_ALERT_N: length 2.2
  TOP w0.081: RH13.2 131.67,49.19 131.72,49.14 UC1.M49
M_BIST: length 13.9
  TOP w0.081: UE1.N8 212.7,55.36 v1(212.55,55.22)
  IN1 w0.064: v2(208.45,54.72) 208.43,54.75 208.43,57.82 v2(208.08,58.16) ; v1(212.55,55.22) 212.35,55.01 v2(212.35,54.68)
  IN3 w0.064: v2(208.08,58.16) 207.26,58.99 v4(207.26,59.16) ; v2(212.35,54.68) 211.98,55.05 210.7,55.05 210.37,54.72 v2(208.45,54.72)
  BOTTOM w0.081: R273.1 205.01,60.37 205.14,60.25 205.51,60.25 206.6,59.16 v3(206.79,59.16) v4(207.26,59.16)
M_BITS_R: length 57.5
  TOP w0.081: QE25.2 v1(196.89,18.45)
  IN1 w0.064: v1(196.89,18.45) 197.07,18.64 197.07,25.9 196.25,26.71 196.25,30.38 196.38,30.5 196.38,31.6 197.19,32.41 197.19,36.55 196.53,37.21 196.53,44.77 197.64,45.88 197.64,46.62 197.64,46.62 197.64,46.76 199.69,48.82 200.29,48.82 201.28,48.82 201.45,48.98 203.32,48.98 205.65,51.3 205.65,53.76 207.55,55.67 207.55,56.62 207.23,56.93 206.75,56.93 206.65,57.03 206.65,58.15 206.98,58.48 v2(206.98,58.71)
  IN3 w0.064: v2(206.98,58.71) 206.98,59.32 207.37,59.71 207.37,60.92 206.94,61.35 206.24,61.35 v4(205.82,61.76)
  BOTTOM w0.081: R273.2 205.59,61.53 205.59,61.54 v4(205.82,61.76) 206.11,62.05 D481.2 206.76,61.35 C92.1 206.63,61.22 R272.2 R283.2
MBP2#: length 2.4
  TOP w0.081: UC1.T10 v5(133.32,28.83)
  BOTTOM w0.081: v3(134.08,29.59) RC723.2 133.84,28.83 v5(133.32,28.83)
MBP3#: length 1.2
  IN1 w0.064: v1(133.8,26.88) 133.52,27.16 v2(133.47,27.16)
  IN3 w0.064: v4(134.08,26.73) 133.65,27.16 v2(133.47,27.16)
MCSI_E_CLKN: length 228.6
  TOP w0.091: v5(164.19,82.29) 164.35,82.45 164.35,82.96 164,83.31 164,83.56 163.9,83.65 JUFC1.10
  IN1 w0.081: v2(127.96,29.54) 127.96,29.86 v1(127.99,29.89)
  IN3 w0.081: v5(163.85,78.9) 163.85,78.29 163.4,77.85 159.58,77.85 159.12,77.39 157.13,77.39 155.32,75.58 155.32,72.64 153.52,70.84 138.9,70.84 137.4,72.33 124.86,72.33 122.86,70.33 108.25,70.33 104.78,66.86 99.36,66.86 98.61,67.61 87.81,67.61 83.83,71.59 73.78,71.59 71.55,69.36 71.55,18.28 72.34,17.49 106.01,17.49 106.66,16.83 107.27,16.83 107.4,16.7 108.58,16.7 108.83,16.45 110.09,16.45 110.83,17.19 119.16,17.19 122.38,20.41 122.38,23.5 125.56,26.67 125.56,29.14 125.9,29.49 126.75,29.49 127.25,28.99 127.63,28.99 127.83,29.19 127.83,29.4 v2(127.96,29.54) 127.8,29.7 127.8,29.96 127.6,30.15 127.6,30.27 v4(127.81,30.48)
  BOTTOM w0.091: v5(163.85,78.9) 163.85,79.78 164.36,80.29 164.36,80.77 164.22,80.91 D444.2 163.99,81.19 164.12,81.32 164.31,81.32 164.4,81.41 164.4,82.09 v5(164.19,82.29)
MCSI_E_CLKP: length 228.6
  TOP w0.091: v5(164.78,82.29) 164.55,82.52 164.55,83.04 164.2,83.39 164.2,83.6 164.3,83.7 JUFC1.9
  IN1 w0.081: v2(127.43,29.55) 127.53,29.65 127.53,29.82 127.47,29.89 v1(127.34,29.89)
  IN3 w0.081: v4(127.23,30.48) 127.41,30.3 127.41,30.07 127.6,29.87 127.6,29.72 v2(127.43,29.55) 127.63,29.35 127.63,29.27 127.55,29.19 127.33,29.19 126.83,29.69 125.82,29.69 125.36,29.22 125.36,26.75 122.19,23.58 122.19,20.5 119.08,17.39 110.75,17.39 110.01,16.65 108.91,16.65 108.66,16.9 107.48,16.9 107.35,17.03 106.75,17.03 106.09,17.69 72.43,17.69 71.75,18.37 71.75,69.27 73.86,71.39 83.75,71.39 87.73,67.41 98.53,67.41 99.28,66.66 104.87,66.66 108.33,70.13 122.94,70.13 124.94,72.13 137.32,72.13 138.81,70.64 153.6,70.64 155.52,72.55 155.52,75.5 157.21,77.19 159.21,77.19 159.67,77.65 163.49,77.65 164.05,78.21 164.05,78.52 v5(164.43,78.9)
  BOTTOM w0.091: v5(164.43,78.9) 164.05,79.28 164.05,79.7 164.56,80.2 164.56,80.77 164.7,80.91 D445.2 165.01,81.19 164.88,81.32 164.69,81.32 164.6,81.41 164.6,82.12 v5(164.78,82.29)
MCSI_E_DN0: length 227.4
  TOP w0.091: v5(162.84,82.46) 163.03,82.65 163.03,82.98 162.78,83.23 162.78,83.54 162.7,83.62 JUFC1.13
  IN1 w0.081: v2(126.63,29.12) 126.56,29.19 126.56,29.76 v1(126.69,29.89)
  IN3 w0.081: v2(126.63,29.12) 126.46,28.95 126.46,28.28 126.28,28.11 126.28,26.57 125.94,26.22 125.94,26.05 126.13,25.86 126.13,25.58 125.84,25.29 125.56,25.29 125.37,25.48 125.2,25.48 125.08,25.36 125.08,25.2 125.27,25.01 125.27,24.73 124.98,24.44 124.7,24.44 124.57,24.57 124.45,24.57 124.22,24.34 v4(124.22,24.05) 124.01,24.05 122.97,23.01 122.97,20.17 119.4,16.61 111.08,16.61 110.34,15.86 108.59,15.86 108.34,16.12 107.15,16.12 107.02,16.25 106.42,16.25 105.76,16.9 72.1,16.9 70.96,18.04 70.96,69.6 73.54,72.17 84.07,72.17 88.05,68.19 98.85,68.19 99.53,67.52 100.79,67.52 100.96,67.69 104.79,67.69 108.05,70.95 122.2,70.95 124.16,72.91 137.76,72.91 139.21,71.47 153.33,71.47 154.74,72.88 154.74,75.82 156.89,77.97 158.88,77.97 159.34,78.43 162.16,78.43 162.33,78.6 v5(162.33,78.81)
  BOTTOM w0.091: v5(162.84,82.46) 163.03,82.27 163.03,82.05 162.55,81.57 162.55,81.32 D446.2 162.42,80.91 162.51,80.82 162.51,80.22 162.33,80.03 v5(162.33,78.81)
MCSI_E_DP0: length 227.4
  TOP w0.091: v5(163.42,82.46) 163.23,82.65 163.23,83.06 162.99,83.31 162.99,83.49 163.1,83.6 JUFC1.12
  IN1 w0.081: v1(126.04,29.89) 126.36,29.56 126.36,29.39 v2(126.09,29.12)
  IN3 w0.081: v5(162.91,78.81) 162.53,78.44 162.44,78.44 162.24,78.24 159.42,78.24 158.96,77.78 156.97,77.78 154.93,75.74 154.93,72.8 153.41,71.27 139.12,71.27 137.68,72.72 124.24,72.72 122.28,70.75 108.13,70.75 104.87,67.49 101.04,67.49 100.87,67.32 99.45,67.32 98.77,68 87.97,68 83.99,71.97 73.62,71.97 71.16,69.52 71.16,18.12 72.18,17.1 105.85,17.1 106.5,16.44 107.11,16.44 107.24,16.32 108.42,16.32 108.67,16.06 110.25,16.06 110.99,16.8 119.32,16.8 122.77,20.25 122.77,23.1 123.82,24.14 v4(123.82,24.46) 124.06,24.46 124.36,24.77 124.65,24.77 124.78,24.63 124.9,24.63 125.07,24.81 125.07,24.92 124.88,25.11 124.88,25.45 125.12,25.68 125.45,25.68 125.64,25.49 125.75,25.49 125.93,25.66 125.93,25.78 125.74,25.97 125.74,26.3 126.09,26.65 126.09,28.19 126.26,28.37 126.26,28.95 v2(126.09,29.12)
  BOTTOM w0.091: v5(162.91,78.81) 162.53,79.2 162.53,79.95 162.72,80.14 162.72,80.8 162.82,80.91 D447.2 162.76,81.32 162.76,81.49 163.23,81.96 163.23,82.27 v5(163.42,82.46)
ME_FWP: length 76.6
  IN1 w0.064: v1(215.9,61.16) v2(215.9,61.49)
  IN2 w0.051: v2(173.49,60.37) 173.51,60.4 177.62,60.4 177.82,60.2 179.88,60.2 180.75,59.32 182.02,59.32 183.13,58.21 188.18,58.21 189.19,57.2 190.83,57.2 192.8,59.17 200.33,59.17 201.21,58.29 207.37,58.29 207.78,58.7 208.91,58.7 209.32,58.29 210.83,58.29 211.07,58.05 211.75,58.05 212.3,58.6 213.47,58.6 213.85,58.98 213.85,59.56 215.77,61.49 v2(215.9,61.49)
  IN3 w0.064: v2(173.49,60.37) 173.49,60.13 174.68,58.95 175.12,58.95 176.68,57.39 176.68,56.95 176.85,56.77 176.85,55.68 176.23,55.05 176.23,53.3 176.85,52.67 176.85,52.21 175.48,50.84 175.05,50.84 174.73,50.52 174.69,50.52 174.2,50.03 173.89,50.03 173.48,49.61 173.48,49.12 172.87,48.51 171.19,48.51 170.95,48.27 170.95,47.79 170.76,47.6
  IN3 w0.081: v4(169.64,46.9) 170.06,46.9 170.76,47.6
  BOTTOM w0.081: RH218.1 165.84,50.68 166.12,50.4 166.12,50.1 165.37,49.35 165.37,47.93 166.09,47.22 v3(169.32,47.22) v4(169.64,46.9)
ME_FWP_PCH: length 1.7
  BOTTOM w0.081: v3(165.82,50.22) 165.7,50.1 RH218.2 164.92,49.44 RH217.1
ME_RESET#: length 4
  TOP w0.081: RC433.2 187.86,32.21 v3(188.58,32.21) 189.31,32.21 RC434.2 189.76,32.67 189.76,33.76 189.57,33.95 UC29.2
MEC_XTAL1: length 5.3
  TOP w0.081: UE1.A1 207.1,66.45 206.66,66.89 206.66,68.05 206.42,68.29 CE66.1 206.42,70.02 YE2.1
MEC_XTAL2: length 2.8
  TOP w0.081: YE2.2 207.66,70.15 CE89.1 RE178.2
MEC_XTAL2_R: length 2.3
  TOP w0.081: UE1.A3 208.7,68.05 RE178.1
MEDIACARD_IRQ#: length 2.2
  TOP w0.081: 159.54,48.41 159.76,48.63 v5(159.76,48.69)
  TOP w0.089: UC1.CH49 159.29,48.16 159.54,48.41
  BOTTOM w0.081: RC682.2 RH645.1 159.99,48.92 v5(159.76,48.69)
MEDIACARD_IRQ#_R: length 201
  IN1 w0.064: v2(206.78,25.22) 206.78,25.22 206.13,25.86 206.13,26.28 208.61,28.76 208.61,29.18 209.28,29.84 209.28,31.55 207.42,33.4 207.42,38.25 209.86,40.69 212.09,40.69 212.92,41.51 212.92,41.92 212.92,47.8 213.77,48.66 213.77,52.33 214.26,52.82 214.26,54.26 v2(214.04,54.49) ; v1(278.61,30.87) 279.1,30.87 v2(279.24,30.73)
  IN2 w0.051: v2(279.24,30.73) 279.24,29.25 276,26.01 276,25.11 276.23,24.89 276.23,20.47 276.13,20.36 276.13,20.3 274.62,18.79 274.62,17.65 272.07,15.1 272.07,13.74 269.11,10.78 267.76,10.78 266.74,9.76 265.24,9.76 264.65,9.18 264.65,7.72 262.62,5.69 253.05,5.69 251.29,7.45 249.1,7.45 248.05,6.4 236.03,6.4 234.25,4.62 227.93,4.62 220.86,11.7 215.56,11.7 212.9,14.35 212.9,16.76 209.48,20.18 209.48,24.32 208.58,25.22 206.79,25.22 v2(206.78,25.22) ; v2(161.03,48.46) 161.03,48.53 161.56,49.05 161.73,49.05 162.89,47.9 164.17,47.9 164.4,48.13 166.03,48.13 166.91,49.01 167.74,49.01 168.51,49.78 171.85,49.78 176.03,53.96 178.8,53.96 179.92,52.84 191.08,52.84 191.44,53.2 191.63,53.39 192.71,53.39 193.04,53.72 195.05,53.72 195.23,53.9 196.77,53.9 197.12,53.54 200.15,53.54 200.37,53.76 202.85,53.76 202.89,53.72 205.19,53.72 205.47,54 210.29,54 211.34,55.05 213.47,55.05 v2(214.04,54.49)
  IN3 w0.064: v4(160.57,49) 161.03,48.53 v2(161.03,48.46)
  BOTTOM w0.081: RH645.2 160.49,49.8 v3(160.87,49.41) 160.87,49.3 v4(160.57,49)
MEM_CONFIG0: length 10.8
  IN1 w0.064: v2(179.74,37.14) 178.67,37.14 177.63,38.18 176.9,38.18 176.4,38.68 175.54,38.68 174.56,37.7 172.8,37.7 v1(171.98,36.89)
  IN3 w0.064: v4(180.6,37.18) 180.56,37.14 v2(179.74,37.14)
  BOTTOM w0.081: RH612.2 v4(180.6,37.18)
MEM_CONFIG1: length 4.3
  TOP w0.081: RH613.2 RH139.1 176.8,37.61 175.66,37.61 175.17,38.11 174.64,38.11 174.57,38.14 174.02,38.14 173.63,38.53 UC1.DU30
MEM_CONFIG2: length 9.7
  IN1 w0.064: v1(172.81,38.53) 174.69,38.53 175.33,39.17 176.64,39.17 177.14,38.68 177.84,38.68 178.63,37.88 v2(178.95,37.88)
  IN3 w0.064: v2(178.95,37.88) 179.27,37.57 v4(179.61,37.57)
  BOTTOM w0.081: RH614.2 RH145.1 180.22,37.57 v4(179.61,37.57)
MEM_CONFIG3: length 4.9
  TOP w0.081: UC1.DT29 173.33,37.69 173.54,37.69 173.7,37.62 173.88,37.62 173.95,37.65 174.28,37.65 174.37,37.62 174.51,37.62 174.6,37.65 175.33,37.65 176.03,36.96 176.31,36.96 RH615.2 RH185.1
MEM_CONFIG4: length 13.1
  TOP w0.081: v1(181.83,38.51) 181.83,38.15 181.58,37.9 177.82,37.9 177.73,37.98 176.69,37.98 176.65,37.94 175.59,37.94 175.25,38.28 174.68,38.28 174.6,38.31 174.34,38.31 UC1.DV30
  IN1 w0.064: v1(181.83,38.51) 181.83,38.52 181.64,38.52 181.39,38.77 181.01,38.77 180.5,38.26 v2(179.6,38.26)
  IN3 w0.064: v2(179.6,38.26) 180.29,38.26 v4(180.37,38.35)
  BOTTOM w0.081: v4(180.37,38.35) 180.6,38.58 RH665.1 RH616.2
MEM_INTERLEAVED: length 6.6
  TOP w0.081: v1(177.98,26.9) RH629.1
  TOP w0.089: v1(174.35,29.6) 174.12,29.37 UC1.DV11
  IN1 w0.064: v2(174.47,30.24) 174.47,29.72 v1(174.35,29.6) ; v2(177.66,26.96) 177.72,26.9 v1(177.98,26.9)
  IN2 w0.051: v2(174.47,30.24) 174.47,30.15 v2(177.66,26.96)
MEM_PG: length 153.1
  TOP w0.081: v1(202.15,52.51) 202.15,51.95 202.31,51.79 v3(202.31,50.7) ; RD41.1 v1(82.61,71.22)
  IN1 w0.064: v1(202.15,52.51) 202.15,54.27 202.6,54.72 v2(202.6,55.8) ; v2(171.93,54.89) 171.7,55.12 170.66,55.12 170.43,54.89 170.07,54.89 169.85,55.11 169.85,55.44 170.18,55.77 170.18,61.57 170.72,62.11 170.72,66.93 167.5,70.15 165.45,70.15 164.01,71.59 155.91,71.59 155.09,70.78 153.49,70.78 152.85,71.41 143.42,71.41 143.35,71.34 136.79,71.34 135.93,70.48 126.01,70.48 125.76,70.74 120.81,70.74 120.25,70.18 118.32,70.18 117.6,70.9 110.1,70.9 104.68,65.47 98.85,65.47 98.26,66.06 95.74,66.06 95.57,66.23 94.71,66.23 93.61,65.12 89.31,65.12 87.72,66.72 87.72,68.49 84.73,71.48 82.87,71.48 v1(82.61,71.22)
  IN2 w0.051: v2(202.6,55.8) 202.23,56.17 194.96,56.17 194.91,56.22 193.39,56.22 192.32,55.15 182.12,55.15 181.56,54.59 180.39,54.59 180.37,54.57 178.71,54.57 176.16,57.12 174.76,57.12 174.61,56.97 173.13,56.97 172.61,56.45 172.61,55.96 171.93,55.27 v2(171.93,54.89)
MERGED_TRST_PD: length 2.8
  BOTTOM w0.081: R137.2 112.05,4.23 v3(111.76,4.52) 111.5,4.77 JMIPI60.8
MIC2-VREFO-L: length 3.2
  TOP w0.203: v5(31.26,20.6) 31.26,20.44 30.94,20.12 UA1.28
  BOTTOM w0.102: v6(31.15,22.2) 31.44,21.91 RA2.1
  BOTTOM w0.381: v5(31.26,20.6) 31.44,20.78 RA2.1
MIC2-VREFO-R:
  vias: v3(30.96,21.31)
MIPI60_CFG0#: length 53.7
  TOP w0.081: v5(111.13,8.02) v3(111.13,7.15)
  IN1 w0.064: v5(111.13,8.02) 111.52,8.41 115.05,8.41 115.42,8.04 117.35,8.04 118.42,9.11 122.92,9.11 127.31,13.5 132.08,13.5 136.18,17.59 136.18,18.39 139.39,21.59 139.39,26.79 v1(139.29,26.88)
  BOTTOM w0.081: R160.1 R140.2 112.88,15.12 R230.2 112.63,14.21 113.33,14.21 113.52,14.01 113.72,14.01 114.5,13.23 JMIPI60.19 114.5,10.72 113.89,10.11 111.53,10.11 110.6,9.18 110.6,8.55 v5(111.13,8.02)
MIPI60_CFG1#: length 52.7
  TOP w0.081: v5(111.07,8.61) v3(111.07,9.4)
  IN1 w0.064: v1(138.37,27.53) 138.46,27.45 138.46,27.09 139.06,26.49 139.06,21.73 135.85,18.53 135.85,17.73 132.4,14.29 130.49,14.29 130.34,14.14 130.34,13.89 130.28,13.83 127.18,13.83 122.79,9.44 118.28,9.44 117.21,8.37 116.17,8.37 115.66,8.88 113.27,8.88 113,8.61 v5(111.07,8.61)
  BOTTOM w0.081: v5(111.07,8.61) 111.22,8.77 111.22,9.54 111.6,9.93 113.97,9.93 114.42,10.38 114.84,10.38 115,10.54 JMIPI60.21 115,12.99 113.8,14.2 113.6,14.2 113.5,14.29 113.5,14.8 R141.2 R161.1
MIPI60_CFG2#: length 52.2
  IN1 w0.064: v5(112.44,7.9) 112.78,8.24 114.98,8.24 115.35,7.87 117.42,7.87 118.49,8.94 122.99,8.94 127.38,13.33 132.15,13.33 136.34,17.53 136.34,18.32 139.55,21.53 139.55,27.28 139.3,27.53 v1(139.29,27.53)
  BOTTOM w0.081: v5(112.44,7.9) 112.27,7.9 111.4,8.77 111.4,9.47 111.68,9.74 114.05,9.74 114.5,10.2 115.15,10.2 115.5,10.55 JMIPI60.23 115.5,12.96 v3(114.75,13.71) 114.21,14.26 114.21,14.74 R142.2 R162.1
MIPI60_CFG3#: length 55.5
  TOP w0.081: v1(137.67,28.44) 137.62,28.39 137.62,28.38 UC1.AD9 ; v5(113,7.88) v3(113,7.28)
  IN1 w0.064: v1(137.67,28.44) 138.75,28.44 139.72,27.47 139.72,21.46 136.51,18.25 136.51,17.46 132.22,13.17 127.45,13.17 123.06,8.78 118.56,8.78 117.22,7.43 113.87,7.43 113.43,7.88 v5(113,7.88)
  BOTTOM w0.081: R163.1 R143.2 114.97,14.75 114.97,14.19 116,13.16 JMIPI60.25 116,10.79 115.23,10.01 114.57,10.01 114.12,9.56 111.76,9.56 111.59,9.39 111.59,8.84 112.02,8.41 112.47,8.41 v5(113,7.88)
MIPI60_CFG4#: length 48.9
  IN1 w0.064: v2(115.41,8.55) 115.76,8.55 116.11,8.2 117.28,8.2 118.35,9.27 122.85,9.27 127.25,13.66 130.43,13.66 130.5,13.74 130.5,14.05 130.58,14.12 130.68,14.12 130.76,14.05 130.76,13.74 130.83,13.66 130.94,13.66 131.01,13.74 131.01,14.05 131.09,14.12 131.19,14.12 131.27,14.05 131.27,13.74 131.34,13.66 131.45,13.66 131.52,13.74 131.52,14.05 131.59,14.12 131.7,14.12 131.77,14.05 131.77,13.74 131.85,13.66 131.96,13.66 132.02,13.73 132.02,14.06 132.09,14.12 132.47,14.12 136.01,17.66 136.01,18.46 139.22,21.66 139.22,26.58 139.03,26.77 139.03,27.93 138.77,28.18 v1(138.37,28.18)
  IN3 w0.064: v4(114.5,9.56) 115.41,8.65 v2(115.41,8.55)
  BOTTOM w0.081: v4(114.5,9.56) 114.77,9.83 115.49,9.83 116.5,10.84 JMIPI60.27 116.5,13.46 v3(116.25,13.71) 115.73,14.24 115.73,14.74 R144.2 R164.1
MIPI60_CFG5#: length 48.7
  IN1 w0.064: v1(136.55,28.18) 137.37,28.18 137.52,28.03 137.52,27.12 137.9,26.75 138.57,26.75 138.89,26.43 138.89,21.8 135.68,18.59 135.68,17.8 132.34,14.45 130.25,14.45 130.17,14.38 130.17,14.07 130.1,13.99 129.99,13.99 129.92,14.07 129.92,14.38 129.85,14.45 129.74,14.45 129.67,14.38 129.67,14.07 129.59,13.99 129.49,13.99 129.41,14.07 129.41,14.38 129.34,14.45 129.23,14.45 129.16,14.38 129.16,14.07 129.08,13.99 128.98,13.99 128.9,14.07 128.9,14.38 128.83,14.45 128.72,14.45 128.65,14.38 128.65,14.07 128.58,13.99 128.47,13.99 128.4,14.07 128.4,14.38 128.32,14.45 128.22,14.45 128.14,14.38 128.14,14.07 128.07,13.99 127.93,13.99 127.85,14.07 127.85,14.38 127.78,14.45 127.67,14.45 127.6,14.38 127.6,14.07 127.53,13.99 127.11,13.99 122.72,9.6 118.21,9.6 117.14,8.53 116.66,8.53 v2(116.49,8.7)
  IN3 w0.064: v4(116.11,9.56) 116.11,8.89 116.3,8.7 v2(116.49,8.7)
  BOTTOM w0.081: R165.1 R145.2 116.49,14.74 116.49,14.01 117,13.49 JMIPI60.29 117,11.09 116.11,10.19 v4(116.11,9.56)
MIPI60_CFG6#: length 49.6
  IN1 w0.064: v2(117.76,7.46) 117.77,7.46 117.77,7.75 118.63,8.61 119.69,8.61 119.76,8.54 119.76,7.86 119.84,7.79 119.94,7.79 120.02,7.86 120.02,8.54 120.09,8.61 120.2,8.61 120.27,8.54 120.27,7.86 120.34,7.79 120.45,7.79 120.52,7.86 120.52,8.54 120.6,8.61 120.7,8.61 120.78,8.54 120.78,7.86 120.85,7.79 120.96,7.79 121.03,7.86 121.03,8.54 121.11,8.61 121.21,8.61 121.29,8.54 121.29,7.86 121.36,7.79 121.47,7.79 121.54,7.86 121.54,8.54 121.61,8.61 123.13,8.61 127.52,13 132.29,13 136.67,17.39 136.67,18.18 139.88,21.39 139.88,26.65 140.11,26.88 v1(140.2,26.88)
  IN3 w0.064: v2(117.76,7.46) v4(117.76,7.79)
  BOTTOM w0.081: R166.1 R146.2 117.32,14.81 117.32,14.79 117.31,14.79 117.31,13.56 117.5,13.38 JMIPI60.31 117.5,10.83 116.57,9.89 116.57,8.78 116.87,8.48 117.07,8.48 v4(117.76,7.79)
MIPI60_CFG7#: length 49.2
  TOP w0.081: UC1.AB7 v1(137.07,27.53)
  IN1 w0.064: v1(137.07,27.53) 137.07,27.95 137.13,28.02 137.3,28.02 137.36,27.95 137.36,27.05 138.12,26.3 138.22,26.3 138.45,26.53 138.56,26.53 138.63,26.45 138.63,26.35 138.4,26.12 138.4,26.01 138.72,25.69 138.72,21.87 135.22,18.37 135.22,18.26 135.52,17.97 135.52,17.87 135.4,17.75 135.3,17.75 135.04,18.01 134.94,18.01 134.86,17.94 134.86,17.83 135.12,17.58 135.12,17.47 134.29,16.64 134.16,16.64 134.06,16.73 133.96,16.73 133.85,16.62 133.85,16.51 133.96,16.4 133.96,16.31 133.86,16.21 133.77,16.21 133.65,16.33 133.55,16.33 133.45,16.23 133.45,16.12 133.56,16.01 133.56,15.91 133.48,15.83 133.38,15.83 133.27,15.94 133.16,15.94 133.09,15.87 133.09,15.76 133.2,15.65 133.2,15.55 133.12,15.47 133.02,15.47 132.91,15.58 132.8,15.58 132.73,15.51 132.73,15.4 132.84,15.29 132.84,15.19 132.76,15.11 132.66,15.11 132.55,15.22 132.45,15.22 132.37,15.15 132.37,15.04 132.48,14.93 132.48,14.83 132.4,14.75 132.3,14.75 132.19,14.86 132.09,14.86 131.84,14.62 127.5,14.62 122.65,9.77 119.29,9.77 119.21,9.84 119.21,10.22 119.14,10.29 119.03,10.29 118.96,10.22 118.96,9.84 118.88,9.77 118.78,9.77 118.7,9.84 118.7,10.22 118.63,10.29 118.52,10.29 118.45,10.22 118.45,9.84 118.37,9.77 117.44,9.77 117.38,9.7 v2(117.38,9.24)
  IN3 w0.064: v2(117.38,9.24) 117.31,9.31 v4(117.31,9.63)
  BOTTOM w0.081: v4(117.31,9.63) 117.08,9.63 116.99,9.71 116.99,9.95 117.08,10.03 117.75,10.03 118,10.29 JMIPI60.33 118,13.46 v3(117.75,13.71) 118,13.97 118,14.73 R147.2 R167.1
MIPI60_CFG8#: length 49.2
  IN1 w0.064: v2(116.89,9.08) 116.47,9.08 116.4,9.14 116.4,9.49 116.62,9.71 117.08,9.71 117.14,9.77 117.14,10.21 117.2,10.27 117.36,10.27 117.42,10.21 117.42,10 117.48,9.93 117.61,9.93 117.67,10 117.67,10.4 117.74,10.46 117.88,10.46 117.95,10.39 117.95,10.01 118.03,9.93 118.13,9.93 118.21,10.01 118.21,10.39 118.28,10.46 119.37,10.46 119.51,10.33 119.51,10 119.57,9.93 122.58,9.93 127.43,14.78 131.77,14.78 133.71,16.72 133.71,16.72 133.96,16.97 134.38,16.97 134.7,17.28 134.7,18.07 134.73,18.11 134.73,18.21 134.45,18.49 134.45,18.6 134.53,18.67 134.63,18.67 134.91,18.39 135.02,18.39 138.56,21.94 138.56,25.62 137.18,27 137.18,27.05 136.09,28.14 135.96,28.14 135.89,28.2 135.89,28.2 135.36,28.74 134.81,28.74 v1(134.71,28.83)
  IN3 w0.064: v2(116.89,9.08) 116.88,9.07 116.88,8.98 v4(117.06,8.8)
  BOTTOM w0.081: v4(117.06,8.8) 117.24,8.97 117.43,8.97 117.57,9.12 117.57,9.54 118.5,10.48 JMIPI60.35 118.5,13.42 118.78,13.69 118.78,14.74 R148.2 R168.1
MIPI60_CFG9#: length 48.8
  IN1 w0.064: v1(140.2,26.23) 140.05,26.07 140.05,21.32 136.84,18.11 136.84,17.32 132.36,12.84 127.59,12.84 123.2,8.45 121.77,8.45 121.7,8.38 121.7,7.19 121.61,7.1 121.51,7.1 121.44,7.17 121.44,7.55 121.36,7.62 121.26,7.62 121.18,7.55 121.18,7.17 121.11,7.1 121,7.1 120.93,7.17 120.93,7.55 120.85,7.62 120.75,7.62 120.67,7.55 120.67,7.17 120.6,7.1 120.48,7.1 120.42,7.16 120.42,7.55 120.34,7.62 119.65,7.62 119.6,7.67 119.6,8.38 119.53,8.45 119.37,8.45 119.29,8.37 119.29,7.69 119.23,7.62 119.14,7.62 119.07,7.7 119.07,8.35 118.96,8.45 118.8,8.45 118.74,8.38 118.74,7.94 118.68,7.87 118.17,7.87 118.1,7.81 118.1,7.63 v2(118.27,7.46)
  IN3 w0.064: v2(118.27,7.46) v4(118.27,7.79)
  BOTTOM w0.081: R169.1 R149.2 119.54,14.74 119.54,14.01 v3(119.25,13.71) 119,13.47 JMIPI60.37 119,10.72 117.75,9.47 117.75,8.74 117.96,8.54 117.96,8.1 v4(118.27,7.79)
MIPI60_CFG10#: length 49.6
  TOP w0.081: v5(119.87,10.3) v3(119.35,10.3)
  IN1 w0.064: v5(119.87,10.3) 120.02,10.46 120.32,10.46 120.39,10.39 120.39,10.16 120.45,10.1 122.51,10.1 127.36,14.95 131.7,14.95 133.24,16.49 133.24,16.74 133.06,16.92 133.06,17.43 133.52,17.89 133.62,17.89 133.7,17.81 133.81,17.81 133.88,17.89 133.88,17.99 133.8,18.07 133.8,18.18 134.63,19.01 134.73,19.01 135.01,18.73 135.12,18.73 135.19,18.8 135.19,18.91 134.91,19.19 134.91,19.29 134.99,19.37 135.09,19.37 135.37,19.09 135.48,19.09 135.55,19.16 135.55,19.27 135.27,19.55 135.27,19.65 135.35,19.72 135.45,19.72 135.73,19.45 135.84,19.45 135.91,19.52 135.91,19.63 135.63,19.9 135.63,20.01 135.71,20.08 135.81,20.08 136.09,19.81 136.2,19.81 136.56,20.17 136.56,20.28 136.28,20.56 136.28,20.66 137.02,21.4 137.11,21.4 137.41,21.11 137.5,21.11 137.61,21.23 137.61,21.33 137.34,21.61 137.34,21.71 137.41,21.79 137.52,21.79 137.79,21.51 137.9,21.51 137.97,21.58 137.97,21.69 137.7,21.97 137.7,22.07 137.77,22.15 137.88,22.15 138.15,21.87 138.26,21.87 138.37,21.98 138.37,22.08 138.09,22.35 138.09,22.47 138.39,22.77 138.39,25.55 137.01,26.93 137.01,26.98 136.02,27.97 135.89,27.97 135.82,28.04 135.82,28.04 135.29,28.57 134.61,28.57 134.45,28.72 134.45,28.99 134.6,29.13 134.98,29.13 135.05,29.06 135.05,28.98 135.13,28.9 135.23,28.9 135.31,28.98 135.31,29.06 135.38,29.13 135.57,29.13 135.63,29.07 v1(135.63,28.83)
  BOTTOM w0.081: v5(119.87,10.3) 119.68,10.12 119.1,10.12 119.02,10.2 119.02,10.48 119.5,10.96 JMIPI60.39 119.5,13.08 120.37,13.94 120.37,14.67 120.81,15.11 R150.2 R170.1
MIPI60_CFG11#: length 49.2
  IN1 w0.064: v1(140.2,27.53) 140.36,27.53 140.47,27.42 140.47,26.12 140.21,25.87 140.21,21.25 137.01,18.05 137.01,17.25 132.43,12.67 127.66,12.67 123.14,8.15 123.14,7.53 123.08,7.47 122.66,7.47 122.59,7.54 122.59,8.18 122.5,8.28 121.99,8.28 121.87,8.16 121.87,7.04 121.76,6.93 120.31,6.93 120.25,7 120.25,7.4 120.19,7.46 120.05,7.46 119.98,7.4 119.98,7.03 119.92,6.97 119.78,6.97 119.7,7.05 119.7,7.4 119.64,7.46 v2(118.78,7.46)
  IN3 w0.064: v2(118.78,7.46) v4(118.78,7.79)
  BOTTOM w0.081: R171.1 R151.2 121.51,15.11 121.19,14.79 121.19,14.16 v3(120.75,13.71) 120.58,13.71 120,13.14 JMIPI60.41 120,10.88 120.24,10.64 120.24,10.07 120.1,9.93 118.48,9.93 117.94,9.39 117.94,8.84 118.78,8 v4(118.78,7.79)
MIPI60_CFG12#: length 49.8
  TOP w0.081: v5(120.75,10.46) v3(121.25,10.46)
  IN1 w0.064: v5(120.75,10.46) 120.94,10.26 121.33,10.26 121.41,10.34 121.41,10.39 121.48,10.46 121.59,10.46 121.66,10.39 121.66,10.34 121.74,10.26 121.84,10.26 121.92,10.34 121.92,10.39 121.99,10.46 122.1,10.46 122.17,10.39 122.17,10.34 122.24,10.26 122.44,10.26 123.27,11.09 123.27,11.24 123.12,11.39 123.12,11.49 123.19,11.55 123.28,11.55 123.45,11.38 123.56,11.38 123.63,11.45 123.63,11.56 123.47,11.73 123.47,11.83 123.54,11.91 123.65,11.91 123.81,11.74 123.92,11.74 123.99,11.81 123.99,11.92 123.83,12.09 123.83,12.19 123.9,12.27 124,12.27 124.17,12.1 124.28,12.1 124.35,12.17 124.35,12.31 124.2,12.46 124.2,12.57 124.27,12.63 124.36,12.63 124.53,12.46 124.64,12.46 124.71,12.53 124.71,12.68 124.56,12.82 124.56,12.93 124.63,12.99 124.72,12.99 124.89,12.82 125,12.82 125.07,12.89 125.07,13 124.9,13.16 124.9,13.27 124.98,13.34 125.08,13.34 125.25,13.18 125.36,13.18 125.43,13.25 125.43,13.39 125.28,13.54 125.28,13.65 125.35,13.71 125.44,13.71 125.61,13.54 125.72,13.54 125.79,13.61 125.79,13.75 125.64,13.9 125.64,14.01 125.71,14.07 125.8,14.07 125.97,13.9 126.08,13.9 126.15,13.97 126.15,14.08 125.98,14.24 125.98,14.35 126.06,14.42 126.16,14.42 126.33,14.26 126.44,14.26 126.51,14.33 126.51,14.47 126.36,14.62 126.36,14.73 126.42,14.79 126.51,14.79 126.69,14.62 126.8,14.62 126.87,14.69 126.87,14.82 126.72,14.98 126.72,15.08 126.78,15.15 126.87,15.15 127.05,14.98 127.15,14.98 127.41,15.23 128.19,15.23 128.32,15.11 131.63,15.11 132.89,16.37 132.89,17.5 135.68,20.29 135.84,20.29 136.09,20.04 136.2,20.04 136.32,20.16 136.32,20.29 136.04,20.56 136.04,20.65 138.23,22.84 138.23,25.48 136.85,26.86 136.85,26.91 135.96,27.81 135.83,27.81 135.76,27.87 135.75,27.87 135.22,28.41 134.54,28.41 134.29,28.65 134.29,29.05 134.53,29.3 135.84,29.3 135.92,29.22 135.92,28.94 135.98,28.88 136.09,28.88 136.17,28.95 136.17,29.22 136.24,29.3 136.46,29.3 136.55,29.21 v1(136.55,28.83)
  BOTTOM w0.081: v5(120.75,10.46) 120.5,10.7 JMIPI60.43 120.5,12.88 121.89,14.26 121.89,14.8 R152.2 R172.1
MIPI60_CFG13#: length 49.6
  IN1 w0.064: v1(141.12,27.53) 141.12,27.86 141.06,27.93 140.69,27.93 140.63,27.86 140.63,26.05 140.38,25.8 140.38,23.33 140.45,23.26 140.57,23.26 140.65,23.18 140.65,23.08 140.57,23 140.45,23 140.38,22.93 140.38,22.82 140.45,22.75 140.57,22.75 140.65,22.67 140.65,22.57 140.57,22.49 140.45,22.49 140.38,22.42 140.38,22.31 140.45,22.24 140.57,22.24 140.65,22.17 140.65,22.06 140.57,21.99 140.45,21.99 140.38,21.91 140.38,21.81 140.45,21.73 140.57,21.73 140.65,21.66 140.65,21.55 140.57,21.48 140.45,21.48 140.38,21.4 140.38,21.18 137.17,17.98 137.17,17.18 132.5,12.51 132.11,12.51 132.04,12.43 132.04,12.05 131.96,11.97 131.86,11.97 131.78,12.05 131.78,12.43 131.71,12.51 131.6,12.51 131.53,12.43 131.53,12.05 131.45,11.97 131.35,11.97 131.27,12.05 131.27,12.43 131.2,12.51 131.09,12.51 131.02,12.43 131.02,12.05 130.95,11.97 130.84,11.97 130.77,12.05 130.77,12.43 130.69,12.51 130.59,12.51 130.51,12.43 130.51,12.05 130.44,11.97 130.33,11.97 130.26,12.05 130.26,12.43 130.18,12.51 130.08,12.51 130,12.43 130,12.05 129.93,11.97 129.82,11.97 129.75,12.05 129.75,12.43 129.68,12.51 129.57,12.51 129.5,12.43 129.5,12.05 129.42,11.97 129.32,11.97 129.24,12.05 129.24,12.43 129.17,12.51 129.06,12.51 128.99,12.43 128.99,12.05 128.91,11.97 128.81,11.97 128.73,12.05 128.73,12.43 128.66,12.51 128.55,12.51 128.48,12.43 128.48,12.05 128.41,11.97 128.3,11.97 128.23,12.05 128.23,12.43 128.15,12.51 127.73,12.51 127.62,12.4 127.62,12.05 127.54,11.97 127.19,11.97 123.54,8.32 123.54,8.08 v2(123.48,8.02)
  IN3 w0.064: v2(123.48,8.02) 123.47,8.02 123.33,8.16 v4(123.33,8.94)
  BOTTOM w0.081: v4(123.33,8.94) 123.33,9.2 122.45,10.08 121.82,10.08 121,10.89 JMIPI60.45 121,13.06 122.08,14.13 122.37,14.13 122.59,14.35 122.59,14.74 R153.2 R173.1
MIPI60_CFG14#: length 49.9
  IN1 w0.064: v1(141.12,28.18) 141.38,27.92 141.38,27.33 141.32,27.27 140.88,27.27 140.81,27.21 140.81,26.57 140.89,26.49 141.3,26.49 141.37,26.42 141.37,26.31 141.3,26.24 140.89,26.24 140.81,26.16 140.81,26.06 140.89,25.98 141.3,25.98 141.37,25.91 141.37,25.78 141.3,25.71 140.62,25.71 140.54,25.64 140.54,25.53 140.62,25.46 141.31,25.46 141.38,25.38 141.38,25.27 141.31,25.19 140.62,25.19 140.54,25.12 140.54,25.01 140.62,24.94 140.74,24.94 140.81,24.86 140.81,24.76 140.74,24.68 140.62,24.68 140.54,24.61 140.54,24.51 140.62,24.43 140.74,24.43 140.81,24.36 140.81,24.25 140.74,24.18 140.62,24.18 140.54,24.1 140.54,24 140.62,23.92 140.74,23.92 140.81,23.85 140.81,23.74 140.74,23.67 140.62,23.67 140.54,23.59 140.54,23.49 140.62,23.41 140.74,23.41 140.81,23.34 140.81,21.39 137.34,17.91 137.34,17.11 132.03,11.81 128.14,11.81 128.06,11.89 128.06,12.28 128,12.34 127.85,12.34 127.78,12.28 127.78,11.89 127.71,11.81 127.28,11.81 125.86,10.39 125.86,10.29 126.12,10.03 126.12,9.93 126.04,9.85 125.94,9.85 125.68,10.11 125.58,10.11 125.5,10.03 125.5,9.93 125.76,9.67 125.76,9.57 125.68,9.49 125.58,9.49 125.32,9.75 125.22,9.75 125.14,9.67 125.14,9.57 125.4,9.31 125.4,9.21 125.32,9.13 125.22,9.13 124.96,9.39 124.86,9.39 124.4,8.93 124.4,7.94 124.34,7.87 124.01,7.87 123.95,7.94 v2(123.95,8.26)
  IN3 w0.064: v2(123.95,8.26) 123.74,8.46 v4(123.74,9.31)
  BOTTOM w0.081: v4(123.74,9.31) 122.79,10.26 122.08,10.26 121.5,10.84 JMIPI60.47 121.5,13.11 122.1,13.71 v3(122.24,13.71) 122.66,14.13 123.13,14.13 123.35,14.35 123.35,14.74 R154.2 R174.1
MIPI60_CFG15#: length 50.4
  IN1 w0.064: v1(140.2,28.18) 139.67,28.18 139.61,28.24 139.61,28.76 139.67,28.83 139.84,28.83 139.91,28.75 139.91,28.52 139.99,28.45 140.09,28.45 140.17,28.52 140.17,28.75 140.24,28.83 140.44,28.83 140.51,28.75 140.51,28.24 140.59,28.17 140.69,28.17 140.77,28.24 140.77,28.73 140.84,28.8 141,28.8 141.08,28.73 141.08,28.55 141.15,28.47 141.26,28.47 141.33,28.55 141.33,28.73 141.41,28.8 141.66,28.8 141.73,28.74 141.73,27.1 141.66,27.03 141.06,27.03 140.99,26.96 140.99,26.85 141.06,26.78 141.47,26.78 141.55,26.7 141.55,25.17 140.98,24.6 140.98,21.32 137.5,17.84 137.5,17.05 132.1,11.64 128.12,11.64 127.81,11.34 127.71,11.34 127.45,11.6 127.34,11.6 127.27,11.52 127.27,11.42 127.53,11.16 127.53,11.05 127.45,10.98 127.35,10.98 127.07,11.26 126.96,11.26 126.89,11.18 126.89,11.08 127.17,10.8 127.17,10.69 127.09,10.62 126.99,10.62 126.71,10.9 126.6,10.9 126.53,10.82 126.53,10.72 126.81,10.44 126.81,10.33 126.73,10.26 126.63,10.26 126.35,10.54 126.24,10.54 126.17,10.46 126.17,10.36 126.45,10.08 126.45,9.97 125.12,8.64 125.03,8.64 v2(124.81,8.86)
  IN3 w0.064: v2(124.81,8.86) 124.7,8.98 v4(124.7,9.62)
  BOTTOM w0.081: v4(124.7,9.62) 123.7,9.62 122.8,10.51 122.4,10.51 122,10.91 JMIPI60.49 122,13.23 122.11,13.34 122.49,13.34 123.1,13.95 123.21,13.95 123.45,14.2 123.96,14.2 124.11,14.35 124.11,14.74 R155.2 R175.1

# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PS2_CLK1B_TP: length 91.4
  TOP w0.081: JIO1.40 255.35,9.53 256.13,10.31 256.13,10.73 D50.2 256.89,10.98 v1(257.02,10.86) ; RE467.1 v1(220.09,64.5)
  IN1 w0.064: v1(257.02,10.86) 256.76,11.12 256.76,11.85 254.42,14.19 247.42,14.19 244.92,11.69 239.12,11.69 238.67,12.14 232.17,12.14 231.73,12.58 228.81,12.58 224.01,17.38 224.01,22.8 220.36,26.45 220.36,42.94 220.92,43.5 220.92,52.55 221.09,52.71 221.09,59.9 220.2,60.78 220.2,64.39 v1(220.09,64.5)
PS2_DAT1B_TP: length 90.8
  TOP w0.081: v1(254.99,10.98) 255.11,10.86 C1226.1 255.95,10.53 255.95,10.39 255.44,9.88 254.99,9.88 254.75,9.64 JIO1.38
  IN1 w0.064: v1(219.46,65.13) 219.63,65.13 219.83,64.93 219.83,64.39 220.04,64.18 220.04,60.72 220.92,59.83 220.92,52.78 220.76,52.61 220.76,43.57 220.19,43.01 220.19,26.38 223.85,22.73 223.85,17.31 228.74,12.41 231.66,12.41 232.1,11.97 238.6,11.97 239.05,11.52 244.99,11.52 247.49,14.03 253.52,14.03 255.25,12.3 255.25,11.24 v1(254.99,10.98)
PWM1: length 21.5
  IN1 w0.254: 100.58,35.58 98.98,35.58 97.58,36.98 93.95,36.98 93.66,37.27 93.66,44.59 92.45,45.79 92.45,47.5 92.7,47.75 95.47,47.75
  vias: v1(95.73,47.75) v1(96.36,47.76) v1(100.58,35.56) v1(100.87,35.53)
PWM2: length 31.9
  IN1 w0.254: v1(100.58,26.41) 100.55,26.41 100.3,26.67 95.52,26.67 93.92,28.27 93.92,36.5 93.3,37.13 93.3,44.44 91.82,45.93 91.82,47.85 92.37,48.41 95.45,48.41 v1(95.57,48.28)
  vias: v1(96.36,48.16) v1(100.83,26.21)
PWM_FAN1: length 213.8
  TOP w0.081: JFAN1.2 63.95,3.4 64.27,3.71 64.27,8.59 65.67,9.99 v1(65.67,13.63) ; v1(213.84,58.27) 214.16,57.96 UE1.L10
  IN1 w0.064: v2(87.58,9.15) 87.55,9.17 86.48,9.17 85.8,8.5 84.73,8.5 84.54,8.69 83.87,8.69 82.42,7.24 79.15,7.24 76.6,9.79 73.96,9.79 72.8,10.95 70.78,10.95 68.23,13.5 65.79,13.5 v1(65.67,13.63) ; v2(213.3,55.7) 213.3,56.36 214,57.06 214,58.12 v1(213.84,58.27)
  IN2 w0.051: v2(87.58,9.15) 88.17,9.15 88.89,9.88 88.89,10.9 90.42,12.43 90.42,46.35 91.56,47.49 97.58,47.49 98.11,48.02 99.67,48.02 102.94,51.29 108.55,51.29 108.99,51.73 110.5,51.73 111.06,51.17 113.55,51.17 114.81,52.42 128.36,52.42 128.69,52.75 129.52,52.75 129.85,52.42 130.48,52.42 130.9,52.84 144.18,52.84 144.29,52.73 150.55,52.73 150.65,52.84 155.28,52.84 155.78,52.34 165.53,52.34 167.14,53.95 167.14,55.22 167.85,55.93 169.15,55.93 170.05,56.84 170.05,57.23 170.57,57.75 172.18,57.75 172.47,58.03 173.72,58.03 174.51,58.82 176.07,58.82 178.06,56.84 187.8,56.84 188.72,55.92 191.27,55.92 192.81,57.46 194.54,57.46 195.2,56.79 204.49,56.79 204.69,57 205.83,57 206.71,56.13 209.49,56.13 210.12,55.5 211.05,55.5 211.58,56.04 212.97,56.04 v2(213.3,55.7)
  IN3 w0.064: v2(213.3,55.7) 213.3,55.46 v4(213.46,55.31)
  BOTTOM w0.081: v6(213.03,55.4) 213.05,55.37 213.39,55.37 v4(213.46,55.31)
PWM_FAN2: length 88.3
  TOP w0.081: v5(226.54,22.61) 225.52,22.61 224.08,21.16 224.08,7.4 224.75,6.74 225.43,6.74 227.41,8.72 229.48,8.72 229.91,8.29 232.06,8.29 232.31,8.05 232.31,6.78 234.99,4.09 234.99,4.09 236.48,2.6 R39.1 236.59,2.01 237.46,1.13 237.8,1.13 238.15,1.48 JFAN2.2
  IN1 w0.064: v1(215.1,57.96) 215.42,58.29 v2(215.42,58.29)
  IN3 w0.064: v2(215.42,58.29) 215.7,58.29 217.32,59.91 218.35,59.91 218.78,59.49 218.78,52.62 218.17,52.01 218.17,51.15 217.99,50.98 217.99,47.83 215.06,44.89 215.06,38.21 216.64,36.63 219.26,36.63 220.87,35.02 220.87,33.25 220.87,33.24 220.87,27.43 225.69,22.61 v5(226.54,22.61)
  BOTTOM w0.081: v5(226.54,22.61) 226.56,22.61 226.6,22.57 226.6,22.2 v6(226.79,22.01)
PWRBTN#: length 304.9
  TOP w0.081: v5(56.17,16.48) 56.17,15.28 58.87,12.58 58.87,12.06 61.88,9.05 61.88,7.59 v1(62.9,6.58) ; RE187.1 v1(200.79,63.85) ; v5(68.1,23.79) 67.28,23.79 66.96,24.1 SW1.1 v5(66.96,26.01) SW1.3 ; v1(84.49,4.71) 83.9,5.3 PD600.1
  IN1 w0.064: v2(201.64,61.77) 200.79,62.62 v1(200.79,63.85) 200.63,64.02 200.63,66.97 v2(201.45,67.79) ; v1(84.49,4.71) 84.46,4.74 82.2,4.74 81.01,3.55 75.65,3.55 71.76,7.45 65.8,7.45 64.93,6.58 v1(62.9,6.58)
  IN2 w0.051: v2(201.45,67.79) 201.39,67.86 198.42,67.86 197.67,67.11 195.57,67.11 195.37,67.31 189.52,67.31 189.31,67.52 179.3,67.52 176.34,70.48 174.54,70.48 173.7,71.32 171.41,71.32 168.11,74.62 167.96,74.62 167.96,74.62 154.81,74.62 154.63,74.43 152.82,72.63 145.57,72.63 140.13,78.07 133.61,78.07 130.69,80.98 130.69,82.61 129.85,83.45 124.64,83.45 123.67,82.48 123.67,81.79 121.8,79.92 121.8,77.56 119.27,75.02 100.42,75.02 94.84,69.44 89.44,69.44 88.04,70.84 73.5,70.84 71.38,68.72 71.38,24.81 71.38,24.52 68.17,21.31 67.9,19.96 65.54,17.6 62.55,17.6 62.14,17.18 56.87,17.18 v5(56.17,16.48)
  IN3 w0.064: v2(201.64,61.77) 202.37,62.51 205.56,62.51 206.53,61.53 206.99,61.53 207.54,60.98 207.54,59.19 207.89,58.84 210.68,58.84 211.29,59.45 213.66,59.45 214.06,59.06 214.06,57.92 214.78,57.2 215.13,57.2 215.3,57.37 215.58,57.37 215.99,57.77 v4(217.14,57.77)
  BOTTOM w0.081: JAPS1.11 v4(217.14,57.77) ; SW1.1 v5(66.96,26.01) SW1.3 ; v5(68.1,23.79) v6(68.1,22.26) 68.1,20.52 65.6,18.01 56.92,18.01 56.69,17.78 QF1.1 56.69,16.79 56.76,16.71 R208.2 v5(56.17,16.48)
PWRBTN#_FPR: length 7.4
  TOP w0.081: v6(58.6,13.6) 58.11,13.6 57.06,14.65 v8(57.06,15.99) 57.06,17.5 57.41,17.85 JFP1.7
  IN1 w0.064: v8(57.06,15.99) 56.99,16.05 v2(56.99,16.48)
  IN3 w0.064: v9(57.35,16.48) v2(56.99,16.48)
  BOTTOM w0.081: v9(57.35,16.48) 57.35,16.79 57.39,16.83 QF1.3
REM_DIODE1_N: length 192.3
  TOP w0.127: v1(212.39,68.3) 212.39,68.3 212.06,67.97 212.06,67.77 212.41,67.42 212.41,66.24 UE1.A8
  IN1 w0.127: v2(212.29,67.88) 212.23,67.95 212.23,68.14 v1(212.39,68.3)
  IN2 w0.127: v2(212.29,67.88) 212.29,67.85 211.85,67.41 208.39,67.41 207.06,66.07 203.5,66.07 203.09,66.49 202.49,66.49 200.94,64.93 194.87,64.93 194.23,65.57 178.79,65.57 177.14,67.22 172.27,67.22 167.11,72.38 155.71,72.38 153.74,70.4 144.61,70.4 144.09,70.92 137.95,70.92 137.75,70.72 137.75,70.59 v5(137.93,70.41)
  IN3 w0.127: v5(137.93,70.41) 137.75,70.22 137.75,69.89 137.38,69.52 136.38,69.52 135.54,70.36 124.72,70.36 123.45,69.09 108.75,69.09 104.66,65 104.66,52.42 116.92,40.16 131.2,40.16 131.98,39.38 131.98,32.45 133.08,31.35 137.5,31.35 138.73,30.12 138.73,28.15 v4(138.91,27.98)
  BOTTOM w0.127: v5(137.93,70.41) 137.83,70.31 137.83,69.34 137.93,69.24 CE58.2 137.93,68.5 137.64,68.21 QE14.1 137.86,67.66 QE14.2 ; v4(138.91,27.98) 140.18,27.98 141.45,26.71 v3(142.59,26.71) 143.82,26.71 CE57.2 143.99,26.74 QE4.3
REM_DIODE1_P: length 193.7
  TOP w0.127: UE1.A7 212.16,66.22 212.16,67.31 211.81,67.66 211.81,67.97 v1(211.47,68.3)
  IN1 w0.127: v2(211.74,67.92) 211.74,68.03 v1(211.47,68.3)
  IN2 w0.127: v5(137.34,70.41) 137.49,70.56 137.49,70.83 137.84,71.18 144.2,71.18 144.72,70.66 153.64,70.66 155.61,72.63 167.22,72.63 172.38,67.47 177.25,67.47 178.9,65.82 194.34,65.82 194.98,65.19 200.83,65.19 202.39,66.74 203.19,66.74 203.6,66.33 206.95,66.33 208.29,67.66 211.74,67.66 211.78,67.7 211.78,67.88 v2(211.74,67.92)
  IN3 w0.127: v4(138.91,27.6) 138.75,27.6 138.48,27.87 138.48,30.02 137.4,31.09 132.97,31.09 131.73,32.34 131.73,39.27 131.1,39.9 116.82,39.9 104.4,52.32 104.4,65.11 108.64,69.35 123.35,69.35 124.61,70.61 135.64,70.61 136.48,69.77 137.27,69.77 137.49,69.99 137.49,70.26 v5(137.34,70.41)
  BOTTOM w0.127: v4(138.91,27.6) 140.02,27.6 v3(140.8,26.82) 141.29,26.33 143.82,26.33 CE57.1 143.99,26.29 QE4.2 145.13,26.29 145.29,26.45 145.29,26.5 QE4.1 ; QE14.3 137.09,67.51 137.09,68.26 137.34,68.51 CE58.1 137.34,69.24 137.45,69.34 137.45,70.31 v5(137.34,70.41)
REM_DIODE2_N: length 71.2
  TOP w0.127: UE1.A10 214.06,66.2 214.06,66.48 214.93,67.35 215.14,67.35 215.6,67.81 215.6,67.96 v1(215.95,68.3) ; v1(210.34,38.92) 210.41,38.99 QE17.3
  IN1 w0.127: v1(210.34,38.92) 210.34,38.98 210.44,39.07 212.66,39.07 214.61,41.02 214.61,42.87 217.99,46.25 217.99,50.19 217.34,50.84 217.34,51.85 217.43,51.94 217.43,55.12 217.96,55.65 217.96,56.35 217.71,56.6 217.53,56.6 v2(217.35,56.79) 217.2,56.65 217.09,56.65 216.98,56.75 216.98,58.21 217.68,58.91 217.68,62.58 218.58,63.48 218.58,64.22 218.45,64.36 218.45,66.22 217.63,67.05 216.26,67.05 215.64,67.67 215.64,67.99 v1(215.95,68.3)
  IN3 w0.127: v2(217.35,56.79) 217.22,56.66 216.9,56.66 215.72,55.48 215.28,55.48 215.01,55.75 214.32,55.75 213.72,56.35 211.76,56.35 211.54,56.58 208.53,56.58 207.74,55.78 204.89,55.78 203.35,57.33 201.07,57.33 200.56,56.82 197.42,56.82 197.24,56.64 195.26,56.64 v4(194.95,56.34)
  BOTTOM w0.127: QE8.1 191.56,55.44 QE8.2 192.69,55.44 CE55.2 192.96,55.31 193.77,55.31 v3(193.85,55.38) 194,55.38 v4(194.95,56.34)
REM_DIODE2_P: length 70.7
  TOP w0.127: QE17.1 211.59,39.44 QE17.2 210.41,39.44 v1(210.34,39.51) ; v1(215.03,68.3) 215.33,68 215.33,67.89 215.04,67.61 214.83,67.61 213.8,66.58 213.8,66.27 UE1.A9
  IN1 w0.127: v1(215.03,68.3) 215.38,67.95 215.38,67.57 216.16,66.79 217.52,66.79 218.2,66.12 218.2,64.25 218.33,64.12 218.33,63.58 217.43,62.68 217.43,59.01 216.73,58.32 216.73,56.65 216.98,56.39 217.21,56.39 v2(217.35,56.26) 217.44,56.35 217.6,56.35 217.71,56.25 217.71,55.76 217.18,55.22 217.18,52.04 217.09,51.95 217.09,50.73 217.73,50.09 217.73,46.35 214.36,42.98 214.36,41.12 212.56,39.33 210.52,39.33 v1(210.34,39.51)
  IN3 w0.127: v4(195.36,56.17) 195.58,56.39 197.34,56.39 197.52,56.56 200.66,56.56 201.17,57.07 203.25,57.07 204.79,55.53 207.84,55.53 208.64,56.32 211.43,56.32 211.65,56.1 213.61,56.1 214.21,55.5 214.9,55.5 215.17,55.23 215.82,55.23 217,56.41 217.2,56.41 v2(217.35,56.26)
  BOTTOM w0.127: QE8.3 192.69,54.99 CE55.1 192.86,55.03 194.04,55.03 194.69,55.68 194.89,55.68 v3(195.07,55.85) 195.11,55.9 195.11,55.92 v4(195.36,56.17)
REM_DIODE3_N: length 269.3
  TOP w0.089: UE1.B9 213.2,65.45 213.2,66.24 213.25,66.28 213.25,66.31
  TOP w0.127: v1(85.57,24.23) 85.3,24.23 85.27,24.2 QE10.3 ; v1(214.09,71.37) 214.02,71.31 214.02,70.96 214.21,70.78 214.21,69.17 213.86,68.82 213.86,68.6 CE39.1 213.81,67.95 213.81,67.44 213.25,66.87 213.25,66.31 ; QE3.1 245.45,14.49 QE3.2 244.87,14.49 244.76,14.37 244.47,14.37 v1(244.29,14.55)
  IN1 w0.127: v2(95.63,54.16) 95.5,54.02 94.7,54.02 88.47,47.79 88.47,24.29 88.15,23.97 85.83,23.97 v1(85.57,24.23) ; v1(244.29,14.55) 244.12,14.38 242.62,14.38 242.47,14.23 240.19,14.23 239.75,14.68 236.48,14.68 236.02,15.13 229.84,15.13 226.63,18.35 226.63,21.07 225.79,21.91 225.79,23.7 225.34,24.15 225.34,24.77 222.21,27.91 222.21,42.15 222.9,42.84 222.9,68.46 220.15,71.2 214.17,71.2 214.07,71.31 214.07,71.35 v1(214.09,71.37) 214.02,71.44 214.02,71.89 v2(214.17,72.04)
  IN2 w0.127: v2(95.63,54.16) 95.77,54.02 95.97,54.02 96.31,54.36 96.31,62.78 97.61,64.08 98.43,64.08 99.08,64.73 99.08,66.1 102.59,69.61 103.29,69.61 104.23,70.55 107.56,70.55 108.7,71.68 121.77,71.68 122.15,72.07 144.57,72.07 145.09,71.55 153.27,71.55 155.26,73.54 167.67,73.54 171.29,69.92 174.34,69.92 175.27,68.99 176.99,68.99 179.05,66.93 189.06,66.93 189.27,66.72 195.01,66.72 195.35,66.38 197.93,66.38 198.78,67.23 201.61,67.23 202.08,67.71 204.1,67.71 204.25,67.56 206.92,67.56 207.97,68.62 208.88,68.62 209.12,68.86 209.12,70.46 209.93,71.27 209.93,72.31 210.67,73.05 213.58,73.05 213.96,72.66 213.96,72.24 v2(214.17,72.04)
REM_DIODE3_P: length 269.2
  TOP w0.089: 212.98,66.34 213.01,66.32 213.01,65.47 UE1.B8
  TOP w0.127: v1(85.57,23.65) 85.46,23.75 QE10.2 84.63,23.75 84.4,23.98 QE10.1 ; v1(213.71,71.37) 213.77,71.31 213.77,70.85 213.95,70.67 213.95,69.27 213.61,68.93 213.61,68.65 CE39.2 213.56,67.99 213.56,67.55 212.99,66.98 212.99,66.95 212.98,66.94 212.98,66.34 ; QE3.3 244.36,14.04 v1(244.29,13.97)
  IN1 w0.127: v1(85.57,23.65) 85.64,23.72 88.26,23.72 88.72,24.18 88.72,47.69 94.81,53.77 95.47,53.77 v2(95.63,53.6) ; v2(213.63,72.04) 213.77,71.9 213.77,71.43 v1(213.71,71.37) 213.81,71.27 213.81,71.2 214.07,70.95 220.05,70.95 222.65,68.35 222.65,42.95 221.95,42.25 221.95,27.81 225.09,24.67 225.09,24.05 225.54,23.6 225.54,21.8 226.37,20.96 226.37,18.24 229.74,14.88 235.92,14.88 236.37,14.42 239.64,14.42 240.09,13.98 242.58,13.98 242.73,14.13 244.13,14.13 v1(244.29,13.97)
  IN2 w0.127: v2(95.63,53.6) 95.8,53.77 96.08,53.77 96.57,54.25 96.57,62.67 97.72,63.83 98.54,63.83 99.33,64.63 99.33,65.99 102.69,69.35 103.39,69.35 104.33,70.29 107.67,70.29 108.8,71.43 121.88,71.43 122.26,71.81 144.46,71.81 144.98,71.29 153.37,71.29 155.36,73.28 167.56,73.28 171.18,69.66 174.23,69.66 175.16,68.73 176.89,68.73 178.95,66.67 188.96,66.67 189.17,66.46 194.91,66.46 195.24,66.12 198.03,66.12 198.88,66.98 201.71,66.98 202.19,67.45 204,67.45 204.15,67.3 207.02,67.3 208.08,68.36 208.98,68.36 209.37,68.75 209.37,70.35 210.18,71.16 210.18,72.2 210.78,72.79 213.47,72.79 213.71,72.56 213.71,72.11 v2(213.63,72.04)
REM_DIODE4_N: length 7.2
  TOP w0.127: UE1.A11 215.1,65.96 214.97,66.08 214.97,66.45 215.87,67.34 217.07,67.34 217.37,67.64 217.37,67.95 CE86.1 217.43,68.59 217.43,68.93 218.01,69.51 218.01,69.92 218.13,70.04 CE110.2 218.13,70.8 QE22.3
REM_DIODE4_P: length 9
  TOP w0.127: UE1.B10 214.72,65.58 214.72,66.55 215.76,67.59 216.97,67.59 217.12,67.74 217.12,67.99 CE86.2 217.18,68.67 217.18,69.06 217.76,69.64 217.76,69.93 217.55,70.15 CE110.1 217.55,70.8 QE22.2 217.61,71.35 QE22.1
RESET_IN#: length 2.3
  TOP w0.081: RE247.2 205.52,64.74 205.9,64.36 UE1.C1
RING2: length 67.6
  IN3 w1.016: 9.18,74.84 10.7,73.32 11.71,73.32 23.59,61.44 23.59,54.06 20.56,51.03 20.56,28.02 23.27,25.31 27.08,25.31 30.32,22.07
  BOTTOM w0.102: v5(30.26,20.61) v6(30.26,19.85)
  vias: v4(8.66,75.83) v4(9,75.83) v4(9.34,75.82) v5(30.26,21.18)
RING2_CONN:
  vias: v1(7.75,72.6) v1(8,72.6) v1(8.25,72.6) v1(8.51,72.6) v2(7.75,72.09) v2(8.19,72.09) v2(8.63,72.09) v3(6.33,73.84) v4(8.22,72.87) v4(8.22,72.55) v4(8.61,72.68)
RREF: length 2.8
  TOP w0.203: UCR1.9 278.6,24.23 278.4,24.03
  TOP w0.305: RR1.2 276.89,23.79 277.13,24.03 278.4,24.03
RSVD_1: length 0.9
  IN1 w0.064: v2(130.17,25.61) 130.29,25.49 v1(130.29,25.18)
  IN3 w0.064: v2(130.17,25.61) 130.27,25.51 v4(130.27,25.25)
RSVD_AA35: length 0.9
  IN1 w0.064: v2(136.42,40.92) 136.41,40.92 v1(136.09,40.92)
  IN3 w0.064: 136.32,41.01 v2(136.42,40.92)
  IN3 w0.081: v4(135.99,41.12) 136.22,41.12 136.32,41.01
RSVD_L34: length 4.1
  TOP w0.089: UC1.L34 131.01,40.51 v5(131.35,40.85)
  BOTTOM w0.081: v5(131.35,40.85) 130.59,41.61 128.53,41.61 TP67.1
RSVD_M34: length 3.3
  TOP w0.089: v5(131.98,40.85) 131.66,40.53 UC1.M34
  BOTTOM w0.081: v5(131.98,40.85) 132.35,41.22 132.96,41.22 133.42,41.68 133.93,41.68 TP68.1
RSVD_W35: length 0.7
  IN1 w0.064: v2(134.85,40.87) 134.9,40.92 v1(135.17,40.92)
  IN3 w0.081: v4(135.1,41.12) 135.1,41.12 v2(134.85,40.87)
RSVD_Y34: length 1
  IN1 w0.064: v2(135.73,40.11) 135.63,40.21 v1(135.63,40.46)
  IN3 w0.064: v4(135.54,40.61) 135.54,40.3 v2(135.73,40.11)
RT_FORCE_PWR: length 519.3
  TOP w0.076: URT1.B10 9.8,47.34 v1(10.38,47.34)
  TOP w0.081: RT6.1 RT109.1
  TOP w0.089: v1(172.63,40.8) 172.93,40.5 UC1.DT34
  IN1 w0.064: v2(214.1,15.63) 214.37,15.37 214.37,15.09 212.37,13.09 212.37,11.71 211.79,11.13 211.79,5.26 212.21,4.84 213.61,4.84 215.02,3.43 219.68,3.43 221.43,5.18 223.54,5.18 226.36,2.35 233.48,2.35 237.15,6.02 238.81,6.02 240.08,4.75 255.12,4.75 257.61,7.24 257.61,8.17 258.07,8.63 v2(258.07,9.64) ; v2(176.12,40.09) 175.95,39.91 173.52,39.91 v1(172.63,40.8) ; v2(9.96,25.05) 10.84,25.05 v1(11.82,26.03) ; v1(10.38,47.34) 10.15,47.57 8.58,47.57 7.91,48.25 v2(7.91,48.59) 7.91,48.73 8.73,49.55 8.73,50 8.85,50.11 v1(8.85,50.37) ; v1(285.01,19.18) 282.88,19.18 282.54,19.51 282.54,19.51 282.48,19.58 282.48,20.06 282.6,20.18 282.6,20.81 282.29,21.12 274.64,21.12 274.26,21.5 273.72,21.5 273.4,21.82 272.69,21.82 v2(270.98,23.53) 270.98,24.76 273.53,27.3 273.53,31.75 274.5,32.73 274.5,34.23 276.61,36.34 276.61,37.68 277.15,38.22 277.15,38.9 v1(277.55,39.3)
  IN2 w0.051: v2(258.07,9.64) 258.07,9.79 258.32,10.04 258.83,10.04 259.43,10.64 261.4,10.64 264.19,13.44 267.24,13.44 269.21,15.4 269.21,20.41 270.69,21.89 270.69,23.24 v2(270.98,23.53) ; v2(174.02,49.68) 174.02,50.3 174.96,51.24 176.29,51.24 176.82,51.77 187.25,51.77 187.8,51.22 189.96,51.22 190.05,51.31 191.81,51.31 192.19,51.69 v2(192.65,51.69) ; v2(216.16,16.55) 216.1,16.55 212.17,20.47 212.17,21.82 212.64,22.29 212.64,23.7 211.36,24.98 211.36,26.61 209.84,28.14 209.84,29 209.56,29.28 208.61,29.28 207.97,29.92 207.57,29.92 207.22,29.57 206.77,29.57 206.41,29.92 204.29,29.92 203.29,30.93 197.79,30.93 196.94,31.79 193.35,31.79 192.96,32.18 192.12,32.18 190.61,33.69 v2(190.34,33.69) 189.7,34.33 189.48,34.33 185.78,38.03 184.95,38.03 184.5,38.49 182.25,38.49 182.01,38.73 180.82,38.73 180.23,39.32 180.23,39.89 179.86,40.26 176.81,40.26 176.63,40.09 v2(176.12,40.09) ; v5(103.22,3.02) 102.44,3.02 101.57,3.9 91.74,3.9 91.39,3.54 90.08,3.54 89.73,3.9 79.92,3.9 77.4,6.42 77.4,7.93 75.23,10.09 64.78,10.09 64.37,9.68 61.51,9.68 61.09,10.09 31.06,10.09 30.13,11.02 23.17,11.02 17.04,17.15 17.04,17.98 v2(9.96,25.05) 9.96,25.59 11.82,27.45 11.82,38.84 10.89,39.77 10.89,40.38 9.25,42.02 9.25,43.02 8.78,43.49 7.27,43.49 7.13,43.63 7.13,44.34 7.91,45.12 v2(7.91,48.59)
  IN3 w0.064: v2(174.02,49.68) 174.44,49.68 174.66,49.9 175.34,50.59 175.52,50.59 177.13,52.2 v4(177.13,52.64) ; v2(214.1,15.63) 214.81,16.34 215.96,16.34 v2(216.16,16.55) ; v2(190.34,33.69) 190.09,33.94 190.09,35.98 190.49,36.38 190.49,40.23 192.04,41.78 192.04,47.98 191.6,48.42 191.6,51.23 192.06,51.69 v2(192.65,51.69)
  BOTTOM w0.081: v5(103.22,3.02) 103.79,3.59 103.79,7.92 103.68,8.03 103.68,18.29 104.82,19.43 104.82,23.47 103.04,25.25 97.75,25.25 96.68,26.33 94.2,26.33 92.31,28.22 92.31,42.39 94.91,44.99 99.86,44.99 102.87,48 102.87,55.33 104.5,56.97 107.86,56.97 108.48,57.58 109.7,57.58 110.32,56.97 119,56.97 119.67,57.63 120.7,57.63 122.83,55.51 137.24,55.51 138.93,53.82 155.3,53.82 155.72,53.39 163.17,53.39 163.55,53.76 166.67,53.76 168.56,51.87 174.42,51.87 175.11,52.55 v3(175.67,52.55) 175.77,52.64 v4(177.13,52.64)
RT_L_FORCE_PWR: length 1.6
  TOP w0.081: RPD130.2 12.45,25.4 12.96,25.4 UPD1.43
RT_R_FORCE_PWR: length 1.8
  TOP w0.081: RPD138.2 285.01,18.58 284.43,18.01 UPD2.43
RTC_DET#: length 157.8
  TOP w0.081: v1(54.94,12.02) 55.08,12.16 RH734.1
  IN1 w0.064: v1(54.94,12.02) 55.61,12.02 59.79,7.85 64.35,7.85 65.1,8.6 72.24,8.6 76.14,4.71 80.54,4.71 80.97,5.15 87.49,5.15 91.16,8.82 91.16,9.19 v2(91.17,9.2) ; v2(158.03,47.12) 158.37,47.12 158.68,46.81 158.68,46.52 158.41,46.26 158.41,46.12 158.61,45.92 158.87,45.92 159.42,45.37 159.42,43.76 159.35,43.69 159.35,43.08 159.51,42.92 159.51,42.89 160.21,42.19 161.93,42.19 162.42,42.68 163.05,42.68 163.33,42.4 v1(163.33,42.31)
  IN2 w0.051: v2(91.17,9.2) 94.34,12.38 94.34,22.05 94.14,22.26 94.14,43.02 95.71,44.59 100.28,44.59 102.08,46.39 103.38,46.39 104.29,47.31 112.34,47.31 115.44,44.21 119.44,44.21 122.48,47.24 125.5,47.24 126.77,48.52 135.73,48.52 136.33,47.91 137.66,47.91 137.96,48.21 143.41,48.21 143.56,48.06 146.66,48.06 147.37,48.77 151.73,48.77 152.06,48.44 156.46,48.44 157.78,47.12 v2(158.03,47.12)
RTC_DET#_R: length 21.6
  TOP w0.081: QRTC1.1 39.28,12.42 41.49,12.42 42.14,11.77 43.19,11.77 45,9.97 45.5,9.97 46.06,9.4 v3(49.04,9.4) 49.13,9.4 49.64,9.92 49.64,12.4 49.79,12.55 50.16,12.55 51.18,13.56 53.88,13.56 54.45,13 RTCR2.1 RH734.2
RTCRST_ON: length 72.3
  TOP w0.081: RTCR4.2 180.58,19.72 181.04,20.18 Q3.2 182.9,20.18 183.47,20.75 187.73,20.75 v3(188.47,20.01) 189.24,20.01 v1(189.28,20.04)
  IN1 w0.064: v1(189.28,20.04) 190.25,20.04 191.4,21.19 191.4,22.25 v2(191.39,22.25) ; v2(207.61,28.89) 207.79,28.89 208.33,29.42 208.33,30.05 207.72,30.66 207.72,32.64 207.09,33.27 207.09,33.4 207.09,38.39 209.72,41.02 211.96,41.02 212.59,41.65 212.59,41.79 212.59,47.94 212.87,48.22 212.87,52.73 213.53,53.39 213.53,54.72 213.83,55.01 214.3,55.01 214.41,55.12 214.41,55.4 214.33,55.48 214.33,56.51 214.72,56.9 214.72,57.33 214.33,57.73 214.33,59.08 214.66,59.41 214.66,60.62 215.19,61.14 215.19,61.71 215.1,61.8 v1(215.1,61.96)
  IN3 w0.064: v2(207.61,28.89) 206.85,28.12 202.47,28.12 202.21,27.86 196.55,27.86 194.11,25.43 194.11,24.34 193.54,23.77 192.93,23.77 191.87,22.71 191.87,22.6 191.52,22.25 v2(191.39,22.25)
RTCRST_ON_POWER: length 68.3
  TOP w0.081: v1(189.58,19.69) 187.92,19.69 187.12,20.5 183.64,20.5 182.81,19.67 180.99,19.67 180.54,19.22 180.3,19.22 R5779.2 ; v1(214.87,55.24) 214.87,55.37 214.3,55.94 UE1.N10
  IN1 w0.064: v2(208.23,28.85) 208.24,28.86 208.24,29.04 208.49,29.29 208.49,30.12 207.89,30.73 207.89,32.7 207.26,33.33 207.26,38.32 209.79,40.85 212.02,40.85 212.75,41.58 212.75,41.85 212.75,47.87 213.04,48.15 213.04,52.66 213.7,53.32 213.7,54.65 213.9,54.85 214.47,54.85 v1(214.87,55.24) ; v2(191.98,22.2) 191.98,21.54 190.13,19.69 v1(189.58,19.69)
  IN3 w0.064: v2(191.98,22.2) 192.42,22.64 193.13,22.64 194.28,23.79 194.28,25.36 196.62,27.7 202.28,27.7 202.54,27.96 207.34,27.96 v2(208.23,28.85)
RTCRST_ON_R: length 4.3
  TOP w0.081: Q348.2 181.72,17.64 181.45,17.37 R5769.1 ; R5769.1 C1132.1 v3(181.15,19.26) ; R5769.1 181.15,16.37 D116.2
RUN_ON#: length 4.4
  TOP w0.081: QE18.3 199.79,53.04 199.87,53.13 199.87,53.45 199.62,53.69 QE18.2 199.26,53.66 RE87.1 198.34,52.3 v3(198.66,51.98)
RUN_ON_EC: length 117.3
  TOP w0.081: v1(218.85,24.37) 218.85,19.78 216.94,17.87 216.94,16.75 217.52,16.17 217.52,14.46 216.76,13.7 216.76,12.81 RS378.1 ; UE1.E8 212.31,62.38 212.31,61.76 212.44,61.63 217.84,61.63 217.86,61.61 v1(218.91,61.61) ; v5(196.03,50.68) 196.36,50.68 196.63,50.42 196.63,49.11 196.18,48.66 193.83,48.66 192.55,49.95 191.7,49.95 191.41,50.24 191.41,50.79 190.66,51.54 190.12,51.54 189.83,51.25 187.26,51.25 187.03,51.02 187.03,50.51 186.93,50.41 186.1,49.58 186.1,48.03 v3(186.41,47.73) 186.85,47.73 187.23,48.11 RE15.1 188.17,47.7 188.17,47.01 187.73,46.58 UC4.2
  IN1 w0.064: v1(218.91,61.61) 218.91,61.37 218.88,61.34 218.88,60.32 219.34,59.85 219.34,58.12 220.18,57.28 220.18,53.31 v2(218.73,51.85) 218.73,51.35 219.56,50.51 219.56,46.07 215.91,42.41 215.91,40.54 213.14,37.77 213.14,37.07 211.72,35.65 210.64,35.65 210.1,35.11 210.1,32.42 210.29,32.23 210.29,28.7 212.15,26.85 214.29,26.85 216.77,24.37 v1(218.85,24.37)
  IN2 w0.051: v2(218.73,51.85) 217.72,51.85 217.39,51.52 216.05,51.52 215.46,52.11 215.46,53.14 215.05,53.55 213.53,53.55 213.35,53.37 213.35,52.99 212.77,52.41 210.25,52.41 209.84,51.99 208.41,51.99 207.44,51.03 204.76,51.03 204.53,51.26 200.34,51.26 199.58,50.49 196.22,50.49 v5(196.03,50.68)
RUN_ON_P: length 335.1
  TOP w0.081: v1(201.54,54.97) 201.46,54.89 199.4,54.89 198.97,55.31 198.18,55.31 197.84,54.97 197.84,54.2 197.21,53.57 195.99,53.57 195.71,53.29 R6170.1 196.67,51.85 196.67,51.28 196.81,51.14 196.81,49.04 196.25,48.48 191.48,48.48 190.72,47.73 189.41,47.73 RE14.2 RE15.2 188.35,47.5 188.88,46.96 188.88,46.17 188.72,46.02 188.68,46 187.9,45.22 RE460.2 188.31,45.06 189.18,45.93 UC4.4 ; v1(201.2,53.69) 201.63,53.69 201.71,53.61 201.71,51.98 201.93,51.75 201.93,50.36 v5(202.29,50.01) ; v5(199.78,5.17) 201.9,5.17 204.42,2.66 215.06,2.66 v1(216.95,4.55) ; v1(153.58,16.95) 153.32,16.7 153.32,15.4 153.11,15.19 151.53,15.19 RC731.1 ; R6199.1 270.59,20.99 266.8,20.99 266.16,21.63 266.16,23.21 265.91,23.47 264.57,23.47 263.7,24.34 v1(263.16,24.34)
  IN1 w0.064: v1(201.54,54.97) 201.54,54.04 v1(201.2,53.69) ; v5(199.78,5.17) 199.67,5.05 196.33,5.05 194.99,3.71 185.04,3.71 183.09,5.66 183.09,8.87 181.52,10.44 177.81,10.44 177.59,10.66 173.3,10.66 172.64,11.32 168.71,11.32 167.57,12.46 165.65,12.46 164.72,13.39 164.06,13.39 161.86,15.59 161.29,15.59 159.93,16.95 158.15,16.95 158.04,17.06 153.69,17.06 v1(153.58,16.95) 152.79,16.95 152.74,17 142.02,17 140.9,15.88 139.95,15.88 137.6,13.53 137.6,12.92 137.38,12.7 136.69,12.7 136.49,12.5 136.49,12.04 134.28,9.83 128.87,9.83 123.16,4.11 120.86,4.11 119,5.97 111.92,5.97 111.82,5.87 110.74,5.87 110.29,6.32 109.93,6.32 109.01,7.24 100.37,7.24 v1(100.34,7.21) ; v2(203.61,46.52) 202.69,45.59 202.69,44.57 203.71,43.55 203.71,30.97 202.25,29.51 202.25,25.55 203.66,24.14 208.85,24.14 209.46,23.53 209.46,23.01 210.01,22.45 210.01,20.89 212.79,18.12 215.96,18.12 216.5,17.57 216.5,15.44 213.99,12.93 213.99,6.17 215.61,4.55 v1(216.95,4.55) ; v1(263.16,24.34) 263.15,24.34 262.03,23.22 262.03,22.15 260.81,20.93 259.75,20.93 258.8,19.98 258.29,19.98 256.64,18.32 245.46,18.32 245.03,17.9 v1(245.03,17.74) 245.03,17.33 244.49,16.79 241.32,16.79 240.23,17.88 239.8,17.88 238.65,19.03 237.72,19.03 236.58,17.89 231.1,17.89 230.27,18.72 229.62,20.28 229.62,21.57 229.86,22.76 229.86,23.28 227.43,25.7 226.49,25.7 226.03,25.25 226.03,24.73 226.91,23.85 226.91,22.47 226.57,22.13 v2(226.57,21.91)
  IN3 w0.064: v5(202.29,50.01) 201.78,50.01 201.53,49.76 201.53,49.39 203.44,47.48 203.44,46.7 v2(203.61,46.52) 204.4,46.52 204.81,46.11 204.81,42.18 206.93,40.07 206.93,35.45 211.86,30.53 211.86,29.08 213.15,27.79 215.58,27.79 216.68,26.68 221.16,26.68 225.92,21.91 v2(226.57,21.91)
  BOTTOM w0.081: v5(202.29,50.01) v3(202.29,50.52)
RUN_ON_P_1P8VS: length 1.5
  TOP w0.081: R6170.2 194.79,52.81 194.54,53.06 UC24.3
RUN_ON_P_3VS: length 4.9
  TOP w0.081: v1(244.45,17.74) v3(244.45,16.8)
  IN1 w0.064: v1(241.44,17.41) 241.9,16.95 244.38,16.95 244.45,17.02 v1(244.45,17.74)
RUN_ON_P_5VBS: length 1.5
  TOP w0.081: U60.3 270.13,20.21 270.45,20.53 R6199.2
RUN_ON_P_5VS: length 1.9
  TOP w0.081: R6181.2 99.04,6.5 UC28.3
RUN_ON_R: length 1.6
  TOP w0.081: RC730.2 RC731.2 151.65,16.01 151.8,16.17 UC10.2
RUNPWROK: length 9.1
  TOP w0.081: v1(206.22,55.77) 205.54,55.77 205.46,55.85 RE448.1 ; UE1.G3 208.22,60.68 207.42,60.68 207.3,60.81 206.73,60.81 206.73,60.81 206.73,60.82 v1(206.71,60.82)
  IN1 w0.064: v1(206.71,60.82) 206.53,60.63 206.53,59.34 206.09,58.9 206.09,58.58 206.28,58.39 206.28,55.83 v1(206.22,55.77)
SBIOS_TX: length 102.6
  IN1 w0.064: v2(229.91,10.2) 229.5,10.62 228.71,10.62 v1(228.51,10.41)
  IN1 w0.089: v1(170.03,34.14) v2(170.03,33.78)
  IN2 w0.051: v2(170.03,33.78) 170.82,33.78 171.13,33.48 173.04,33.48 173.39,33.13 175.91,33.13 176.42,33.64 176.99,33.64 177.51,33.13 182.57,33.13 183.51,32.18 183.51,31.35 184.46,30.4 185.31,30.4 187.4,28.32 187.4,27.13 190.41,24.11 193.28,24.11 193.69,23.71 197.21,23.71 198.69,25.18 202.91,25.18 203.48,24.61 v2(205.71,24.61) ; v5(218.4,39.03) 218.8,39.42 219.01,39.42 219.37,39.05 219.37,38 220.47,36.9 220.47,28.23 219.48,27.24 219.48,25.54 220.4,24.62 220.98,24.62 221.34,24.26 221.34,23.09 221.78,22.65 221.78,19.6 223.35,18.04 223.35,16.32 228.52,11.15 228.97,11.15 v2(229.91,10.2)
  IN3 w0.064: v4(208.88,25.44) 208.38,24.93 206.98,24.93 206.66,24.61 v2(205.71,24.61)
  BOTTOM w0.081: v4(208.88,25.44) 209.96,25.44 211.14,26.62 211.45,26.62 214.58,29.74 214.58,36.02 217.58,39.03 v5(218.4,39.03)
SD3_RCOMP: length 0.7
  IN1 w0.099: v1(159.67,44.91) 159.67,45.21 v2(159.74,45.27)
  IN3 w0.081: v2(159.74,45.27) 159.98,45.02 v4(159.99,45.02)
SD_CD#: length 47.3
  TOP w0.081: v1(279.53,29.37) 279.4,29.24 UCR1.30
  IN1 w0.064: v2(285.35,44.46) 285.34,44.45 285.34,44.36 286.24,43.47 287.65,43.47 289.21,41.91 289.21,41.64 289.67,41.18 289.67,34.9 285.77,31.01 283.12,31.01 282.84,30.72 282.15,30.72 280.8,29.37 v1(279.53,29.37)
  IN2 w0.051: v2(285.35,44.46) 284.88,44.93 276.83,44.93 276.08,45.68 276.08,57.16 276.36,57.44 v2(276.63,57.44)
SD_CLK: length 59.1
  TOP w0.081: RR4.2 v1(284.92,24.74)
  IN1 w0.064: v2(285.21,25.06) 284.92,24.76 v1(284.92,24.74)
  IN3 w0.064: v2(285.21,25.06) 284.96,25.06 284.83,25.18 284.83,25.66 284.77,25.72 284.39,25.72 284.32,25.79 284.32,25.98 284.39,26.04 284.77,26.04 284.83,26.1 284.83,26.29 284.77,26.36 284.39,26.36 284.32,26.42 284.32,26.61 284.39,26.67 284.77,26.67 284.83,26.74 284.83,26.93 284.77,26.99 284.39,26.99 284.32,27.06 284.32,27.25 284.39,27.31 284.8,27.31 285.02,27.54 285.02,28.34 285.44,28.76 285.44,32.14 285.58,32.29 287.59,32.29 287.69,32.38 287.69,32.58 287.59,32.68 285.47,32.68 285.4,32.74 285.4,32.97 285.49,33.06 287.18,33.06 287.24,33.12 287.24,33.37 287.18,33.43 286.48,33.43 286.42,33.5 286.42,33.69 286.48,33.75 287.05,33.75 287.12,33.81 287.12,34.27 288.87,36.02 288.87,41.62 288.12,42.37 283.33,42.37 282.13,43.57 276.03,43.57 274.39,45.21 274.39,50 275.27,50.88 275.27,52.22 275.2,52.28 274.86,52.28 274.8,52.35 274.8,52.86 274.86,52.93 276.19,52.93 276.26,52.99 276.26,53.18 276.19,53.25 274.86,53.25 274.8,53.31 274.8,53.5 274.86,53.57 276.26,53.57 276.63,53.94 v2(276.63,54.24)
SD_CLK_L: length 2.8
  TOP w0.081: RR4.1 283.24,24.74 283.18,24.67 283.18,24.37 283.1,24.29 282.82,24.29 282.73,24.37 282.73,25.18 282.67,25.24 UCR1.17
SD_CMD: length 60.9
  TOP w0.081: RR6.2 v1(284.92,26.01)
  IN1 w0.064: v1(284.92,26.01) 284.92,25.92 v2(285.21,25.63)
  IN3 w0.064: v2(285.21,25.63) 285.21,25.95 285.27,26.01 285.59,26.01 285.66,26.07 285.66,26.26 285.59,26.33 285.27,26.33 285.21,26.39 285.21,26.58 285.27,26.65 285.59,26.65 285.66,26.71 285.66,26.9 285.59,26.96 285.27,26.96 285.21,27.02 285.21,27.16 285.39,27.34 285.39,28.19 285.85,28.64 285.85,31.22 285.91,31.28 288.01,31.28 288.07,31.35 288.07,31.54 288.01,31.6 285.94,31.6 285.85,31.69 285.85,31.82 285.94,31.92 288.01,31.92 288.07,31.98 288.07,33.1 288.01,33.16 287.69,33.16 287.62,33.22 287.62,33.42 287.69,33.48 288.01,33.48 288.07,33.54 288.07,33.77 288.01,33.83 287.56,33.83 287.5,33.9 287.5,34.09 287.56,34.15 288.01,34.15 288.07,34.21 288.07,34.66 289.28,35.87 289.28,36.18 289.34,36.24 290.29,36.24 290.35,36.3 290.35,36.49 290.29,36.56 289.34,36.56 289.28,36.62 289.28,36.81 289.34,36.87 290.29,36.87 290.35,36.94 290.35,37.13 290.29,37.19 289.34,37.19 289.28,37.26 289.28,37.45 289.34,37.51 290.29,37.51 290.35,37.57 290.35,37.76 290.29,37.83 289.34,37.83 289.28,37.89 289.28,38.08 289.34,38.14 290.29,38.14 290.35,38.21 290.35,38.4 290.29,38.46 289.34,38.46 289.28,38.53 289.28,41.82 288.36,42.73 283.48,42.73 282.25,43.96 276.15,43.96 274.75,45.36 274.75,49.84 275.64,50.72 275.64,52.44 275.75,52.55 276.13,52.55 276.19,52.49 276.19,52.3 276.26,52.23 276.51,52.23 276.63,52.36 v2(276.63,52.64)
SD_CMD_L: length 1.6
  TOP w0.081: UCR1.19 283.61,26.04 RR6.1
SD_D2: length 60.3
  TOP w0.081: v1(284.92,27.28) RR9.2
  IN1 w0.064: v2(286.16,27.91) 285.55,27.91 v1(284.92,27.28)
  IN3 w0.064: v2(276.63,51.04) 276.53,51.04 276.38,50.9 276.38,50.32 275.49,49.43 275.49,45.67 276.46,44.7 282.56,44.7 283.79,43.47 289.38,43.47 289.45,43.41 289.45,43.34 289.51,43.28 289.7,43.28 289.77,43.34 289.77,43.41 289.83,43.47 290.02,43.47 290.08,43.41 290.08,43.28 290.15,43.22 290.34,43.22 290.4,43.28 290.4,43.41 290.46,43.47 291.07,43.47 291.18,43.36 291.18,42.96 291.12,42.89 290.23,42.89 290.16,42.83 290.16,42.64 290.23,42.57 291.12,42.57 291.18,42.51 291.18,42.32 291.12,42.26 290.55,42.26 290.48,42.19 290.48,42 290.55,41.94 291.12,41.94 291.18,41.88 291.18,41.62 291.12,41.56 290.74,41.56 290.67,41.5 290.67,41.3 290.74,41.24 291.12,41.24 291.18,41.18 291.18,40.99 291.12,40.92 290.74,40.92 290.67,40.86 290.67,40.67 290.74,40.61 291.12,40.61 291.18,40.54 291.18,40.35 291.12,40.29 290.74,40.29 290.67,40.23 290.67,40.03 290.74,39.97 291.12,39.97 291.18,39.91 291.18,39.72 291.12,39.65 290.74,39.65 290.67,39.59 290.67,39.4 290.74,39.34 291.04,39.34 291.1,39.27 291.1,35.9 290.61,35.41 289.85,35.41 288.81,34.36 288.81,29.34 288.74,29.28 286.7,29.28 286.61,29.18 286.61,29.05 286.7,28.96 288.86,28.96 288.96,28.86 288.96,28.73 288.86,28.64 286.7,28.64 286.61,28.55 286.61,28.42 286.7,28.32 288.86,28.32 288.96,28.23 288.96,27.98 288.89,27.91 v2(286.16,27.91)
SD_D2_L: length 1.8
  TOP w0.081: RR9.1 283.21,26.84 UCR1.21
SD_D3: length 60.4
  TOP w0.081: RR8.2 v1(284.92,26.64)
  IN1 w0.064: v2(286.09,26.96) 285.24,26.96 v1(284.92,26.64)
  IN3 w0.064: v2(286.09,26.96) 286.09,27.34 286.03,27.41 285.85,27.41 285.76,27.49 285.76,28.03 286.23,28.5 286.23,29.5 286.37,29.64 288.37,29.64 288.44,29.71 288.44,29.9 288.37,29.96 286.32,29.96 286.23,30.05 286.23,30.19 286.32,30.28 288.37,30.28 288.44,30.34 288.44,30.53 288.37,30.6 286.32,30.6 286.23,30.69 286.23,30.82 286.32,30.91 288.34,30.91 288.44,31.01 288.44,34.51 289.78,35.85 290.48,35.85 290.73,36.1 290.73,38.58 290.48,38.84 289.72,38.84 289.66,38.9 289.66,39.23 289.72,39.3 290.23,39.3 290.29,39.36 290.29,39.55 290.23,39.61 289.72,39.61 289.66,39.68 289.66,39.87 289.72,39.93 290.23,39.93 290.29,40 290.29,40.19 290.23,40.25 289.72,40.25 289.66,40.31 289.66,40.5 289.72,40.57 290.23,40.57 290.29,40.63 290.29,40.82 290.23,40.88 289.72,40.88 289.66,40.95 289.66,41.14 289.72,41.2 290.23,41.2 290.29,41.27 290.29,41.5 290.23,41.57 289.78,41.57 289.72,41.63 289.72,41.82 289.78,41.88 290.04,41.88 290.1,41.95 290.1,42.07 289.9,42.27 289.82,42.27 289.65,42.11 289.56,42.11 289.43,42.24 289.43,42.33 289.78,42.68 289.78,42.77 289.65,42.91 289.56,42.91 289.2,42.55 289.11,42.55 288.98,42.69 288.98,42.78 289.14,42.94 289.14,43.03 289.07,43.1 283.64,43.1 282.41,44.33 276.31,44.33 275.12,45.52 275.12,49.66 276,50.54 276,51.73 276.12,51.84 v2(276.63,51.84)
SD_D3_L: length 1.7
  TOP w0.081: UCR1.20 283.45,26.44 RR8.1
SD_LN0_M: length 24.6
  TOP w0.066: v1(291.65,44.29) 292.28,44.92 JCR1.14 ; v1(286.1,29.59) 286.01,29.68 283.15,29.68 282.73,29.26 281.91,29.26 281.79,29.39 281.38,29.39 281.31,29.31 281.31,29.15 281.4,29.05 UCR1.25
  IN1 w0.061: v1(291.65,44.29) 291.56,44.2 291.56,41.57 290.81,40.82 290.81,33.7 286.79,29.68 286.19,29.68 v1(286.1,29.59)
SD_LN0_P: length 24.5
  TOP w0.066: v1(291.27,44.29) 291.73,44.75 JCR1.13 ; v1(286.1,29.97) 286.01,29.88 v7(283.35,29.88) 283.06,29.88 282.64,29.46 282,29.46 281.87,29.59 281.3,29.59 281.1,29.39 281.1,29.14 281,29.04 UCR1.26
  IN1 w0.061: v1(291.27,44.29) 291.36,44.2 291.36,41.65 290.61,40.9 290.61,33.79 286.7,29.88 286.19,29.88 v1(286.1,29.97)
SD_LN1_M: length 67.2
  TOP w0.066: UCR1.23 282.61,27.64 282.66,27.6 v1(283.2,27.6) ; v1(291.72,61.5) 291.73,61.5 JCR1.16
  IN1 w0.061: v2(283.62,27.73) 283.43,27.53 283.27,27.53 v1(283.2,27.6) ; v2(291.53,61.16) 291.72,61.35 v1(291.72,61.5)
  IN3 w0.061: v2(283.62,27.73) 283.46,27.56 283.3,27.56 283.24,27.62 283.24,28.34 284.5,29.6 284.5,31.21 282.01,33.7 274.8,33.7 271.89,36.62 271.89,44 272.21,44.32 272.21,56.15 272.64,56.58 272.64,59.47 277.4,64.24 278.61,64.24 280.78,62.06 285.99,62.06 286.12,62.19 288.94,62.19 289.51,61.62 291.07,61.62 v2(291.53,61.16)
SD_LN1_P: length 67.8
  TOP w0.066: v1(283.2,27.21) 283.03,27.39 282.76,27.39 282.61,27.24 UCR1.22 ; v1(291.17,61.5) 291.18,61.5 JCR1.17
  IN1 w0.061: v1(283.2,27.21) 283.32,27.33 283.49,27.33 v2(283.62,27.19) ; v2(291.43,61.89) 291.43,61.77 v1(291.17,61.5)
  IN3 w0.061: v2(283.62,27.19) 283.46,27.36 283.22,27.36 283.04,27.54 283.04,28.42 284.3,29.68 284.3,31.13 281.93,33.5 274.72,33.5 271.69,36.53 271.69,44.09 272,44.41 272,56.24 272.43,56.67 272.43,59.56 277.32,64.44 278.69,64.44 280.86,62.27 285.91,62.27 286.04,62.39 289.02,62.39 289.59,61.82 291.37,61.82 v2(291.43,61.89)
SD_PWR_EN: length 139
  TOP w0.081: R6171.1 266.29,26.07 266.99,26.07 267.56,25.5 v3(267.56,25.44) 267.56,24.93 266.61,23.98 266.61,21.56 266.99,21.18 271.3,21.18 271.43,21.06 271.43,20.1 271.3,19.98 v1(271.18,19.98)
  TOP w0.089: UC1.DU12 v1(173.79,29.71)
  IN1 w0.064: v1(173.79,29.71) 173.79,29.56 v2(174.04,29.31) ; v2(271.75,19.98) v1(271.18,19.98)
  IN2 w0.051: v2(271.75,19.98) 271.56,20.17 270.67,20.17 270.1,19.59 270.1,14.07 268.38,12.36 264.83,12.36 261.72,9.24 260.83,9.24 260.7,9.37 259.68,9.37 258.67,8.36 253.12,8.36 252.3,9.18 248.39,9.18 247.33,8.13 233.82,8.13 232.43,6.74 231.77,6.74 231.46,6.42 228.57,6.42 221.57,13.42 218.67,13.42 216.69,15.39 216.69,16.61 216.13,17.18 215.68,17.18 212.33,20.53 212.33,21.75 212.8,22.22 212.8,23.76 211.51,25.04 211.51,26.68 209.99,28.2 209.99,29.06 209.62,29.43 208.67,29.43 208.03,30.07 207.12,30.07 v2(206.94,29.9)
  IN3 w0.064: v2(174.04,29.31) 174.28,29.55 178.47,29.55 179.89,28.13 184.15,28.13 185.28,27.01 185.98,27.01 186.59,27.61 187.99,27.61 189.74,29.36 191.75,29.36 192.66,30.28 205.47,30.28 205.84,29.9 v2(206.94,29.9)
SD_PWR_EN_R: length 3.6
  TOP w0.081: R667.2 R6171.2 R666.2 264.94,25 264.47,24.53 v3(264.47,24.23) 264.47,24.15 264.66,23.96 UC31.4
SD_RCLK_M: length 60.8
  TOP w0.066: RR2.2 284.45,23.56 284.7,23.56 v1(284.92,23.34)
  IN1 w0.061: v2(283.6,40.98) 283.74,41.12 283.9,41.12 284.16,41.38 284.16,42.13 283.75,44.17 283.75,44.52 284.13,44.91 285.46,44.91 286.52,43.84 287.8,43.84 289.58,42.06 289.58,41.8 290.04,41.33 290.04,34.75 284.04,28.75 284.04,23.97 284.45,23.56 284.7,23.56 v1(284.92,23.34)
  IN3 w0.061: 276.31,41.08 276.17,41.08 275.43,41.81 275.43,42.68 273.4,44.72 273.4,54.33 274.15,55.08 275.29,55.08 276.12,55.9 276.12,56.07 276.37,56.32 276.55,56.32 276.63,56.41 v2(276.63,56.64) ; v2(283.6,40.98) 283.41,41.17 283.23,41.17 282.29,42.11 280.88,42.11 280.43,41.94 278.52,41.22 278.44,41.18
  IN3 w0.064: 278.44,41.18 278.16,41.08 276.31,41.08
SD_RCLK_M_L: length 3.6
  TOP w0.066: UCR1.15 281,23.87 281.53,23.34 RR2.1
SD_RCLK_P: length 60.1
  TOP w0.066: v1(284.92,23.98) 284.7,23.76 284.45,23.76 RR3.2
  IN1 w0.061: v2(283.6,41.51) 283.6,41.4 283.67,41.32 283.82,41.32 283.95,41.46 283.95,42.11 283.55,44.15 283.55,44.61 284.05,45.11 285.54,45.11 286.61,44.04 287.88,44.04 289.78,42.14 289.78,41.88 290.24,41.42 290.24,34.67 284.24,28.66 284.24,24.06 284.54,23.76 284.7,23.76 v1(284.92,23.98)
  IN3 w0.061: v2(283.6,41.51) 283.46,41.38 283.31,41.38 282.37,42.31 280.85,42.31 280.36,42.13 280.36,42.13 278.45,41.41 278.45,41.41 278.38,41.38 278.38,41.38 278.12,41.28 276.25,41.28 275.64,41.9 275.64,42.77 273.6,44.8 273.6,54.24 274.23,54.88 275.38,54.88 276.32,55.82 276.32,55.98 276.46,56.12 276.56,56.12 276.63,56.05 v2(276.63,55.84)
SD_RCLK_P_L: length 3.5
  TOP w0.066: RR3.1 283.22,23.54 281.61,23.54 281.21,23.95 281.21,24 281.27,24.07 281.3,24.07 281.4,24.17 UCR1.16
SD_REG2: length 1.6
  TOP w0.081: CR19.1 283.66,28.68 284.05,28.29 v3(285.09,28.29)
SIO_EXT_WAKE#: length 83.5
  TOP w0.081: v5(218.41,53.39) 218.4,53.4 218.04,53.4 217.91,53.53 RE482.1
  IN1 w0.089: v2(169.58,34.64) 169.58,34.67 169.96,35.06 v1(170.03,35.06)
  IN2 w0.051: v5(218.41,53.39) 218.57,53.24 218.69,53.24 220.06,51.86 220.06,46.04 219.15,45.13 219.15,42.82 v5(218.92,42.58) ; v5(209.46,25.82) 209.37,25.74 206.08,25.74 205.61,25.27 204.22,25.27 203.68,25.82 196.44,25.82 195.29,24.67 194.78,24.67 194.61,24.84 190.34,24.84 187.85,27.32 187.85,29.94 185.22,32.57 183.77,32.57 182.75,33.59 178.23,33.59 177.61,34.22 176.57,34.22 176.21,33.86 175.38,33.86 175.07,34.17 173.17,34.17 172.37,34.96 169.9,34.96 v2(169.58,34.64)
  IN3 w0.064: v2(169.58,34.64) 169.58,34.75 v4(169.39,34.94)
  BOTTOM w0.081: RC671.2 169.44,34.89 v4(169.39,34.94) v3(168.73,34.94) ; v5(218.92,42.58) 217.52,41.18 217.52,40.46 214.39,37.33 214.39,29.82 211.37,26.8 211.07,26.8 210.09,25.82 v5(209.46,25.82)
SIO_EXT_WAKE#_EC: length 3.6
  TOP w0.081: UE1.M12 216.01,57.05 216.01,56.69 216.22,56.48 216.22,55.35 217.33,54.24 RE482.2
SIO_PWRBTN#: length 213.4
  IN1 w0.064: v1(215.1,58.76) 215.57,58.76 215.76,58.56 215.76,58.08 215.39,57.7 215.39,57.43 214.92,56.97 214.92,56.63 v2(214.67,56.37)
  IN2 w0.051: v2(214.67,56.37) 214.57,56.28 206.77,56.28 205.9,57.15 204.63,57.15 204.42,56.95 195.27,56.95 194.6,57.61 192.75,57.61 191.21,56.07 188.79,56.07 187.87,56.99 178.13,56.99 176.14,58.98 174.45,58.98 173.65,58.18 172.4,58.18 172.12,57.9 170.51,57.9 169.9,57.29 169.9,56.9 169.08,56.08 167.78,56.08 165.27,53.57 v5(165.27,52.81)
  IN3 w0.064: v4(119.03,3.11) 116.89,5.25 112.59,5.25 112.07,5.77 110.68,5.77 107.98,8.48 104.83,8.48 104.77,8.54 v4(104.77,8.7) ; v4(167.35,51.87) 167.35,51.86 165.62,50.13 165.62,48.24 165.25,47.87 165.25,46.56 165.07,46.38 v4(165.07,45.9)
  BOTTOM w0.081: v4(104.77,8.7) 104.41,9.06 104.41,17.98 105.55,19.13 105.55,23.77 103.34,25.99 98.06,25.99 96.98,27.06 94.51,27.06 93.04,28.53 93.04,42.08 95.21,44.26 100.16,44.26 103.79,47.88 v3(103.79,48.42) 103.79,55.22 104.81,56.23 108.26,56.23 108.85,56.82 109.39,56.82 109.98,56.23 120.87,56.23 122.84,54.27 126.16,54.27 126.78,53.64 128.05,53.64 128.67,54.27 137.45,54.27 138.63,53.08 154.99,53.08 155.42,52.66 163.48,52.66 163.63,52.81 v5(165.27,52.81) 166.41,52.81 v4(167.35,51.87)
SIO_PWRBTN#_R: length 1.1
  IN1 w0.099: v2(165.01,44.61) 165.16,44.46 v1(165.16,44.26)
  IN3 w0.064: v2(165.01,44.61) 165.07,44.68 v4(165.07,45.31)
SIO_SLP_A#: length 59.8
  TOP w0.081: v1(175.94,51.57) 175.94,52.18 RH685.2
  IN1 w0.064: v2(176.02,52.09) 176.02,52.08 175.94,52 v1(175.94,51.57) 175.94,51.24 175.83,51.12 175.58,51.12 174.73,50.28 174,50.28 173.33,49.61 173.33,49.28 173.24,49.18 173.24,48.86 172.6,48.21 171.89,48.21 171.69,48.42 171.23,48.42 170.96,48.14 170.96,47.58 170.18,46.79 169.43,46.79 v1(169.27,46.63)
  IN2 w0.051: v2(214.99,57.54) 215.03,57.51 215.03,54.42 214.77,54.16 212.72,54.16 212.11,53.54 205.66,53.54 205.38,53.26 202.7,53.26 202.18,52.74 200.37,52.74 200.02,53.08 196.93,53.08 196.58,53.44 195.42,53.44 195.24,53.26 193.23,53.26 192.9,52.93 191.82,52.93 191.63,52.74 191.27,52.38 178.34,52.38 177.9,52.82 176.19,52.82 176,52.63 176,52.11 v2(176.02,52.09)
  IN3 w0.064: v2(214.99,57.54) 215.11,57.65 v4(215.39,57.65)
  BOTTOM w0.081: v4(215.39,57.65) v3(215.81,58.07) 216.5,58.77 216.5,60.14 216.63,60.27 JAPS1.6
SIO_SLP_S0#: length 141.4
  TOP w0.081: R54.1 v1(209.86,12.09)
  IN1 w0.064: v1(206.84,7.59) 209.01,9.76 v2(209.01,10.22) 209.01,11.24 v1(209.86,12.09)
  IN1 w0.099: v1(160.55,45.98) 160.68,46.11 v2(161.34,46.11)
  IN2 w0.051: v5(218.92,42.02) 219.3,42.41 219.3,45.06 220.21,45.97 220.21,53.5 217.94,55.77 217.14,55.77 v2(216.99,55.62) 217.7,54.91 217.7,52.44 217.13,51.87 216.13,51.87 215.77,52.23 215.77,53.26 215.18,53.85 213.4,53.85 213.04,53.5 213.04,53.12 213.04,53.11 212.64,52.72 210.13,52.72 209.71,52.3 208.28,52.3 207.31,51.33 204.88,51.33 204.65,51.56 200.19,51.56 199.44,50.81 197.61,50.81 197.01,51.41 194.9,51.41 194.39,50.89 193.4,50.89 192.54,50.04 191.43,50.04 190.53,49.13 187.84,49.13 186.79,50.19 183.53,50.19 183.44,50.28 181.4,50.28 180.75,50.93 175.08,50.93 174.51,50.35 174.51,49.48 173.73,48.7 172.71,48.7 171.76,47.75 169.62,47.75 168.97,48.4 167.16,48.4 166.28,47.52 164.66,47.52 163.9,46.76 162.13,46.76 161.48,46.11 v2(161.34,46.11)
  IN3 w0.064: v2(209.01,10.22) 209.09,10.3 v4(209.61,10.3) ; v2(161.34,46.11) 161.13,46.11 v4(160.62,45.6) ; v2(216.99,55.62) 217.24,55.62 v4(217.39,55.77)
  BOTTOM w0.081: v4(160.62,45.6) RH689.2 ; v4(209.61,10.3) 214.13,10.3 215.04,11.21 215.04,13.44 215.33,13.72 222.26,13.72 224.32,15.78 224.32,19.6 224.63,19.91 v6(224.63,24.23) 224.63,24.68 220.14,29.17 220.14,35.21 219.94,35.41 219.94,36.32 219.36,36.9 219.36,41.58 v5(218.92,42.02)
SIO_SLP_S3#: length 182.7
  TOP w0.081: v1(174.8,51.57) 174.72,51.65 RH683.2 ; UC7.1 186.33,30.72 186.01,30.4 186.01,30.19 185.14,29.32 185.14,28.48 ; 190.03,19.77 190.03,19.46 189.4,18.83 187.88,18.83 186.09,17.04 186.09,16.11 183.78,13.8 181.24,13.8 180.31,12.87 v1(180.31,10.7) ; 190.03,19.77 190.37,20.11 190.37,21.54 186.28,25.63 186.28,25.78 185.14,26.92 185.14,28.48 ; 190.03,19.77 188.88,20.93 181.28,20.93 180.6,20.25 179.46,20.25 179.19,19.98 179.19,18.85 178.98,18.63 U15.1 ; UC4.1 187.06,47.23 186.85,47.03 186.85,45.53 RE460.1 187.7,45.44 187.8,45.44 188.44,46.08 v5(188.44,46.71) ; 185.14,28.48 184.95,28.48 184.35,29.08 184.35,29.65 185,30.3 185,31.23 183.87,32.36 183.87,33.06 183.39,33.54 183.39,34.69 183.57,34.87 184.55,34.87 185.05,35.37 185.05,35.49 185.75,36.19 185.75,37.16 186.2,37.61 186.2,39.68 v1(185.52,40.36) ; v1(153.11,17.23) 153.11,16.65 152.85,16.39 RC730.1 ; v5(199.7,57.8) 199.7,57.55 199.41,57.27 QE15.2
  IN1 w0.064: v1(185.52,40.36) 185.52,41.01 185.66,41.15 185.66,41.22 186.33,41.89 186.33,44.34 188.44,46.45 v5(188.44,46.71) ; v1(174.8,51.57) 174.8,51.3 174.27,50.77 173.8,50.77 172.65,49.62 172.65,48.97 172.39,48.71 172.09,48.71 171.65,49.15 v2(171.51,49.15) 171.27,49.15 170.46,48.34 170.46,47.74 170.23,47.52 169.3,47.52 168.78,48.03 167.76,48.03 167.63,47.9 167.63,47.51 167.77,47.38 167.77,47.38 168.06,47.08 v1(168.06,46.63) ; v1(180.31,10.7) 177.78,10.7 177.66,10.83 173.37,10.83 172.71,11.48 168.78,11.48 167.64,12.63 165.72,12.63 164.79,13.56 164.13,13.56 161.93,15.75 161.36,15.75 160,17.11 158.22,17.11 158.11,17.23 v1(153.11,17.23)
  IN2 w0.051: v2(213.52,59.12) 213.52,59.45 215.36,61.29 215.36,61.9 215.5,62.03 216.26,62.03 v2(217.27,63.04) ; v2(171.51,49.15) 171.67,49.15 174.05,51.54 176.16,51.54 176.69,52.07 187.68,52.07 187.96,51.8 v2(187.96,51.75)
  IN3 w0.064: v5(199.7,57.8) 200.01,58.12 205.19,58.12 206.42,56.89 207.41,56.89 208.11,57.59 212.68,57.59 213.52,58.43 v2(213.52,59.12) ; v2(187.96,51.75) 187.91,51.7 187.91,51.7 187.36,51.15 187.36,50.71 187.04,50.39 187.04,49.17 188.44,47.78 v5(188.44,46.71) ; v4(217.39,62.27) 217.27,62.4 v2(217.27,63.04)
  BOTTOM w0.081: v5(199.7,57.8) 199.7,56.77 197.94,55.01 197.94,52.98 197.53,52.58 197.53,49.65 195.78,47.89 190.95,47.89 190.61,48.23 v3(189.96,48.23) v5(188.44,46.71)
SIO_SLP_S4#: length 72.4
  TOP w0.081: RH684.2 CH54.2 173.51,51.56 172.49,50.53 172.49,49.45 v1(172.39,49.35) ; UC5.1 187.82,50.88 188.5,50.2 190.06,50.2 RC695.1 190.68,49.92 v5(190.89,50.14) ; UE1.N12 215.54,56 v5(215.54,55.91)
  IN1 w0.064: v1(166.8,47.29) 166.8,47.53 167.47,48.2 168.85,48.2 169.38,47.67 170.17,47.67 170.29,47.79 170.29,48.27 170.29,48.41 171.37,49.49 171.8,49.49 v2(172.24,49.05) 172.39,49.19 v1(172.39,49.35)
  IN2 w0.051: v2(172.24,49.05) 173.85,49.05 174.35,49.54 174.35,50.42 175.02,51.08 180.81,51.08 181.46,50.43 183.51,50.43 183.6,50.34 186.85,50.34 187.9,49.29 190.04,49.29 v5(190.89,50.14) 190.94,50.19 192.48,50.19 193.33,51.05 194.32,51.05 194.84,51.56 197.07,51.56 197.67,50.96 199.37,50.96 200.12,51.71 204.72,51.71 204.95,51.48 207.25,51.48 208.21,52.45 209.65,52.45 210.06,52.87 212.58,52.87 212.89,53.18 212.89,53.56 213.34,54 214.83,54 215.18,54.35 215.18,55.55 v5(215.54,55.91)
  BOTTOM w0.081: v5(190.89,50.14) 191.04,50.14 v3(191.36,49.82) ; v5(215.54,55.91) 215.12,56.33 215.12,57.84 216.32,59.04 216.32,60.43 216.66,60.77 JAPS1.5
SIO_SLP_S5#: length 61.1
  TOP w0.081: v1(175.37,51.57) 175.45,51.65 175.45,52.1 RH691.2
  IN1 w0.064: v1(168.06,45.98) 168.32,46.25 168.8,46.25 169.01,46.46 169.01,46.74 169.23,46.96 170.11,46.96 170.8,47.65 170.8,48.08 170.8,48.21 171.17,48.58 171.75,48.58 171.96,48.38 172.53,48.38 173.07,48.92 173.07,49.25 173.17,49.34 173.17,49.67 173.94,50.44 174.65,50.44 175.37,51.16 v1(175.37,51.57) 175.37,51.68 v2(175.56,51.87)
  IN2 w0.051: v2(175.56,51.87) 175.56,52.41 176.27,53.12 177.81,53.12 178.41,52.53 191.2,52.53 191.57,52.89 191.76,53.08 192.84,53.08 193.17,53.41 195.18,53.41 195.35,53.59 196.64,53.59 197,53.24 200.09,53.24 200.43,52.89 202.12,52.89 202.64,53.41 205.32,53.41 205.6,53.69 212.03,53.69 212.86,54.52 v2(212.86,54.71)
  IN3 w0.064: v4(213.19,54.95) 212.95,54.71 v2(212.86,54.71)
  BOTTOM w0.081: JAPS1.4 216.78,61.27 216.14,60.63 216.14,59.12 214.94,57.92 214.94,56.45 v3(214.73,56.23) 214.73,56.11 213.57,54.95 v4(213.19,54.95)
SIO_SLP_SUS#: length 400
  TOP w0.081: RC699.1 RH686.2 176.44,51.65 v1(176.51,51.57) ; RT95.1 289.05,24.42 v5(289.85,24.42)
  TOP w0.097: UC1.DM49 171.14,47.92 v1(171.2,47.98)
  IN1 w0.064: v1(171.2,47.98) 171.31,48.08 v2(171.55,48.08) 171.58,48.05 172.66,48.05 173.4,48.79 173.4,49.11 173.58,49.29 174.1,49.29 174.48,49.66 174.48,49.79 175.64,50.96 175.9,50.96 v1(176.51,51.57) 176.47,51.61 176.47,52.34 v2(176.33,52.49) ; v2(207.72,53.06) 207.82,53.06 v1(208,53.24) ; v1(18.54,40.49) 18.89,40.13 18.89,29.5 18.51,29.12 18.51,27.53 20.67,25.37 20.67,23.2 21.41,22.45 21.41,21.46 21.83,21.05 21.83,15.99 22.52,15.3 24.83,12.99 31.99,12.99 34.01,15.01 35.22,15.01 36.3,13.93 40.41,13.93 41.22,14.74 47.81,14.74 50.05,16.98 50.79,16.98 52.4,15.37 59.76,15.37 62.95,12.18 65.56,12.18 65.91,12.53 68.24,12.53 70.5,10.27 72.52,10.27 73.68,9.11 76.31,9.11 78.87,6.55 86.78,6.55 89.04,8.82 89.04,9.61 89.54,10.1 v2(90.29,10.1)
  IN2 w0.051: v2(207.72,53.06) 207.25,52.59 205.53,52.59 205.31,52.81 203.98,52.81 203.76,52.59 200.3,52.59 199.96,52.93 196.87,52.93 196.51,53.29 195.48,53.29 195.3,53.11 193.3,53.11 192.97,52.78 191.88,52.78 191.63,52.53 191.33,52.23 176.59,52.23 v2(176.33,52.49) ; v2(90.29,10.1) 93.01,12.82 93.01,44.25 94.42,45.66 99.71,45.66 101.51,47.46 102.76,47.46 104.13,48.83 115.54,48.83 116.88,50.17 125.51,50.17 126.19,49.48 132.37,49.48 133.06,50.18 139.05,50.18 139.38,50.51 143.37,50.51 144.6,49.28 146.29,49.28 147.38,50.37 153.23,50.37 154.12,49.48 155.02,49.48 155.35,49.82 158.27,49.82 159.15,48.94 159.15,48.15 159.4,47.9 160.29,47.9 160.53,47.67 162.43,47.67 162.65,47.44 164.37,47.44 164.59,47.67 166.22,47.67 167.1,48.55 169.27,48.55 169.3,48.52 169.7,48.52 169.72,48.55 171.08,48.55 v2(171.55,48.08) ; v2(215.09,52.25) 215.09,51.37 216.25,50.21 218.98,50.21 219.45,49.74 219.45,46.63 218.71,45.9 218.71,44.13 218.35,43.76 218.35,41.22 218.68,40.89 219.52,40.89 220.64,39.77 220.64,38.03 221.39,37.28 221.39,27.86 220.39,26.86 220.39,25.92 220.78,25.53 221.36,25.53 222.26,24.63 222.26,23.47 222.7,23.02 222.7,19.98 229.93,12.75 249.31,12.75 249.45,12.89 261.54,12.89 263.98,15.33 263.98,17.35 266.54,19.91 266.54,21.37 268.07,22.9 268.07,23.21 v2(268.45,23.6)
  IN3 w0.064: v2(207.72,53.06) 208.19,52.59 212.57,52.59 212.95,52.2 215.05,52.2 v2(215.09,52.25) ; v2(268.45,23.6) 268.45,23.66 v4(268.7,23.91)
  BOTTOM w0.081: v5(289.85,24.42) 288.92,25.35 288.92,27.71 288.26,28.36 287.24,28.36 v6(287.05,28.17) 284.73,25.85 284.73,24.39 283.76,23.41 274.03,23.41 273.6,23.84 273.6,23.84 273.53,23.91 v4(268.7,23.91)
SIO_SLP_SUS#_EC: length 4.9
  TOP w0.081: UE1.N4 209.5,55.96 208,54.46 RE115.2 208,54.12 207.57,53.69 207.57,53.18 207.06,52.66 v3(206.85,52.66)
SIO_SLP_WLAN#: length 31
  TOP w0.081: Q124.1 177.07,63.47 177.44,63.11 v5(177.44,60.92) ; v1(172.91,49.46) 173.9,50.44 173.9,51.24 CH52.2 174.23,52.18 RH682.2
  TOP w0.089: UC1.DE49 v1(167.86,47.61)
  IN1 w0.064: v1(167.86,47.61) 167.86,47.66 168.05,47.85 168.75,47.85 169.23,47.37 170.3,47.37 170.62,47.69 170.62,48.27 171.1,48.75 171.82,48.75 172.03,48.54 172.46,48.54 172.91,48.99 v1(172.91,49.46) 172.91,49.65 173.87,50.61 174.59,50.61 175.11,51.13 175.11,52.03 175.29,52.22 175.29,55.34 175.01,55.62 175.01,56.12 175.22,56.34 175.83,56.34 176.21,56.72 176.21,59.23 177.44,60.46 v5(177.44,60.92)
  BOTTOM w0.081: v5(177.44,60.92) 177.44,61.38 177.2,61.62 v3(177.2,61.7) 177.2,62.08 176.65,62.62 Q350.3
SLEEVE: length 60.2
  IN2 w1.016: 13.62,70.39 14.51,70.39 23.46,61.44 23.46,54.08 20.56,51.17 20.56,28.06 23.25,25.37 24.48,25.37 28.73,21.12
  BOTTOM w0.102: v6(29.43,22.13) 29.62,21.94 v5(29.62,21.18)
  vias: v5(12.22,70.39) v5(12.8,70.39) v5(29.62,20.61)

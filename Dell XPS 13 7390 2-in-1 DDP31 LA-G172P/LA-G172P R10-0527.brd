# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N57277748: length 2.7
  TOP w0.081: UC6.4 180.86,42 181.92,40.94 RC624.1
N57317701:
  vias: v3(201.85,9.48)
N57317721: length 6.2
  TOP w0.254: v1(196.01,6.17) 196.01,6.72 196.16,6.87 PU1500.8
  IN1 w0.254: v1(196.01,6.17) 196.02,6.19 196.02,6.99 195.57,7.45 v1(195.57,10.82)
N57317835: length 1.2
  TOP w0.254: PU1500.5 196.15,9.61 PR1507.1
N57406634: length 0.8
  TOP w0.254: PR1503.1 195.96,5.08 195.71,4.84 PC1506.2
N57457324: length 2.7
  TOP w0.203: PC1103.2 PR1117.2 98.41,44.13 PU1100.4
N57485049: length 1.2
  TOP w0.203: PR1204.2 101.73,34.77 101.96,35 PU1200.11
N57485111: length 1.4
  TOP w0.203: PR1205.2 101.7,25.5 101.94,25.74 PU1201.11
N57612688: length 1.3
  TOP w0.254: PU900.15 142.46,12.93 142.23,13.16 PR908.1
N57652232: length 3.9
  TOP w0.081: PQ100.5 95.73,10.45 PR104.2 PR100.1 94.32,10.37 94.13,10.18 v3(93.89,10.18) 93.89,10.73 PR103.2
N57652736: length 2.5
  TOP w0.081: v3(97.51,11.4) 96.48,10.37 PR102.1 96.38,10.44 PQ100.6
N57652767:
  vias: v3(94.27,13.94)
N57792379: length 4.4
  BOTTOM w0.081: R114.2 R113.2 C100.1 113.32,4.46 v3(113.26,4.52) 112.78,4.52 112.5,4.8 JMIPI60.12
N57957180: length 12.2
  BOTTOM w0.297: L24.1 CW5.1 106,76.31 108.06,74.25 JANTL3.1
N57957195: length 3.9
  BOTTOM w0.297: L24.2 97.71,76.31 CW6.1 v5(97.71,80.19)
N57957882: length 4.9
  BOTTOM w0.297: v5(200.35,80.19) CW8.1 200.35,78.03 arc(200.34,77.92) 200.31,77.82 arc(200.1,77.55) 199.77,77.44 CW7.1 L27.2
N58351095: length 4.4
  BOTTOM w0.081: JDEBUG2.8 211.53,68.32 211.55,68.3 RE193.2 RE428.2 210.68,67.89 210.34,68.24 208.8,68.24 v3(208.66,68.1)
N58362161: length 4.1
  BOTTOM w0.081: v3(159.61,81.89) 159.61,80.81 159.25,80.45 R710.1 R6207.2 158.9,79.44 158.9,79.02 158.48,78.6 QC1.3
N58555606: length 13.6
  IN3 w0.064: v4(126.92,77.4) 127.18,77.67 128.89,77.67 129.19,77.98 129.19,79.96 128.24,80.91 128.24,82.75 128.85,83.36 v4(130.31,83.36)
  BOTTOM w0.081: R622.2 v4(126.92,77.4) v3(126.92,76.49) ; CV651.1 132.24,83.67 DV12.1 130.61,83.67 v4(130.31,83.36)
N58555679: length 1.5
  BOTTOM w0.081: QV20.1 127.06,78.92 127.49,78.48 R628.2
N58555687: length 0.9
  BOTTOM w0.081: QV20.2 125.98,78.58 126.35,78.22 R622.1
N58555721: length 1.6
  BOTTOM w0.081: QV20.3 125.71,79.14 125.57,79.01 125.57,78.19 R652.2
N58555838: length 1.9
  BOTTOM w0.081: v3(121.87,77.83) 122.03,78 R627.2 122.8,78.03 QV18.1
N58555842: length 2.6
  BOTTOM w0.081: v3(121.26,80.05) 121.87,80.05 R621.1 121.7,79.44 121.7,78.78 121.78,78.69 QV18.2
N59045842: length 1.9
  TOP w0.081: RE219.1 RE477.2 198.02,55.97 QE15.3
N59045862: length 3
  TOP w0.081: RE219.2 197.71,59.28 198.15,59.73 QE16.2
N59074234: length 5
  TOP w0.081: CE109.1 212.77,48.47 213.72,48.47 RE479.2 214.17,49.31 213.85,49.63 213.85,50.66 214.09,50.9 UE6.7
N59074244: length 4.2
  TOP w0.081: v3(215.74,48.11) 215.85,48.11 216.16,48.41 RE480.1 216.53,49.36 216.53,49.91 QE19.2 215.93,49.9 UE6.5
N59074258: length 3
  TOP w0.254: UE6.3 212.71,50.4 212.94,50.62 212.94,51.65 RE478.2
N59591429: length 1.4
  TOP w0.081: C224.1 174.58,70.13 U34.12
N59591541: length 1.3
  TOP w0.081: C237.1 175.38,70.22 U34.10
N59636611:
  vias: v3(180.12,15.28)
N59636658: length 2.9
  TOP w0.081: Q348.1 184.31,15.66 v3(183.87,15.21) R5768.2
N60250631:
  vias: v3(67.11,19.85)
N60434250: length 0.6
  BOTTOM w0.081: CC659.1 RC734.2
N61867318: length 0.9
  IN1 w0.064: v2(205.39,4.86) 205.18,4.65 v1(205.18,4.48)
  IN3 w0.064: v4(205.39,5.25) v2(205.39,4.86)
N62320917: length 1.4
  TOP w0.081: US1.6 217.14,7.69 CS95.1
N62322923: length 2.6
  TOP w0.081: CT362.1 14.5,37.48 14.92,37.05 UT1.6
N62323625: length 1.6
  TOP w0.081: UT2.6 288.76,31.78 CT210.1
N62327553: length 1.4
  TOP w0.081: C4189.1 190.47,53.06 UC24.6
N62327555: length 1.5
  TOP w0.081: UC25.6 67.6,14.26 67.15,13.82 C234.1
N62327559: length 2.5
  TOP w0.081: UC28.6 95,6.5 C4205.1 v3(94.66,7.83)
N62327561: length 3.1
  TOP w0.081: U734.6 188.43,15.65 188.56,15.78 189.66,15.78 C4209.1 v3(190.9,15.54)
N62327579: length 1.5
  TOP w0.081: C1676.1 200.95,27.28 201.46,26.77 U733.6
N62332316: length 4.4
  TOP w0.081: C1683.1 217.38,48.22 217.14,47.98 v3(217.01,47.98) 216.63,47.98 216.21,47.56 216.21,47.09 216.38,46.92 216.38,45.94 216.5,45.81 U735.6
N64510614: length 1.7
  TOP w0.081: U60.6 266,20.21 265.68,20.53 C4213.1
N65197718: length 2.5
  TOP w0.081: U36.6 42.24,16.67 C245.1 v3(42.23,17.94)
N65755618: length 3.1
  TOP w0.081: UC30.6 238.81,17.41 238.7,17.53 238.7,18.03 238.97,18.3 C227.1 v3(238.97,19.89)
N65757083: length 2.1
  TOP w0.081: C244.1 19.34,23.85 19.72,24.23 19.72,24.61 U51.6
N66149970: length 1.8
  BOTTOM w0.081: RW36.1 RW1.1 196.44,62.39 196.49,62.45 UW2.4
N66651145: length 3
  BOTTOM w0.081: v3(196.36,56.73) 195.98,57.11 195.41,57.11 195.26,57.26 RW39.1 195.26,57.57 195.26,57.69
  BOTTOM w0.089: QW2.2 QW2.3 195.26,57.69
N66651168: length 3
  BOTTOM w0.081: v3(198.06,59.95) 197.48,59.37 RW45.2 196.6,59.37 196.58,59.39 QW2.6
  BOTTOM w0.089: RW40.1 RW45.2
N67742614: length 0.8
  TOP w0.081: C453.1 R648.1
N67754895: length 12.7
  TOP w0.081: RE494.1 v1(205.86,67.92) ; UE1.K1 206.46,58.76 206.22,58.52 v1(205.84,58.52)
  IN1 w0.064: v1(205.86,67.92) 205.86,67.67 206.5,67.03 206.5,64.74 205.91,64.15 205.91,63.18 206.11,62.98 206.11,60.71 205.74,60.34 205.74,58.62 v1(205.84,58.52)
N71871431: length 8.4
  TOP w0.081: R30.2 95.59,68.32 93.77,66.5 92.53,66.5 92.11,66.08 90.44,66.08 90.28,65.91 R633.2 89.83,65.66 89.6,65.42 Q16.6
N72909470: length 17
  TOP w0.081: D132.1 66.01,16.82 66.01,11.72 v6(66.9,10.83) 66.99,10.74 R38.1 65.69,9.75 64.45,8.51 JFAN1.3
N72910554: length 14.3
  TOP w0.081: v6(230.02,8.78) 231.74,8.78 232.53,9.56 R41.1 232.66,9.07 232.57,8.98 232.57,6.77 234.14,5.2 D12.1 235.06,4.41 235.93,3.53 v1(236.51,3.53) ; JFAN2.3 238.65,3.42 238.48,3.59 v1(238.41,3.59)
  IN1 w0.064: v1(236.51,3.53) 236.57,3.59 v1(238.41,3.59)
N73050981: length 2.8
  TOP w0.081: QZ20.1 198.3,13.82 198.68,13.44 R789.1 199.19,13.96 v3(199.71,14.48)
N73546395: length 21.3
  BOTTOM w0.297: L27.1 194.81,77.44 191.62,74.25 JANTR1.1
N73773655: length 2.6
  TOP w0.081: Q16.5 89.72,64.77 90.02,65.07 R633.1 90.28,64.35 90.13,64.2 v3(90.13,63.69)
N73857547: length 1.3
  TOP w0.081: RC147.1 221,45.44 220.92,45.52 QC2.6 QC2.5
N73891446: length 1.7
  TOP w0.127: 88.06,63.82 88.48,63.82 89.12,63.17 v3(89.12,62.84)
N76201276: length 2.5
  TOP w0.081: v3(186.48,19.73) 186.15,19.4 R271.1 185.26,19.53 Q3.1
N76327865: length 1
  TOP w0.081: QT1.2 10.19,36.08 RT223.1
N76328430: length 0.8
  TOP w0.081: RT225.1 287.18,23.33 QT2.2

## Copper pours and planes (outline as drawn)
+0.6V_VDDQ on TOP (solid shape): 105.47,61.52 105.47,59.3 105.39,59.23 102.7,59.23 102.59,59.35 102.59,61.5 102.78,61.7 105.29,61.7
+0.6V_VDDQ on TOP: 74.44,64.21 77.29,64.21 77.36,64.13 77.36,62.99 77.15,62.77 74.58,62.77 74.29,63.07 74.29,64.06
+0.6V_VDDQ on IN3: 74.92,62.77 84.32,62.77 84.74,63.19 87.94,63.19 89.41,61.73 89.41,59.57 90.58,58.39 100.96,58.39 101.12,58.55 103.06,58.55 103.28,58.77 103.28,61.63 103.09,61.82 94.13,61.82 93.06,62.89 93.06,64.93 91.61,66.38 89.8,66.38 89.47,66.71 74.77,66.71 74.45,66.39 74.45,63.5 74.73,63.22 74.73,62.97
+0.6V_VDDQP on TOP (solid shape): 77.59,70.27 77.59,67.66 77.01,67.08 77.01,64.45 76.92,64.36 76.41,64.36 76.41,63.82 76.4,63.82 76.17,63.82 76.17,64.37 75.61,64.37 75.61,63.82 75.37,63.82 75.37,64.36 74.9,64.36 74.77,64.49 74.77,70.2 74.9,70.33 77.52,70.33
+0.9V_TBT_L_LVR on TOP: 13.7,45.21 15.3,45.21 15.45,45.36 16.17,45.36 16.19,45.38 16.19,45.95 16.17,45.96 15.42,45.96 15.03,45.58 13.69,45.58 13.64,45.53 13.64,45.27
+0.9V_TBT_L_SVR on TOP (solid shape): 18.89,41.88 18.89,40.93 18.78,40.82 17.01,40.82 16.81,40.62 16.81,39.64 16.7,39.53 15.83,39.53 15.64,39.72 15.64,40.33 15.22,40.75 15.22,41.13 15.26,41.18 15.76,41.18 15.87,41.29 15.87,41.78 16.1,42.01 18.77,42.01
+0.9V_TBT_L_SVR on IN1 (solid shape): 16.92,42.14 16.92,40.22 16.49,39.79 15.91,39.79 15.78,39.91 15.78,42.2 15.84,42.26 16.8,42.26
+0.9V_TBT_L_SVR on BOTTOM: 9.94,43.52 9.94,48.1 10.09,48.25 12.64,48.25 12.71,48.18 12.71,43.45 12.63,43.37 10.09,43.37
+0.9V_TBT_L_SVR on IN2: 10.5,47.47 10.5,42.3 11.08,41.72 15.21,41.72 15.74,41.18 15.78,41.18 16.1,40.87 16.8,40.87 16.99,41.06 16.99,43.49 15.78,44.69 15.78,47.14 15.2,47.73 10.75,47.73
+0.9V_TBT_R_SVR on TOP (solid shape): 285.17,32.74 285.82,32.74 286.07,32.49 286.07,31.45 285.79,31.17 285.34,31.17 285.02,30.86 285.02,30.33 284.91,30.22 283.86,30.22 283.81,30.26 283.81,30.71 283.43,31.09 282.66,31.09 282.63,31.12 282.63,32.85 282.74,32.97 284.94,32.97
+0.9V_TBT_R_SVR on IN1: 279.74,39.03 279.25,39.03 279.11,39.17 278.91,39.17 278.8,39.06 278.8,36.37 279.02,36.15 279.02,33.22 279.48,32.77 281.71,32.77 282.08,32.4 284.8,32.4 284.89,32.5 284.89,33.05 282.19,35.75 280.76,35.75 280.36,36.14 280.36,38.16 280.88,38.67 280.88,38.93 280.59,39.21 279.92,39.21
+0.9V_TBT_R_SVR on VCC: 279.22,39.06 280.56,39.06 280.84,38.78 280.84,38.59 280.41,38.15 280.41,36.26 280.88,35.79 282.18,35.79 284.93,33.04 284.93,32.51 284.8,32.38 282.09,32.38 281.71,32.76 279.47,32.76 279.02,33.22 279.02,36.15 278.78,36.38 278.78,38.63
+1.1V_MEM on TOP (solid shape): 161.3,54.72 161.3,51.33 161.01,51.03 160.34,51.03 160.33,51.03 160.33,51.85 160.33,51.9 160.24,51.99 160.24,52.04 160.34,52.14 160.34,52.84 160.22,52.97 159.63,52.97 159.53,53.07 159.53,54.74 159.6,54.81 161.21,54.81
+1.1V_MEM on TOP (solid shape): 147.59,54.32 147.59,53.02 147.44,52.87 147.44,52.31 147.47,52.28 147.47,52.27 147.48,52.27 147.58,52.17 147.89,52.17 148.08,51.98 150.17,51.98 150.17,51.31 149.77,50.9 147.95,50.9 147.95,51.07 147.39,51.07 147.39,50.9 146.65,50.9 146.59,50.96 146.59,51.08 146.65,51.14 146.65,51.87 146.39,52.13 145.98,52.13 145.82,52.3 145.82,54.33 145.89,54.41 147.5,54.41
+1.1V_MEM on TOP (solid shape): outline of 5518 points within 131.02,53.81 167.29,70.94
+1.1V_MEM on TOP (solid shape): outline of 17775 points within 104.79,40.24 160.44,70.84
+1.1V_MEM on BOTTOM: 156.56,41.59 156.22,41.25 155.65,41.25 155.34,41.48 155.03,41.25 153.29,41.25 152.68,40.64 136.94,40.64 136.33,41.25 136.11,41.38 135.89,41.25 135.32,41.25 135.1,41.38 134.88,41.25 129,41.25 119.73,50.52 106.52,50.52 105.51,51.54 105.51,54.84 105.76,55.09 120.43,55.09 122.56,52.96 132.4,52.96 135.41,49.95 150.65,49.95 156.56,44.04
+1.1V_MEM on IN2: 157.96,54.5 157.96,54.09 157.97,54.09 157.97,53.92 158.05,53.84 162.61,53.84 162.73,53.97 162.73,54.54 162.47,54.81 161.02,54.81 160.87,54.95 159.5,54.95 159.15,54.6 158.05,54.6 158.05,54.59
+1.1V_MEM on IN2: 148.98,53.77 149.24,54.02 149.24,54.47 149.01,54.7 144.2,54.7 144.08,54.59 144.08,54.03 144.35,53.77
+1.1V_MEM on IN2: outline of 173 points within 104.59,53.52 166.2,68.81
+1.1V_MEMP on TOP (solid shape): 104.15,58.44 104.15,56.13 104.62,55.66 104.62,51.59 104.52,51.48 102.15,51.48 102.07,51.57 102.06,51.58 102.01,51.65 101.93,51.71 101.92,51.72 101.65,51.99 101.65,55.37 101.47,55.55 99.26,55.55 99.08,55.73 99.08,58.15 99.6,58.67 103.92,58.67
+1.05V_VCCST on TOP (solid shape): 110.89,21.36 110.89,18.98 110.84,18.93 110.68,18.93 110.36,19.18 110.04,18.93 109.76,18.93 109.68,19.01 109.68,21.33 109.75,21.4 110.85,21.4
+1.05V_VCCSTG on TOP: 124.88,19.52 124.88,18.54 124.99,18.42 128.69,18.42 129.21,18.94 132.62,18.94 133.13,19.45 133.13,20.51 133.52,20.9 133.52,21.73 133.5,21.76 133.12,21.76 133.06,21.7 133.06,21.26 133.02,21.21 132.4,21.21 132.32,21.29 132.32,21.75 132.25,21.81 131.3,21.81 131.26,21.77 131.26,21.28 131.2,21.21 130.05,21.21 130,21.27 130,21.78 129.96,21.81 129.58,21.81 129.49,21.73 129.49,20.21 128.79,19.51 125.7,19.51 125.62,19.59 124.95,19.59
+1.8V_1.2V_SSD on TOP (solid shape): 190.85,18.01 190.85,16.42 190.66,16.23 188.75,16.23 188.67,16.31 188.67,17.37 188.63,17.41 188.63,18.07 188.82,18.26 190.6,18.26
+1.8V_1.2V_SSD_R on TOP (solid shape): 187.99,17.31 187.99,16.34 188.06,16.27 188.06,14.83 187.99,14.77 186.17,14.77 186.02,14.92 186.02,15.31 186.6,15.88 186.6,16.81 187.16,17.37 187.93,17.37
+1.8V_1.2VDX_SSD on BOTTOM (solid shape): outline of 409 points within 193.57,28.12 207.16,37.5
+1.8V_1.2VDX_SSD on TOP: 191.1,28.68 192.18,29.75 194.98,29.75 195.23,29.5 195.23,27.53 194.15,26.45 194.15,16.32 193.77,15.94 191.31,15.94 191.1,16.14
+1.8V_1.2VDX_SSD on TOP: 198.09,36.71 198.09,34.16 198.45,33.79 203.33,33.79 203.4,33.87 203.4,36.55 203.17,36.78 201.92,36.78 201.63,36.49 201.63,34.5 201.5,34.36 199.85,34.36 199.77,34.44 199.77,36.67 199.64,36.8 198.18,36.8
+1.8V_3.3V_ALW_VTR3 on BOTTOM (solid shape): 209.41,56.16 210.33,56.16 210.53,55.96 210.53,55.71 210.42,55.6 209.23,55.6 208.48,56.35 208.48,56.61 208.68,56.82 208.75,56.82
+1.8V_3.3V_ALW_VTR3 on TOP: 200.74,67.92 200.8,67.86 200.8,66.73 200.77,66.7 200.38,66.7 200.18,66.9 199.72,66.9 199.14,66.32 198.75,66.32 198.67,66.4 198.67,67.86 198.72,67.92
+1.8V_MEM on TOP (solid shape): 170.73,61.89 170.73,61.38 170.65,61.3 170.65,60.28 170.61,60.24 168.56,60.24 168.42,60.37 168.42,61.96 168.66,62.2 170.41,62.2
+1.8V_MEM on TOP: 139.92,59.16 140.37,59.16 140.62,58.9 140.62,57.69 140.56,57.63 140.11,57.63 139.86,57.89 139.86,59.09
+1.8V_MEM on BOTTOM: 122.62,55.73 121.23,57.11 120.76,57.11 120.72,57.15 108.64,57.15 107.97,57.82 107.97,68.01 108.32,68.36 136.45,68.36 136.51,68.3 136.51,67.78 136.49,67.71 136.42,67.68 136.13,67.31 136.5,67.02 136.58,66.99 136.61,66.92 136.61,66.49 136.69,66.41 138.48,66.41 138.6,66.53 138.6,68.19 138.76,68.36 164.16,68.36 168.96,63.56 168.96,59.61 166.31,56.96 155.89,56.96 154.66,55.73
+1.8V_MEM_R on TOP (solid shape): 172.08,62.21 172.08,59.33 171.93,59.18 170.32,59.18 170.25,59.26 170.25,59.62 170.42,59.8 171.01,59.8 171.19,59.98 171.19,60 171.41,60.22 171.41,61.48 171.44,61.51 171.44,62.2 171.55,62.3 171.99,62.3
+1.8V_PRIM on TOP (solid shape): 69.06,18.45 69.06,16.74 68.87,16.55 68.04,16.55 67.98,16.61 67.98,17.5 67.34,18.13 67.34,18.52 67.41,18.58 68.93,18.58
+1.8V_PRIM on TOP (solid shape): 138.65,3.66 138.65,3.28 138.91,3.02 138.91,2.64 138.88,2.61 137.48,2.61 137.38,2.7 137.38,3.02 137.64,3.28 137.64,3.66 137.7,3.72 138.59,3.72
+1.8V_PRIM on TOP (solid shape): 149.42,19.58 149.42,17.96 149.35,17.89 148.19,17.89 148.05,17.75 148.05,16.71 148.12,16.64 148.12,16.07 148,15.94 146.85,15.94 146.76,16.03 146.76,19.56 146.84,19.64 149.36,19.64
+1.8V_PRIM on TOP (solid shape): 197.62,23.53 197.62,22.73 197.1,22.73 197.1,22.07 197.62,22.07 197.62,21.53 197.1,21.53 197.1,20.87 197.62,20.87 197.62,20.82 197.61,20.81 197.61,19.4 197.42,19.21 195.09,19.21 194.93,19.37 194.93,23.42 195.09,23.58 197.56,23.58
+1.8V_PRIM on TOP (solid shape): 181.13,36.1 181.13,35.15 181.45,34.83 182.29,34.83 182.34,34.79 182.34,34.12 182.31,34.1 181.41,34.1 181.2,33.88 181.2,32.55 181.07,32.42 180.12,32.42 179.99,32.55 179.99,34.96 180.25,35.22 180.34,35.22 180.4,35.28 180.4,36.13 180.44,36.17 181.07,36.17
+1.8V_PRIM on TOP (solid shape): 172.67,58.94 172.67,57.33 172.58,57.23 171.49,57.23 171.37,57.12 171.37,56.64 171.49,56.52 172.14,56.52 172.18,56.48 172.18,56.09 172.16,56.07 171.48,56.07 171.45,56.03 171.45,55.63 171.42,55.59 170.79,55.59 170.12,56.26 170.12,58.97 170.14,58.99 172.62,58.99
+1.8V_PRIM on TOP (solid shape): outline of 88 points within 191.61,48.81 196.41,52.77
+1.8V_PRIM on IN1 (solid shape): 148.04,16.8 148.04,16.05 148.01,16.01 146.03,16.01 146,16.04 146,16.73 146.13,16.86 147.99,16.86
+1.8V_PRIM on IN1 (solid shape): 171.6,56.48 171.99,56.48 172.13,56.35 172.13,55.78 172.01,55.66 170.73,55.66 170.55,55.84 170.55,56.44 170.62,56.51 171.57,56.51
+1.8V_PRIM on TOP: 199.66,66.67 200.16,66.67 200.3,66.53 200.77,66.53 200.82,66.48 200.82,65.53 200.74,65.45 199.56,65.45 199.34,65.67 199.34,66.35
+1.8V_PRIM on VCC: 170.89,19.91 170.53,20.27 170.53,56.13 171.02,56.62 178.17,56.62 188.2,46.58 198.36,46.58 198.98,45.97 198.98,33.99 196.95,31.96 196.95,28.44 197.86,27.53 198.49,27.53 198.98,27.05 198.98,20.27 198.62,19.91
+1.8V_PRIMP on TOP (solid shape): 204.54,23.59 204.54,20.52 204.53,20.51 204.53,19.4 204.09,18.95 203.57,18.95 202.26,20.26 199.39,20.26 199.1,19.97 197.8,19.97 197.71,20.06 197.71,20.77 197.72,20.78 197.72,20.98 197.2,20.98 197.2,21.43 197.72,21.43 197.72,22.18 197.2,22.18 197.2,22.63 197.72,22.63 197.72,23.51 198.06,23.85 204.29,23.85
+1.8VS_AUDIO on TOP (solid shape): 68.99,12.23 68.99,11.78 68.68,11.47 68.49,11.47 68.36,11.34 68.36,11.02 68.3,10.96 67.65,10.96 67.59,11.02 67.59,12.03 67.87,12.31 68.91,12.31
+1.8VS_AUDIO_R on TOP (solid shape): 68.93,14.9 68.93,13.05 68.9,13.03 67.94,13.03 67.91,13.05 67.91,15.09 67.98,15.15 68.68,15.15
+1.8VS_R on TOP: 189.79,52.7 191.9,52.7 191.93,52.67 191.93,51.9 191.71,51.68 189.81,51.68 189.78,51.71 189.78,52.69
+3.3V_ALW2 on TOP (solid shape): 79.22,58.7 80.51,58.7 80.51,58.27 78.44,58.27 78.39,58.32 78.39,58.85 78.43,58.89 79.03,58.89
+3.3V_ALW_UE1 on TOP: 202.92,62.24 203.37,62.24 203.4,62.21 203.4,60.98 203.96,60.42 205.23,60.42 205.58,60.76 207.24,60.76 207.37,60.64 207.37,60.04 207.22,59.89 206.28,59.89 205.2,58.81 204.61,58.81 204.56,58.87 204.56,59.62 204.45,59.73 202.49,59.73 202.46,59.76 202.46,61.05 202.85,61.44 202.85,62.16
+3.3V_TBT_L on TOP (solid shape): 12.8,37.31 13.3,37.31 13.37,37.25 13.37,36.55 13.18,36.36 13.18,35.66 13.05,35.53 12.29,35.53 12.22,35.6 12.22,36.13 12.01,36.34 11.1,36.34 11.02,36.42 11.02,37.43 11.09,37.5 12.61,37.5
+3.3V_TBT_L_B on TOP (solid shape): 15.78,36.61 15.78,35.79 15.48,35.49 13.66,35.49 13.62,35.53 13.62,36.36 13.75,36.49 14.38,36.49 14.59,36.69 15.7,36.69
+3.3V_TBT_L_SVR on TOP (solid shape): 17.43,45.06 17.43,44.11 17.39,44.06 14.73,44.06 14.54,44.26 14.16,44.26 14.08,44.33 14.08,45.03 14.12,45.07 17.42,45.07
+3.3V_TBT_R on TOP (solid shape): 289,36.42 289,34.67 288.69,34.36 288.69,33.09 288.47,32.87 286.87,32.87 286.76,32.98 286.76,33.7 285.9,34.56 285.9,35.05 285.95,35.1 288.05,35.1 288.1,35.15 288.1,35.28 288.4,35.58 288.4,36.45 288.43,36.48 288.93,36.48
+3.3V_TBT_R_B on TOP (solid shape): 288,32.19 288,31.61 288.42,31.19 288.42,30.05 288.37,30 287,30 286.21,30.79 286.21,31.13 286.61,31.53 286.61,31.82 287.11,32.32 287.87,32.32
+3.3V_TBT_R_LC on TOP (solid shape): 276.92,29.36 276.92,28.87 276.83,28.79 276.34,28.79 276.07,28.94 275.79,28.79 275.27,28.79 275,28.93 274.74,28.79 274.69,28.79 274.63,28.72 274.63,28.27 274.59,28.23 274.26,28.23 274.19,28.3 274.19,29.33 274.27,29.41 276.86,29.41
+3.3V_TBT_R_SVR on TOP: 285.85,35.43 285.83,35.45 285.83,35.92 285.73,36.02 283.15,36.02 282.69,36.49 282.31,36.49 282.29,36.46 282.04,36.46 281.95,36.55 281.95,37.06 281.99,37.1 283.75,37.1 284.03,36.82 285.46,36.82 285.47,36.81 286.03,36.81 286.54,36.3 286.54,35.45 286.53,35.43
+3.3V_VPS_TPM on TOP (solid shape): 217.33,15.98 217.33,14.67 216.54,13.88 216.54,13.16 216.4,13.01 215.49,13.01 215.39,13.11 215.39,13.44 215.78,13.83 215.78,14.72 215.39,15.11 215.39,15.69 215.81,16.1 217.2,16.1
+3.3V_VPS_TPM on TOP (solid shape): 215.93,10.13 215.93,9.51 215.86,9.43 215.54,9.43 215.45,9.34 215.45,8.88 215.39,8.82 214.87,8.82 214.74,8.95 213.6,8.95 213.52,9.03 213.52,9.17 213.57,9.22 214.43,9.22 214.93,9.72 214.93,10.15 214.99,10.21 215.86,10.21
+3.3V_VPS_TPM on TOP (solid shape): 212.32,6.18 212.32,5.29 212.5,5.11 212.5,4.27 212.42,4.19 211.92,4.19 211.31,3.58 209.72,3.58 209.38,3.24 207.72,3.24 207.28,3.68 207.28,4.43 207.35,4.5 208.3,4.5 208.46,4.33 209.24,4.33 209.4,4.5 209.49,4.5 210.12,5.14 211.8,5.14 212.04,5.37 212.04,6.16 212.11,6.23 212.27,6.23
+3.3V_VPS_TPM on IN1: 215.64,13.41 216.26,13.41 216.34,13.33 216.34,11.91 215.62,11.2 215.62,7.54 216.97,6.19 216.97,5.28 216.87,5.18 216.14,5.18 214.78,6.54 214.78,11.83 215.52,12.56 215.52,13.29
+3.3V_VPS_TPM on IN2: 216.76,5.91 210.34,5.91 210.05,5.63 210.05,4.27 210.25,4.07 216.96,4.07 217.13,4.24 217.13,5.54
+3.3VDX_SSD on BOTTOM (solid shape): 202.53,33.37 202.53,31.53 202.99,31.07 206.99,31.07 207.18,30.89 207.18,30.29 207.04,30.16 205.72,30.16 205.58,30.01 205.58,28.37 205.25,28.04 199.3,28.04 198.98,28.36 198.98,31.85 200.63,33.5 202.41,33.5
+3.3VDX_SSD on TOP: 196.44,25.88 198.41,25.88 198.85,25.44 199.49,25.44 199.61,25.56 199.61,26.58 199.23,26.96 199.23,27.79 199.49,28.04 202.72,28.04 203.17,28.48 203.17,33.18 202.85,33.5 198.47,33.5 198.28,33.31 198.28,29.88 196.85,28.46 196.85,26.99 196.76,26.9 196.38,26.9 196.31,26.83 196.31,26.01
+3.3VDX_SSD on TOP: 201.58,45.57 200.12,45.57 199.99,45.44 199.99,43.85 200.12,43.72 201.65,43.72 201.71,43.79 201.71,45.44
+3.3VDX_SSD on BOTTOM: 201.52,46.01 199.93,46.01 199.87,45.95 199.87,44.04 200.12,43.79 201.65,43.79 201.77,43.92 201.77,45.76
+3.3VDX_SSD on VCC: 198.07,28.04 197.45,28.65 197.45,31.74 199.49,33.78 199.49,45.82 203.7,45.82 204.19,45.33 204.19,29.16 203.06,28.04
+3.3VDX_SSD_R on TOP: 202.29,26.44 200.32,26.44 200.18,26.3 200.18,24.96 200.24,24.89 202.17,24.89 202.36,25.08 202.36,26.37
+3V_1.8V_HDA_R on TOP (solid shape): 179.61,39.79 179.61,39.53 179.75,39.39 180.62,39.39 180.65,39.36 180.65,38.07 180.62,38.04 179.07,38.04 179.04,38.07 179.04,39.32 179.04,39.72 179.17,39.85 179.55,39.85
+3V_5V_CAM_PWR on TOP: 169.13,67.92 169.7,67.92 169.71,67.92 170.68,67.92 170.92,67.67 171.22,67.67 171.36,67.54 171.36,64.96 171.07,64.68 170.09,64.68 169.83,64.94 169.83,66.39 169.51,66.71 169.13,66.71 169.01,66.84 169.01,67.79
+3V_NB_LID on TOP (solid shape): 91.66,12.64 91.66,7.97 91.6,7.91 90.84,7.91 90.58,7.66 90.58,6.89 90.52,6.83 89.31,6.83 89.25,6.89 89.25,8.99 89.31,9.05 89.88,9.05 90.08,9.26 90.08,12.67 90.2,12.79 91.52,12.79
+3V_NB_LID_R on TOP: 214.14,51.22 214,51.37 214,52.58 214.17,52.74 215.31,52.74 215.45,52.6 215.45,51.35 215.32,51.22
+3V_PRIM on BOTTOM (solid shape): 218.56,16.95 218.56,16.11 218.36,15.9 213.59,15.9 212.66,16.83 212.66,17.07 212.89,17.3 218.22,17.3
+3V_PRIM on BOTTOM (solid shape): 175.22,37.92 175.22,36.64 175.29,36.56 176.1,36.56 176.46,36.2 178.91,36.2 179.65,35.45 179.65,32.5 179.61,32.46 178.97,32.46 178.94,32.5 178.94,35.42 178.71,35.65 176.49,35.65 176.04,35.2 173.41,35.2 173.35,35.26 173.35,35.81 173.28,35.89 172.75,35.89 172.56,35.7 172.56,35.31 172.5,35.25 172.12,35.25 172.08,35.29 172.08,36.24 173.73,36.24 173.73,36.27 174.29,36.27 174.29,36.83 173.73,36.83 173.73,36.85 173.1,36.85 173.1,36.24 172.08,36.24 172.08,36.36 171.96,36.48 171.5,36.48 171.45,36.53 171.45,36.92 171.31,37.05 171.31,37.06 169.45,37.06 169.31,36.91 169.31,36.91 169.31,35.89 169.44,35.76 170.56,35.76 170.62,35.7 170.62,35.31 170.32,35.31 170.27,35.25 168.78,35.25 168.75,35.28 167.93,35.28 167.74,35.47 167.74,37.11 168.7,38.07 175.06,38.07
+3V_PRIM on IN1 (solid shape): 169.2,37.57 169.2,37.25 169.13,37.18 169.13,36.8 169.2,36.74 169.2,36.55 169.2,36.36 168.94,36.1 168.77,36.02 168.69,35.85 168.24,35.41 167.93,35.41 167.86,35.47 167.86,35.85 168.12,36.11 168.2,36.11 168.37,36.28 168.37,36.36 168.56,36.55 168.56,37.57 168.69,37.69 169.07,37.69
+3V_PRIM on TOP: 188.95,31.96 189.14,31.77 189.14,30.82 189.18,30.78 191.89,30.78 192.06,30.61 192.06,30.08 190.97,28.99 190.28,28.99 189.79,28.5 189.22,28.5 189.14,28.58 189.14,29.55 188.41,30.28 187.72,30.28 187.5,30.49 187.5,31.9 187.56,31.96
+3V_PRIM on TOP: 183.78,39.05 183.78,37.76 182.84,36.83 182.84,35.69 182.77,35.61 182.23,35.61 182.18,35.66 182.18,37.07 183.16,38.05 183.16,38.59 182.98,38.77 181.98,38.77 181.98,38.77 181.04,38.77 180.98,38.83 180.98,40.14 180.93,40.19 179.81,40.19 179.66,40.04 179.22,40.04 179.19,40.08 179.19,41.19 179.1,41.28 179.1,41.63 179.17,41.69 180.99,41.69 181.55,41.13 181.55,39.62 181.64,39.52 183.3,39.52
+3V_PRIM on TOP: 207.61,12.42 207.23,12.8 207.23,14.32 207.3,14.39 212.3,14.39 212.82,14.91 212.82,16.85 213,17.03 215.04,17.03 215.11,16.96 215.11,12.9 214.63,12.42
+3V_PRIM on BOTTOM: 160.92,45.27 160.98,45.22 160.98,44.73 161.01,44.7 162.84,44.7 162.88,44.74 162.88,45.22 162.94,45.27 164.09,45.27 164.32,45.04 164.78,45.04 164.97,44.86 164.97,43.8 164.99,43.77 168,43.77 168.2,43.57 168.2,42.97 168.14,42.9 167.45,42.9 167.25,43.1 164.99,43.1 164.89,43 164.89,42.25 164.69,42.05 161.02,42.05 160.98,42.1 160.98,43.18 161.01,43.21 162.1,43.21 162.15,43.16 162.15,43.08 162.15,43.07 162.15,42.73 162.2,42.68 162.8,42.68 162.83,42.7 162.83,43.88 162.77,43.93 158.36,43.93 158.24,44.05 158.24,45.21 158.3,45.27
+3V_PRIM on BOTTOM: 120.07,3.28 120.11,3.32 120.48,3.32 120.53,3.26 120.53,2.89 120.64,2.79 121.88,2.79 121.97,2.88 121.97,3.28 122.03,3.34 122.39,3.34 122.45,3.27 122.45,3.11 122.47,3.09 123.31,3.09 123.44,3.22 123.44,4.19 123.48,4.23 124.02,4.23 124.12,4.14 124.12,2.21 123.9,2 120.21,2 120.07,2.14
+3V_PRIM on BOTTOM: 111.3,16.25 111.3,18.09 111.39,18.18 111.39,18.64 111.31,18.72 110.6,18.72 110.1,18.22 109.48,18.22 109.42,18.28 109.42,18.57 109.46,18.61 109.82,18.61 110.32,19.11 111.98,19.11 112.03,19.06 112.03,17.06 111.77,16.8 111.77,16.24 111.7,16.18 111.37,16.18
+3V_PRIM on IN3: 167.14,36.51 168.25,36.51 168.58,36.84 168.58,37.44 168.88,37.73 169.29,37.73 169.41,37.61 169.41,36.15 169.33,36.07 168.87,36.07 168.73,35.93 168.73,35.42 168.57,35.27 167.16,35.27 167.06,35.37 167.06,36.42
+3V_PRIM_R on TOP (solid shape): 206.6,15.21 206.6,13.44 206.53,13.37 204.69,13.37 204.63,13.44 204.63,14.26 205.7,15.33 206.47,15.33
+3V_SPI on BOTTOM: 188.39,39.96 188.22,39.79 187.08,39.79 186.99,39.89 186.99,40.19 186.89,40.29 185.89,40.29 185.87,40.32 185.87,41.16 185.93,41.23 188.27,41.23 188.39,41.11
+3VALW on TOP (solid shape): 107.39,70.16 107.39,69.27 107.35,69.23 105.4,69.23 105.29,69.34 105.29,70.15 105.37,70.23 107.31,70.23
+3VALW on TOP (solid shape): 266,23.06 266,21.8 265.87,21.68 263.9,21.68 263.6,21.98 263.6,23 263.79,23.19 265.87,23.19
+3VALW on TOP (solid shape): 288.45,28.59 288.45,27.51 288.95,27.01 288.95,26.48 288.9,26.44 288.5,26.44 288.33,26.26 287.24,26.26 287.12,26.39 287.12,28.42 287.36,28.66 288.37,28.66
+3VALW on TOP (solid shape): 203.3,12.04 203.3,10.9 203.04,10.64 203.04,10.13 202.98,10.07 202.34,10.07 202.15,9.88 201.39,9.88 201.26,10.01 201.26,11.02 201.48,11.23 202.51,11.23 202.64,11.36 202.64,12.04 202.71,12.1 203.23,12.1
+3VALW on TOP (solid shape): 18.38,38.77 18.7,38.77 18.77,38.71 18.77,37.95 19.02,37.69 19.02,36.04 18.89,35.91 17.24,35.91 17.18,35.98 17.18,36.61 17.3,36.74 18.07,36.74 18.13,36.8 18.13,37.31 18.07,37.37 17.24,37.37 17.18,37.44 17.18,39.03 17.24,39.09 18.07,39.09
+3VALW on TOP (solid shape): 77.67,62.3 77.67,60.09 77.57,59.99 76.55,59.99 76.55,60.49 75.9,60.49 75.9,60.49 75.9,59.99 75.35,59.99 75.35,60.49 74.69,60.49 74.69,59.99 74.09,59.99 74.06,60.02 74.06,62.25 74.19,62.38 77.59,62.38
+3VALW on TOP (solid shape): 174.29,67.26 174.29,66.25 173.74,65.7 173.74,65.11 173.67,65.04 172.6,65.04 172.56,65 172.56,64.39 172.62,64.33 174.82,64.33 174.9,64.25 174.9,63.65 174.86,63.62 174.05,63.62 173.92,63.74 172.06,63.74 171.53,64.28 171.53,66.36 171.65,66.49 172.33,66.49 172.84,67 173.37,67 173.66,67.29 174.25,67.29
+3VALW on TOP (solid shape): 206.94,12.06 206.94,11.45 206.92,11.43 206.44,11.43 206.27,11.26 206.27,10.04 206.68,9.63 206.68,8.85 206.6,8.76 205.55,8.76 205.42,8.89 205.42,10.03 205.35,10.1 204.96,10.1 204.95,10.11 204.95,10.77 204.63,11.09 204.63,12.04 204.69,12.1 206.9,12.1
+3VALW on TOP (solid shape): 232.15,10.55 232.15,9.96 232.09,9.9 231.73,9.9 231.65,9.98 231.65,10.09 231.56,10.18 229.48,10.18 229.42,10.25 229.42,10.61 229.29,10.74 228.31,10.74 228.15,10.58 228.15,10.23 228.12,10.19 227.2,10.19 227.16,10.24 227.16,10.54 227.11,10.59 226.58,10.59 226.47,10.48 226.47,10.11 226.43,10.08 226.11,10.08 226.04,10.16 226.04,11.04 226.38,11.38 231.32,11.38
+3VALW on TOP (solid shape): 18.51,28.48 18.51,28.29 18.13,27.91 18.13,27.79 18.95,26.96 18.97,26.96 18.97,26.87 18.48,26.38 18.39,26.38 17.85,26.92 17.67,26.92 17.36,26.6 17.36,26.52 17.9,25.98 17.9,25.8 17.77,25.67 17.45,25.67 16.62,26.5 16.62,27.48 16.63,27.49 16.92,27.49 17.31,27.1 17.73,27.51 17.33,27.91 16.92,27.49 16.63,27.49 16.63,27.92 16.86,28.15 17.29,28.15 17.88,28.74 18.26,28.74
+3VALW on TOP (solid shape): 221.88,24.31 221.88,9.96 221.22,9.3 218.37,9.3 218.3,9.38 218.3,10.34 218.18,10.45 217.58,10.45 217.52,10.51 217.52,14.13 217.71,14.32 217.71,16.46 217.95,16.46 217.95,16.4 217.96,16.35 217.98,16.29 218.01,16.24 218.04,16.19 218.08,16.15 218.12,16.12 218.17,16.09 218.22,16.06 218.27,16.05 218.33,16.04 218.39,16.04 218.44,16.05 218.5,16.06 218.55,16.09 218.6,16.12 218.64,16.15 218.68,16.19 218.71,16.24 218.74,16.29 218.75,16.35 218.76,16.4 218.77,16.46 218.76,16.52 218.75,16.57 218.72,16.62 218.7,16.67 218.66,16.72 218.62,16.76 218.57,16.79 218.52,16.82 218.47,16.84 218.41,16.85 218.36,16.85 218.3,16.85 218.25,16.84 218.19,16.82 218.14,16.79 218.1,16.76 218.06,16.72 218.02,16.67 217.99,16.62 217.97,16.57 217.96,16.52 217.95,16.46 217.71,16.46 217.71,16.55 217.52,16.74 217.52,17.7 217.52,17.7 217.52,18.19 218.85,19.52 218.85,19.58 218.99,19.72 218.99,24.18 219.3,24.48 221.7,24.48
+3VALW on IN1 (solid shape): 105.23,71.84 105.23,71.31 106.5,70.04 106.5,69.44 106.37,69.31 105.52,69.31 104.01,70.83 104.01,71.82 104.18,71.99 105.08,71.99
+3VALW on IN1 (solid shape): 265.52,22.64 265.52,21.43 265.4,21.31 265.08,21.31 264.76,21.63 263.94,21.63 263.75,21.82 263.75,22.49 264.28,23.02 265.14,23.02
+3VALW on IN1 (solid shape): 231.5,10.52 233.96,10.52 234.16,10.32 234.16,6.07 233.14,5.05 232.97,5.05 232.62,5.4 232.62,5.55 232.98,5.91 232.98,9.45 232.62,9.81 231.72,9.81 231.46,10.06 231.13,10.06 230.99,10.21 230.99,10.56 231.06,10.64 231.37,10.64
+3VALW on TOP: 175.71,67.32 176.37,67.32 176.73,67.67 178.04,67.67 178.12,67.59 178.12,65.31 178.01,65.2 176.45,65.2 176.42,65.23 176.42,66.12 176.12,66.42 175.71,66.42 175.66,66.46 175.66,67.27
+3VALW on TOP: 201.33,60.78 201.33,57.47 201.5,57.3 203.68,57.3 203.99,57.61 203.99,58.03 203.95,58.07 203.56,58.07 203.45,58.19 203.45,59.21 203.37,59.29 202.6,59.29 202.36,59.52 202.36,60.73 202.26,60.83 201.38,60.83
+3VALW on TOP: 171.46,13.9 171.46,15.65 171.26,15.85 170.91,15.85 170.86,15.9 170.86,16.48 170.58,16.76 170.58,18.45 170.64,18.52 171.06,18.52 171.13,18.59 171.13,19.73 171.22,19.82 173.24,19.82 173.33,19.73 173.33,19.17 173.54,18.96 174.69,18.96 174.96,18.69 175.9,18.69 176.17,18.96 176.8,18.96 177.02,18.73 177.02,16.95 176.85,16.77 176.13,16.77 175.95,16.59 175.46,16.59 175.43,16.62 175.43,17.08 175.48,17.13 175.86,17.13 176,17.28 176.14,17.28 176.19,17.32 176.19,17.68 176.08,17.79 174.73,17.79 174.53,17.58 174.04,17.58 173.93,17.69 173.93,18.53 173.91,18.55 172.93,18.55 172.79,18.69 171.53,18.69 171.47,18.64 171.47,18.06 171.47,17.97 171.63,17.81 171.63,17.52 171.63,17.52 171.47,17.36 171.47,17 171.76,16.71 172.44,16.71 172.55,16.6 172.55,13.91 172.46,13.83 171.53,13.83
+3VALW on TOP: 247.37,8.36 248.83,8.36 248.95,8.48 248.95,10.15 248.76,10.34 248.17,10.34 247.99,10.52 247.99,10.98 247.88,11.09 247.39,11.09 247.23,11.24 246.62,11.24 246.39,11.47 246.39,11.82 246.33,11.88 245.37,11.88 245.28,11.79 245.28,10.72 246.05,9.95 247.16,9.95 247.3,9.82 247.3,8.42
+3VALW on TOP: 242.19,15.8 241.16,15.8 241.02,15.94 241.02,16.99 241.08,17.05 241.84,17.05 241.97,17.18 241.97,17.69 241.9,17.75 241.08,17.75 241.02,17.82 241.02,18.07 241.01,18.08 241.01,19.1 241.13,19.21 241.43,19.21 242.15,19.05 242.87,18.9 242.88,18.9 243.95,18.72 244.03,18.67 244.16,18.54 244.16,16.05 243.91,15.8
+3VALW on TOP: 203.73,26.43 203.73,25.67 203.84,25.56 204.17,25.56 204.38,25.35 204.38,24.82 204.39,24.8 205.39,24.8 205.77,25.18 205.77,26.26 205.56,26.47 203.78,26.47
+3VALW on TOP: 219.35,53.25 219.4,53.19 221.02,53.19 221.11,53.29 221.11,58.75 221.27,58.9 221.27,59.54 221.14,59.66 220.63,59.66 220.45,59.48 220.07,59.48 220.06,59.48 219.7,59.48 219.63,59.42 219.63,58.48 220.27,57.84 220.27,56.39 220.1,56.21 219.36,56.21 219.35,56.2
+3VALW on BOTTOM: 207.7,64.54 211.98,64.54 211.98,64.55 212.36,64.55 212.48,64.67 212.48,66.18 212.37,66.29 212.37,68.3 212.8,68.73 212.8,69.63 212.72,69.71 212.72,70.07 212.78,70.13 214.02,70.13 214.07,70.09 214.07,67.3 214.43,66.93 216.98,66.93 217.31,66.61 217.31,63.7 216.83,63.22 216.83,62.11 216.96,61.98 217.81,61.98 217.86,61.93 217.86,61.66 217.78,61.58 216.34,61.58 216.21,61.71 216.21,62.27 216.1,62.39 214,62.39 212,60.38 212,59.88 211.16,59.05 209.2,59.05 208.57,59.68 208.09,59.68 208.01,59.76 207.59,59.76 207.53,59.82 207.53,60.29 207.59,60.36 207.59,64.44
+3VALW on IN1: 177.68,65.81 177.49,65.63 176.48,65.63 176.28,65.82 176.28,66.36 176.12,66.52 175.6,66.52 175.53,66.59 175.53,67.42 175.71,67.6 175.71,67.97 175.79,68.06 177.58,68.06 177.68,67.96
+3VALW on IN1: 18.62,39.05 18.67,39 18.67,37.6 18.62,37.55 17.39,37.55 17.2,37.74 17.2,38.94 17.31,39.05
+3VALW on IN1: 241.3,17.94 239.95,17.94 239.48,18.4 239.48,19.04 239.58,19.14 241.61,19.14 241.62,19.13 242.69,18.93 244.14,18.68 244.14,17.43 243.85,17.14 242.1,17.14
+3VALW on VCC: outline of 144 points within 17.88,13.5 276.07,74.01 ; 2 cut-outs
+3VALW on IN2: 201.01,10.32 201.39,10.7 212.63,10.7 213.46,9.88 220.7,9.88 221.08,9.5 221.08,8.36 220.76,8.04 201.29,8.04 201.01,8.32
+3VALW on IN2: 223.31,28.89 224.3,28.89 225.75,27.44 225.75,26.8 225.98,26.57 225.98,22.5 230.98,17.5 237.59,17.5 239.3,19.21 240.89,19.21 241.33,18.77 241.33,15.85 239.87,14.39 229.59,14.39 223.58,20.4 223.58,23.54 223.7,23.67 223.7,24.61 222.47,25.84 222.47,27.23 222.52,27.28 222.52,28.42 222.71,28.61 223.03,28.61
+3VALW on IN3: 66.38,27.17 61.99,22.78 59.94,22.78 58.31,21.14 58.31,17.2 58.61,16.9 67.43,16.9 69.6,19.07 69.6,26.55 68.97,27.17
+3VALW on IN3: 196.11,62.78 195.3,62.78 195.13,62.61 195.13,60.77 194.9,60.54 194.9,58.51 195.04,58.37 195.04,57.69 195.49,57.25 197.03,57.25 197.26,57.48 197.26,57.8 197.2,57.86 196.12,57.86 196.07,57.92 196.07,58.48 196.24,58.65 198.25,58.65 199.06,59.46 202.23,59.46 202.47,59.7 202.47,60.62 202.31,60.78 198.11,60.78
+3VALW on IN3: 218.37,10 220.16,10 220.82,9.34 220.82,9.08 220.2,8.46 220.08,8.46 219.68,8.86 218.41,8.86 218.24,9.04 218.24,9.86
+3VALW on IN3: 232,5.79 231.81,5.98 231.81,6.66 232.05,6.9 233.18,6.9 233.29,7.02 233.77,7.02 233.83,6.96 233.83,5.88 233.73,5.79
+3VALW_DSW on TOP (solid shape): 202.6,17.44 202.6,16.29 199.99,16.29 199.8,16.48 199.8,17.31 200.12,17.63 202.41,17.63
+3VALW_DSW on BOTTOM (solid shape): 200.88,17.56 200.88,16.48 200.76,16.36 199.93,16.36 199.8,16.48 199.8,17.56 200.06,17.82 200.63,17.82
+3VALW_DSW on BOTTOM: 167.93,39.4 177.7,39.4 177.85,39.25 179.29,39.25 179.5,39.04 179.5,38.01 179.44,37.96 178.08,37.96 177.18,38.85 176.57,38.85 176.5,38.78 167.87,38.78 167.79,38.86 167.79,39.26
+3VALW_DSW_R on TOP: 201.58,15.62 202.7,15.62 202.81,15.51 202.81,14.95 203.32,14.44 203.32,13.4 203.27,13.36 202.22,13.36 201.51,14.07 201.51,15.55
+3VALW_TPM on TOP (solid shape): 209.13,11.34 209.13,10.43 209.32,10.25 209.32,9.99 209.27,9.95 208.53,9.95 208.29,9.71 207.35,9.71 207.2,9.85 207.2,12.06 207.23,12.09 208.38,12.09
+3VALWP on TOP (solid shape): 75.24,59.84 76,59.84 76,60.39 76.45,60.39 76.45,59.84 77.76,59.84 77.9,59.7 77.9,49.45 77.63,49.19 74.58,49.19 74.39,49.38 74.39,58.24 74.05,58.59 74.05,59.78 74.1,59.84 74.8,59.84 74.8,60.39 75.24,60.39
+3VS on TOP (solid shape): 187.74,33.36 187.74,33.03 187.46,32.76 187.36,32.65 187.36,32.22 187.24,32.09 186.59,32.09 186.09,31.6 185.77,31.6 185.65,31.72 185.65,33.38 185.77,33.5 187.6,33.5
+3VS on BOTTOM (solid shape): 208.73,69.44 208.73,68.65 208.35,68.27 207.88,68.27 206.17,66.56 205.49,66.56 205.29,66.76 205.29,69.14 205.72,69.57 208.6,69.57
+3VS on TOP: 249.21,8.42 249.14,8.48 249.14,10.2 248.88,10.46 248.22,10.46 248.11,10.56 248.11,10.97 248.17,11.03 249.28,11.03 249.59,10.73 249.59,8.48 249.52,8.42
+3VS on TOP: 174.2,57.29 175.54,57.29 175.94,56.88 175.94,56.63 175.78,56.47 175.6,56.47 175.53,56.4 175.53,55.92 175.49,55.88 175.22,55.88 175.03,56.07 174.39,56.07 174.14,56.32 174.14,57.22
+3VS on BOTTOM: 203.07,55.36 203.1,55.39 204.19,55.39 204.24,55.34 204.24,54.82 204.35,54.71 208.22,54.71 208.41,54.52 208.41,53.57 207.14,52.29 202.73,52.29 202.42,52.6 202.42,54.72 202.48,54.79 203.01,54.79 203.07,54.85
+3VS_AUDIO_R on TOP (solid shape): 22.02,25.65 22.02,24.5 21.47,23.95 21.4,23.95 20.77,24.58 20.28,24.58 19.51,25.35 19.51,25.44 20.55,26.47 21.2,26.47
+3VS_CR on TOP (solid shape): 271.47,24.74 271.47,21.95 271.08,21.55 270.3,21.55 270.21,21.64 270.21,22.61 270.03,22.78 270.03,23.79 269.89,23.93 269.89,24.65 270.26,25.02 271.18,25.02
+3VS_CR on IN1 (solid shape): 273.65,24.17 273.65,23.79 273.02,23.15 272.51,23.15 272,23.66 271.3,23.66 271.18,23.79 271.18,24.67 271.43,24.93 272.89,24.93
+3VS_CR on IN1 (solid shape): 278.76,25.34 278.89,25.3 279.02,25.34 279.03,25.35 279.23,25.35 279.37,25.21 279.37,22.58 279.62,22.33 279.62,21.82 279.33,21.53 277.56,21.53 277.34,21.75 277.34,24.52 278.16,25.35 278.74,25.35
+3VS_CR on TOP: 279.25,25.02 279.25,23.79 279.01,23.56 279.01,21.93 279.06,21.88 279.56,21.88 279.61,21.93 279.61,23.19 279.52,23.28 279.52,23.38 279.52,25.02 279.49,25.05 279.28,25.05
+3VS_CR on TOP: 281.1,30.52 281.49,30.52 281.64,30.66 282.68,30.66 282.71,30.63 282.71,29.81 282.65,29.75 282.49,29.75 282.48,29.75 281.04,29.75 280.97,29.69 280.97,29.41 280.82,29.26 280.42,29.26 280.37,29.3 280.37,29.92 280.44,29.99 280.67,29.99 280.86,30.17 280.86,30.27
+3VS_CR on IN1: 283.01,30.3 283.01,27.66 282.95,27.59 281.85,27.59 281.75,27.7 281.75,30.2 281.98,30.42 282.89,30.42
+3VS_CR_R on TOP (solid shape): 269.55,22.56 269.55,21.56 269.48,21.49 267.53,21.49 267.42,21.6 267.42,22.31 267.51,22.4 268.55,22.4 268.73,22.58 269.53,22.58
+3VS_FP on TOP (solid shape): 60.18,18.62 62.23,18.62 62.3,18.54 62.3,17.7 62.22,17.62 61.45,17.62 61.18,17.89 59.18,17.89 59.08,17.99 58.6,17.99 58.43,18.15 57.46,18.15 57.35,18.26 57.35,18.54 57.48,18.67 60.13,18.67
+3VS_FP_R on TOP (solid shape): 63.73,18.95 63.73,17.75 63.61,17.63 62.81,17.63 62.73,17.71 62.73,18.93 62.26,19.4 59.16,19.4 59.11,19.46 59.11,19.95 59.14,19.98 62.71,19.98
+3VS_MID on TOP (solid shape): 166.01,84.23 166.01,83.61 166.21,83.41 166.21,82.71 166.1,82.61 165.69,82.61 165.37,82.93 165.37,84.2 165.45,84.28 165.96,84.28
+3VS_R on TOP (solid shape): 239.62,16.99 239.62,16.23 239.46,16.07 238.59,16.07 237.86,16.07 237.86,16.07 237.3,16.07 237.21,16.17 237.21,16.74 237.33,16.86 238.33,16.86 238.52,17.05 239.55,17.05
+3VS_SSD on TOP (solid shape): 220.38,7.91 221.01,7.91 221.14,7.78 221.14,7.16 220.28,6.3 217.78,6.3 217.74,6.35 217.74,7 217.82,7.08 217.82,7.83 217.9,7.91 220.38,7.91
+3VS_SSD on BOTTOM: 200.15,6.08 201.56,6.08 201.6,6.05 201.6,4.46 201.77,4.29 204.25,4.29 204.25,4.29 214.03,4.29 214.35,4.61 214.35,6.26 215.17,7.09 217.71,7.09 218.54,7.91 220.95,7.91 221.14,7.72 221.14,6.2 219.62,4.67 219.62,3.72 219.3,3.4 219.3,2.45 219.04,2.2 217.71,2.2 217.2,1.69 200.31,1.69 200.11,1.89 200.11,6.04
+3VS_SSD_R on TOP (solid shape): 220.27,9.03 220.27,8.2 220.19,8.12 217.9,8.12 217.79,8.23 217.58,8.23 217.47,8.34 217.47,9.07 217.53,9.13 220.17,9.13
+3VS_SSD_R on IN1: 217.55,9.12 220.06,9.12 220.11,9.07 220.11,8.35 219.99,8.22 217.52,8.22 217.48,8.27 217.48,9.04
+3VS_TPM on TOP (solid shape): 209.32,6.68 209.32,4.56 209.19,4.43 208.51,4.43 208.26,4.68 207.33,4.68 207.18,4.83 207.18,6.71 207.22,6.76 209.24,6.76
+3VS_TS on TOP: 172.59,71.16 172.98,70.77 173.84,70.77 173.96,70.89 173.96,72.85 173.91,72.9 172.13,72.9 171.96,72.74 171.96,71.26 172.07,71.16
+3VS_TS_R on TOP: 172.85,70.62 173.81,70.62 173.91,70.53 173.91,69.93 174.3,69.53 174.3,68.58 174.23,68.51 172.71,68.51 172.54,68.68 172.54,69.63 172.79,69.88 172.79,70.56
+3VS_WLAN on BOTTOM (solid shape): 182.28,70.13 182.28,69.19 182.15,69.06 177.98,69.06 177.25,68.33 176.73,68.33 176.69,68.36 176.69,69.82 177.06,70.2 177.9,70.2 177.91,70.2 179.52,70.2 179.92,70.6 181.81,70.6
+3VS_WLAN on BOTTOM (solid shape): 190.38,70.14 192.31,70.14 192.5,69.95 192.5,69.06 191.8,68.36 191.17,68.36 191.1,68.43 191.1,68.87 190.85,69.12 189.83,69.12 189.77,69.19 189.77,70.15 189.91,70.3 190.22,70.3
+3VS_WLAN on IN1 (solid shape): 177.13,72.87 177.13,72.17 177.01,72.05 175.42,72.05 175.29,72.17 175.29,72.87 175.42,73 177.01,73
+3VS_WLAN on IN1 (solid shape): 184.5,73.51 184.69,73.51 184.88,73.32 184.88,73.01 184.74,72.87 183.17,72.87 182.81,73.22 182.81,73.75 182.88,73.82 184.18,73.82
+3VS_WLAN on TOP: 175.94,71.52 175.87,71.59 175.34,71.59 175.29,71.64 175.29,72.06 175.18,72.17 174.93,72.17 174.77,72.33 174.77,72.71 174.93,72.87 177.07,72.87 177.45,72.49 177.45,70.9 177.39,70.84 175.99,70.84 175.94,70.89
+3VS_WLAN on TOP: 189.62,66.16 191.02,66.16 191.17,66.31 191.17,69 191.36,69.19 191.8,69.19 191.8,69.19 191.87,69.25 191.87,69.95 191.74,70.07 190.49,70.07 190.27,70.29 189.78,70.29 189.5,70.01 189.5,66.27
+3VS_WLAN on TOP: 180.2,70.08 181.71,70.08 181.88,70.25 182.23,70.25 182.34,70.14 182.34,69.08 182.29,69.04 181.72,69.04 181.59,69.17 180.19,69.17 180.16,69.21 180.16,70.03
+3VS_WLAN on VCC: 175.72,70.84 174.98,71.58 174.98,73.65 175.33,74.01 188.2,74.01 188.69,73.53 188.69,71.45 188.08,70.84
+3VS_WLAN on IN2: 190.62,69.37 190.62,70.31 190.35,70.59 181.22,70.59 181.08,70.44 181.08,69.34 180.9,69.16 179.98,69.16 178.96,70.18 178.96,73.3 179.11,73.44 192.21,73.44 192.67,72.98 192.67,69.15 192.45,68.94 192.05,68.94 191.74,69.25 190.74,69.25
+3VS_WLAN_R on TOP: 175.63,68.63 175.63,69.4 175.93,69.7 175.93,70.52 175.99,70.59 177.32,70.59 177.45,70.46 177.45,69.08 176.91,68.53 175.73,68.53
+5VALW on TOP (solid shape): 4.1,21.07 4.1,19.28 4.03,19.21 2.38,19.21 2.27,19.1 2.27,18.1 2.23,18.07 1.78,18.07 1.72,18.13 1.72,20.9 1.91,21.1 4.07,21.1
+5VALW on TOP (solid shape): 8.92,11.53 8.92,10.58 8.35,10.58 8.35,8.55 8.92,8.55 8.92,7.78 8.73,7.59 5.56,7.59 5.11,8.04 5.11,11.47 5.49,11.85 8.61,11.85
+5VALW on IN1 (solid shape): 48.55,9.66 48.55,9.12 48.32,8.89 46.17,8.89 45.75,9.31 45.75,9.88 45.84,9.96 48.25,9.96
+5VALW on IN1 (solid shape): 3.44,20.85 3.44,18.4 3.05,18.01 1.89,18.01 1.68,18.22 1.68,20.99 1.79,21.1 3.2,21.1
+5VALW on TOP: 48.93,9.82 48.74,9.63 45.85,9.63 45.31,10.17 45.31,16.23 45.37,16.29 46.13,16.29 46.26,16.42 46.26,16.93 46.2,16.99 45.37,16.99 45.31,17.05 45.31,17.37 45.44,17.5 46.78,17.5 47.01,17.28 47.84,17.28 48.93,16.19
+5VALW on TOP: 171.56,67.79 171.56,66.72 171.59,66.69 172.36,66.69 172.4,66.73 172.4,68.48 172.31,68.57 170.81,68.57 170.75,68.5 170.75,68.01 170.93,67.83 171.53,67.83
+5VALW on TOP: 97.84,6.17 100.28,6.17 100.84,6.72 100.84,7.4 100.73,7.5 99.46,7.5 98.78,6.83 97.81,6.83 97.77,6.87 97.77,7.31 98,7.54 98.57,7.54 99.08,8.06 101.35,8.06 101.59,7.81 101.59,6.56 100.61,5.59 99.06,5.59 98.82,5.34 98.82,4.59 98.58,4.35 97.83,4.35 97.81,4.38 97.81,5.35 97.77,5.39 97.77,6.1
+5VALW on IN1: 97.94,4.14 101.29,4.14 101.48,4.32 101.48,6.18 101.18,6.48 98.07,6.48 97.78,6.19 97.78,4.3
+5VALW on VCC: 1.17,1.67 1.17,5.48 1.3,5.48 3.12,7.3 1.3,9.12 1.17,9.12 1.17,9.33 1.3,9.33 2.12,9.49 2.81,9.94 2.81,9.94 3.3,10.66 3.47,11.5 3.47,14.5 2.83,16.03 1.3,16.67 1.17,16.67 1.17,21.13 5.05,21.13 5.05,14.41 5.83,13.63 9.11,13.63 9.11,9.9 10.26,8.76 10.26,1.67 4.83,1.67 4.83,1.67
+5VALW on IN3: 33.25,3.17 32.3,2.21 32.3,1.83 32.14,1.67 5.87,1.67 4.66,2.88 4.66,4.16 3.72,5.11 3.72,15.28 1.49,17.5 1.49,20.74 1.87,21.12 6.19,21.12 7.08,22.01 8.04,22.01 15.47,14.58 15.47,14.37 19.76,10.07 100.8,10.07 101.44,9.43 101.44,5.72 100.59,4.87 98.48,4.87 98.18,5.17 74.26,5.17 71.99,7.45 66.9,7.45 66.6,7.15 66.6,5.42 66.43,5.24 58.14,5.24 56.06,3.17 53.44,3.17 53.32,3.28 49.94,3.28 49.83,3.17
+5VALW_L_TBT on TOP (solid shape): 18.44,18.45 19.34,18.45 19.97,17.82 19.97,17.69 19.27,16.99 19.06,16.99 18.8,17.25 18.8,17.25 18.25,17.8 18.25,18.19 17.2,19.23 17.2,19.35 17.31,19.46 17.42,19.46
+5VALW_L_TBT on TOP (solid shape): 9.19,21.53 9.19,21.26 10.54,19.92 10.54,19.83 9.91,19.2 9.37,19.2 7.97,20.61 7.6,20.61 6.95,19.96 6.95,19.66 6.7,19.4 5.79,19.4 5.66,19.53 5.66,21.13 5.71,21.18 6.07,21.18 7.53,22.64 8.08,22.64
+5VALW_L_TBT on IN1 (solid shape): 20.16,17.56 20.16,15.21 19.34,14.39 17.81,14.39 17.62,14.58 17.62,14.83 17.77,14.98 17.79,14.99 17.9,15.06 17.97,15.18 17.98,15.19 18.92,16.13 18.92,17.47 19.27,17.82 19.91,17.82
+5VALW_L_TBT on IN1 (solid shape): 10,20.89 10,19.79 9.87,19.65 6.52,19.65 6.26,19.91 6.26,20.08 7.42,20.08 7.42,20.04 7.43,20 7.44,19.96 7.47,19.92 7.49,19.89 7.53,19.87 7.57,19.85 7.61,19.84 7.65,19.83 7.69,19.84 7.73,19.85 7.77,19.87 7.8,19.89 7.83,19.92 7.85,19.96 7.87,20 7.88,20.04 7.88,20.08 7.87,20.12 7.85,20.16 7.83,20.2 7.8,20.23 7.77,20.26 7.73,20.28 7.69,20.29 7.65,20.29 7.61,20.29 7.57,20.28 7.53,20.26 7.49,20.23 7.47,20.2 7.44,20.16 7.43,20.12 7.42,20.08 6.26,20.08 6.26,20.55 8.03,22.33 8.56,22.33
+5VALW_L_TBT on IN2: 16.73,16.04 16.73,15.34 17.18,14.9 17.69,14.9 18.03,15.24 18.48,15.24 18.83,14.9 18.83,13.69 18.57,13.44 16.73,13.44 15.21,14.96 13.75,14.96 11.08,17.63 9.68,17.63 7.72,19.59 6.83,19.59 6.64,19.79 6.64,20.93 7.27,21.56 8.48,21.56 13.69,16.36 16.42,16.36
+5VALWB on TOP (solid shape): 229.8,7.93 229.8,7.23 229.75,7.17 228.65,7.17 228.52,7.05 227.59,7.05 227.45,7.19 227.45,8.16 227.67,8.37 229.36,8.37
+5VALWB on TOP (solid shape): 270.07,19.54 270.75,19.54 270.76,19.53 270.86,19.53 271.04,19.72 272,19.72 272.13,19.59 274.54,19.59 274.66,19.47 274.66,17.87 274.54,17.75 270.65,17.75 269.46,18.94 268.75,18.94 268.66,19.02 268.66,19.77 268.79,19.9 269.72,19.9
+5VALWB on TOP (solid shape): 245.06,11 245.06,10.67 245.37,10.36 245.37,10.11 245.24,9.99 244.37,9.99 244.31,9.93 244.31,9.58 244.38,9.51 247.05,9.51 247.11,9.45 247.11,8.46 247.07,8.41 243.89,8.41 243.36,8.93 243.36,10.94 243.54,11.11 244.94,11.11
+5VALWB on TOP (solid shape): 287.94,6.64 287.94,5.95 287.61,5.62 287.61,4.38 287.4,3.68 287.36,2.96 285.71,2.96 285.58,3.08 285.58,3.91 286.1,3.91 286.1,5.88 285.58,5.88 285.58,6.44 286.1,6.96 287.62,6.96
+5VALWB on IN1 (solid shape): 272.96,19.34 272.99,19.34 273.07,19.26 274.31,19.26 274.48,19.09 274.48,17.44 274.1,17.05 271.62,17.05 270.99,17.69 270.54,17.69 269.78,18.45 269.78,19.15 269.91,19.28 270.54,19.28 270.92,19.66 272.64,19.66
+5VALWB on TOP: 216.82,43.47 216.82,42.84 216.89,42.77 218.11,42.77 218.27,42.93 218.27,43.52 218.19,43.6 216.95,43.6
+5VALWB on BOTTOM: 272.51,19.91 270.86,19.91 269.59,18.64 269.59,18.58 268.64,17.63 268.64,10.77 267.75,9.88 263.62,9.88 263.3,9.56 258.52,9.56 257.87,8.91 253.82,8.91 253.33,9.4 251.84,9.4 250.73,10.51 245.33,10.51 245.33,10.51 245.09,10.51 244.9,10.32 244.9,8.05 243.94,7.09 229.1,7.09 227.68,8.51 227.4,8.51 225.46,10.45 215.11,10.45 214.54,9.88 197.96,9.88 195.87,11.97 190.41,11.97 189.64,11.21 189.64,10.32 189.77,10.2 190.15,10.2 190.28,10.32 190.28,10.64 190.41,10.77 194.41,10.77 195.04,10.13 195.04,10.11 197.9,7.25 217.52,7.25 218.37,8.1 222.66,8.1 225.84,4.93 239.36,4.93 240.19,5.75 248.25,5.75 249.78,7.28 252.57,7.28 254.48,5.37 282.99,5.37 284,4.35 284,3.53 284.13,3.4 287.31,3.4 287.69,3.78 287.69,5.24 288.96,6.51 288.96,14.13 284.39,18.71 273.65,18.71 272.51,19.85
+5VALWB_R_TBT on TOP (solid shape): 278.85,19.15 278.85,15.71 278.78,15.65 277.83,15.65 277.39,16.09 277.39,16.37 277.25,16.5 276.62,16.5 276.21,16.91 276.21,19.42 276.32,19.53 278.47,19.53
+5VALWB_R_TBT on TOP (solid shape): 283.38,10.5 283.38,8.85 283.59,8.64 283.59,8.24 283.5,8.15 282.92,8.15 282.89,8.18 282.89,8.24 282.91,8.31 282.91,8.38 282.91,8.67 283.09,8.85 283.09,10.5 283.16,10.56 283.32,10.56
+5VALWB_R_TBT on IN1 (solid shape): 278.29,18.26 278.29,17.69 278.8,17.18 278.8,16.05 278.53,15.78 277.78,15.78 276.9,16.67 276.9,16.67 276.77,16.8 276.32,16.8 276,17.12 276,18.39 276.5,18.89 277.66,18.89
+5VALWB_R_TBT on IN1: 283.41,9.09 283.42,8.94 283.51,8.81 283.75,8.56 283.75,7.59 283.72,7.56 283.72,7.37 283.5,7.15 282.22,7.15 281.59,7.78 281.59,9.5 281.91,9.82 283.05,9.82 283.41,9.46
+5VALWB_R_TBT on IN2: 281.4,10.9 281.4,16.1 280.89,16.61 279.18,16.61 278.8,16.23 278.8,15.98 278.67,15.85 277.78,15.85 277.4,16.23 277.4,19.15 278.23,19.98 283.69,19.98 287.56,16.1 287.56,9.05 285.7,7.19 281.61,7.19 281.31,7.5 281.31,8.89 280.77,9.43 280.77,10.26
+5VALWBP on TOP (solid shape): 285.4,6.51 285.4,3.34 285.13,3.07 283.99,3.07 283.85,3.21 280.39,3.21 280.11,2.93 277.43,2.93 277.15,3.21 277.15,6.01 277.55,6.41 279.56,6.41 279.84,6.13 283.81,6.13 284.26,6.58 285.33,6.58
+5VALWP on TOP (solid shape): 19.08,12.44 19.08,8.61 18.83,8.36 10.83,8.36 10.19,7.72 9.3,7.72 9.11,7.91 9.11,11.21 9.3,11.4 15.53,11.4 16.78,12.65 18.87,12.65
+5VBS on TOP (solid shape): 259.62,3.28 259.62,2.64 259.49,2.51 257.65,2.51 257.65,3.47 257.72,3.53 259.37,3.53
+5VBS on TOP (solid shape): 263.16,13.73 263.16,12.33 263.07,12.23 262.23,12.23 262.08,12.38 262.08,13.77 262.18,13.87 263.03,13.87
+5VBS on TOP (solid shape): 264.26,19.79 264.26,19.77 264.26,18.88 264.28,18.88 264.28,18.25 264.22,18.18 263.43,18.18 263.24,17.99 263.24,17.88 262.22,17.88 262.22,19.58 262.48,19.84 264.22,19.84
+5VBS on IN1 (solid shape): 259.75,4.23 259.75,3.08 259.56,2.89 258.92,2.89 258.73,3.08 258.73,4.1 258.92,4.29 259.68,4.29
+5VBS on IN1 (solid shape): 263.54,12.04 263.54,11.44 263.48,11.38 262.47,11.38 262.27,11.57 262.27,12.49 262.38,12.6 262.99,12.6
+5VBS on TOP: 233.95,7.78 236.51,7.78 236.63,7.66 237.9,7.66 238.03,7.78 238.03,8.67 236.38,10.32 235.15,10.32 234.83,10 233.85,10 233.7,10.15 233.7,10.64 233.55,10.8 233.08,10.8 232.99,10.71 232.99,9.45 233.31,9.14 233.8,9.14 233.83,9.11 233.83,7.91
+5VBS_FAN2 on TOP (solid shape): 236.07,6.69 236.07,5 236.14,4.93 237.27,4.93 237.84,4.35 237.84,2.49 237.67,2.32 237.25,2.32 237.01,2.56 237.01,3.66 236.63,4.04 235.74,4.04 235.47,4.32 235.47,5.62 235.42,5.66 235.13,5.66 234.75,6.04 234.2,6.04 234.06,6.18 234.06,7.09 234.1,7.13 235.64,7.13
+5VBS_R on TOP (solid shape): 267.27,19.77 267.27,18.12 267.11,17.96 265.83,17.96 264.92,18.87 264.92,19.77 264.98,19.84 267.2,19.84
+5VS on TOP: 70.21,8.05 70.77,7.49 70.77,6.51 70.69,6.42 69.82,6.42 69.63,6.62 69.03,6.62 68.75,6.34 66.88,6.34 66.77,6.45 66.77,9.05 66.96,9.24 67.22,9.24 67.34,9.37 67.34,9.94 67.41,10.01 67.79,10.01 68.1,9.69 68.1,8.16 68.22,8.05
+5VS on TOP: 92.93,6.16 93.6,6.16 93.63,6.13 93.63,3.37 93.56,3.31 92.31,3.31 92.15,3.46 92.15,4.59 92.89,5.32 92.89,6.12
+5VS on IN3: 93.61,4.18 93.75,4.03 93.75,2.56 93.61,2.42 91.4,2.42 91.16,2.66 91.16,4.1 91.23,4.18
+5VS on IN3: 69.13,7.16 69.13,6.15 66.91,6.15 66.78,6.27 66.78,7.03 66.91,7.16

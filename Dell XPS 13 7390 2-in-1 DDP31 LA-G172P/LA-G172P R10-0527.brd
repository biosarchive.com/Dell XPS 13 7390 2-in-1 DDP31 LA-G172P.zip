# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_CLK: length 3.4
  TOP w0.089: UC1.CR47 162.21,46.96 v1(162.1,46.84)
  IN1 w0.064: v1(162.1,46.84) 162.26,47.01 v2(162.26,47.36)
  IN3 w0.064: v2(162.26,47.36) 162.4,47.5 v4(162.4,47.73)
  BOTTOM w0.081: v4(162.4,47.73) v6(162.02,48.11) 162.02,48.3 162.4,48.68 RC569.2
ESPI_CLK_5105: length 87.8
  IN1 w0.064: v2(211.55,70.23) 212.11,69.67 v1(212.11,69.58) 211.88,69.35 211.52,69.35 211.22,69.05 211.22,68.42 211.14,68.33 211.14,67.58 212.87,65.85 212.87,65.29 212.36,64.78 212.36,63.95 212.59,63.72 212.59,62.69 212.25,62.34 212.25,61.51 v1(211.9,61.16) ; v2(174.12,69.25) 173.32,69.25 172.42,68.35 172.42,67.65 172.23,67.46 172.23,61.5 171.63,60.9 171.63,58.31 172.26,57.67 172.26,52.58 172.19,52.5 171.15,52.5 171.02,52.5 169.71,51.2 169.23,51.2 168.88,51.55 168.6,51.55 v2(168.3,51.85)
  IN3 w0.064: v4(166.44,50.32) 166.51,50.39 166.51,50.4 167.96,51.85 v2(168.3,51.85) ; v4(212.53,69.14) 212.53,69.88 212.18,70.23 211.55,70.23 v2(211.55,70.23) 209.88,71.91 204.98,71.91 204.57,71.49 204.57,69.41 202.58,67.42 200.16,67.42 200.02,67.57 198.62,67.57 197.48,66.43 189.84,66.43 189.23,67.04 178.57,67.04 177.48,68.14 175.64,68.14 174.52,69.25 v2(174.12,69.25)
  BOTTOM w0.081: CC658.1 RC569.1 162.4,50.89 v6(162.63,51.12) 165.73,51.12 166.44,50.41 v4(166.44,50.32)
ESPI_CS#: length 83.6
  TOP w0.081: UE1.H6 211.1,60.48 v1(210.89,60.68) ; v1(163.06,45.98) 163.13,45.98 163.96,46.81 163.96,48.33 164.05,48.42 RC712.1
  IN1 w0.064: v2(210.37,68.63) 210.45,68.56 210.45,67.79 210.22,67.56 210.22,64.93 209.88,64.6 209.88,63.95 210.03,63.81 210.03,63.09 209.88,62.95 209.88,62.3 210.04,62.14 210.04,61.22 210.58,60.68 v1(210.89,60.68) ; v1(163.06,45.98) 162.8,46.25 162.8,47.39 162.95,47.55 163.48,47.55 163.6,47.67 163.62,47.67 165.22,49.27 165.63,49.27 165.87,49.03 166.69,49.03 167.5,49.84 170.26,49.84 171.57,51.16 172.74,51.16 174.3,52.72 174.3,54.89 173.28,55.91 173.28,58.06 172.62,58.72 172.62,59.98 173.34,60.7 173.34,64.92 174.63,66.21 v2(174.63,66.75)
  IN3 w0.064: v2(174.63,66.75) 174.99,67.11 177.34,67.11 178.94,65.5 190.49,65.5 190.59,65.6 197.99,65.6 198.53,66.14 199.45,66.14 199.91,66.6 203.34,66.6 204.25,67.51 206.89,67.51 207.84,68.46 208.84,68.46 208.93,68.55 209.78,68.55 209.86,68.63 v2(210.37,68.63) 210.48,68.63 210.99,69.14 v4(211.03,69.14)
ESPI_IO0: length 81.4
  TOP w0.081: v1(167.16,51.48) 167.07,51.38 166.38,51.38 166.12,51.12 163.28,51.12 162.84,50.68 RC336.2
  IN1 w0.064: v2(174.61,68.69) 175.24,68.06 175.24,67.8 174.78,67.35 173.05,67.35 172.89,67.19 172.89,61.23 172.29,60.63 172.29,58.58 172.92,57.95 172.92,52.31 172.46,51.84 171.29,51.84 169.98,50.54 168.96,50.54 168.6,50.89 168.17,50.89 168.12,50.94 167.7,50.94 v1(167.16,51.48) ; v2(208.64,69.46) 208.64,65.78 208.44,65.57 208.44,63.09 207.89,62.54 207.89,62.24 208.12,62.01 208.63,62.01 209.03,61.61 209.03,61.2 209.07,61.16 209.07,60.6 208.61,60.14 208.61,59.7 209.19,59.11 209.81,59.11 210.17,58.76 v1(210.3,58.76)
  IN3 w0.064: v4(209.01,69.72) 208.75,69.46 v2(208.64,69.46) 205.73,69.46 204.44,68.17 203.96,68.17 203.04,67.26 200.09,67.26 199.95,67.4 198.69,67.4 197.55,66.26 189.77,66.26 189.27,66.77 178.62,66.77 177.41,67.97 175.57,67.97 174.85,68.69 v2(174.61,68.69)
  BOTTOM w0.081: JDEBUG2.3 209.03,69.7 v4(209.01,69.72)
ESPI_IO0_R: length 4.6
  TOP w0.081: RC336.1 162.78,48.42 162.69,48.33 162.69,46.8 162.54,46.64 162.33,46.64 161.79,46.1 UC1.CN45
ESPI_IO1: length 82.8
  TOP w0.081: v1(167.95,52.17) 167.86,52.26 166.48,52.26 166.25,52.04 v3(165.35,52.04) 164.99,51.67 162.98,51.67 162.69,51.38 162.33,51.38 162.15,51.2 161.39,51.2 RC367.2
  IN1 w0.064: v2(206.44,68.87) 206.44,68.12 206.7,67.86 206.7,66.02 207.94,64.78 207.94,63.57 207.23,62.86 207.23,61.82 207.39,61.66 207.39,59.35 208.52,58.23 209.23,58.23 v1(209.5,57.96) ; v1(167.95,52.17) 167.95,51.72 168.23,51.44 168.32,51.44 168.38,51.38 168.81,51.38 169.16,51.03 169.78,51.03 171.08,52.34 172.25,52.34 172.43,52.51 172.43,57.74 171.79,58.38 171.79,60.83 172.4,61.43 172.4,67.39 172.58,67.58 172.58,68.28 172.99,68.69 v2(174.1,68.69)
  IN3 w0.064: v4(209.53,69.14) 209.51,69.13 208.5,69.13 208.33,69.3 206.86,69.3 v2(206.44,68.87) 205.57,68.01 204.04,68.01 203.13,67.09 200.02,67.09 199.88,67.24 198.76,67.24 197.62,66.1 189.7,66.1 189.2,66.6 178.55,66.6 177.34,67.81 175.5,67.81 174.96,68.35 174.48,68.35 174.14,68.69 v2(174.1,68.69)
ESPI_IO1_R: length 3.2
  TOP w0.081: UC1.CN48 161.79,47.34 161.45,47.68 161.45,48.74 160.88,49.31 RC367.1
ESPI_IO2: length 78.9
  TOP w0.081: v1(167.61,51.81) 167.36,52.07 166.77,52.07 v3(166.66,51.96) 166.43,51.96 165.97,51.49 163.12,51.49 162.83,51.2 162.4,51.2 162.22,51.02 161.85,51.02 RC368.2 ; UE1.G6 210.87,61.39 v1(210.87,61.52)
  IN1 w0.064: v1(167.61,51.81) 168.15,51.27 168.25,51.27 168.31,51.22 168.74,51.22 169.09,50.87 169.84,50.87 171.15,52.17 172.32,52.17 172.59,52.45 172.59,57.81 171.96,58.45 171.96,60.76 172.56,61.37 172.56,67.33 172.75,67.51 172.75,68.21 172.88,68.34 174.19,68.34 v2(174.55,67.98) ; v1(210.87,61.52) 210.74,61.64 210.74,61.79 210.59,61.95 210.59,63.68 210.68,63.78 210.68,64.06 210.59,64.15 210.59,64.63 210.45,64.76 210.45,67.46 210.69,67.7 210.69,68.51 210.71,68.53 210.71,69.08 210.54,69.25 210.19,69.25 v2(209.96,69.47)
  IN3 w0.064: v2(174.55,67.98) 175.09,67.98 175.64,67.44 177.48,67.44 179.08,65.83 190.35,65.83 190.45,65.93 197.69,65.93 198.83,67.07 199.81,67.07 199.95,66.93 203.2,66.93 204.11,67.84 205.88,67.84 207.18,69.13 208.26,69.13 208.51,68.88 209.64,68.88 209.9,69.14 v4(210.03,69.14) 210.03,69.41 v2(209.96,69.47)
ESPI_IO2_R: length 2.3
  TOP w0.081: UC1.CN49 161.79,49.1 161.51,49.38 RC368.1
ESPI_IO3: length 82.6
  TOP w0.081: v1(167.57,51.46) 167.21,51.81 166.93,51.81 166.78,51.66 166.4,51.66 166.04,51.31 163.2,51.31 162.91,51.02 162.48,51.02 RC369.2 ; UE1.L5 v1(210.11,58.39)
  IN1 w0.064: v2(207.32,68.8) 206.89,68.8 206.67,68.58 206.67,68.12 206.86,67.93 206.86,66.09 208.11,64.85 208.11,63.5 207.4,62.79 207.4,61.89 207.56,61.73 207.56,59.42 208.59,58.39 v1(210.11,58.39) ; v2(174.04,67.98) 173.45,67.98 172.73,67.26 172.73,61.3 172.12,60.69 172.12,58.52 172.76,57.88 172.76,52.38 172.39,52.01 171.22,52.01 169.91,50.7 169.02,50.7 168.67,51.05 168.24,51.05 168.19,51.11 167.92,51.11 v1(167.57,51.46)
  IN3 w0.064: v4(210.53,69.14) 210.4,69.14 210.14,68.88 209.87,68.88 209.71,68.72 208.27,68.72 208.19,68.8 v2(207.32,68.8) 207.07,68.8 205.95,67.68 204.18,67.68 203.27,66.76 199.89,66.76 199.74,66.91 198.9,66.91 197.76,65.77 190.52,65.77 190.42,65.67 179.01,65.67 177.41,67.27 174.72,67.27 174.04,67.95 v2(174.04,67.98)
ESPI_IO3_R: length 3.6
  TOP w0.081: RC369.1 162.15,47.26 161.79,46.91 UC1.CN47
ESPI_RESET#: length 86.2
  TOP w0.081: RC711.1 163.42,48.55 163.34,48.47 163.34,46.52 163.13,46.31 v1(162.43,46.31) ; UE1.K6 210.85,59.01 v1(210.85,59.03)
  IN1 w0.064: v2(209.56,68.03) 209.57,68.02 209.57,67 210.05,66.52 210.05,65.02 209.71,64.68 209.71,63.88 209.86,63.74 209.86,63.16 209.71,63.01 209.71,62.23 209.87,62.07 209.87,59.93 210.07,59.73 210.07,59.59 210.63,59.03 v1(210.85,59.03) ; v2(174.06,66.84) 173.89,66.84 173.64,67.09 173.08,67.09 173.06,67.07 173.06,61.16 172.45,60.56 172.45,58.65 173.11,57.99 173.11,55.85 174.12,54.84 174.12,52.77 172.68,51.32 171.51,51.32 170.19,50 167.43,50 167.23,49.8 165.83,49.8 165.47,49.44 165.15,49.44 163.43,47.71 162.88,47.71 162.63,47.46 162.63,46.52 v1(162.43,46.31)
  IN3 w0.064: v2(174.06,66.84) 175.56,65.34 190.56,65.34 190.66,65.44 198.06,65.44 198.6,65.97 199.52,65.97 199.98,66.43 203.87,66.43 203.93,66.37 204.35,66.37 204.54,66.56 204.54,67.1 204.79,67.35 206.96,67.35 207.91,68.3 209.3,68.3 v2(209.56,68.03) 209.76,67.83 v4(209.88,67.83)
  BOTTOM w0.081: v4(209.88,67.83) 209.81,67.76 209.81,67.42 v6(209.91,67.32) 209.92,67.31 RE428.1
FB_0.6V: length 3.1
  TOP w0.254: PR803.2 82.11,64.83 82.11,66.42 81.75,66.78 PU800.10
FB_1.1V: length 2.9
  TOP w0.254: PU700.13 94.11,62.05 93.67,62.05 93.24,62.48 PR704.1 PR702.2 91.49,62.48 PR712.1
FB_1.8V: length 2.9
  TOP w0.254: PU500.10 210.63,19.14 PR504.1 PR502.2 211.67,18.91 211.68,18.9 PR501.2
FB_3V: length 4.4
  TOP w0.254: PR304.2 84.56,56.99 v1(84.56,56.99) 84.5,56.93 PU300.13
  IN1 w0.254: v1(86.45,57.45) 85.02,57.45 v1(84.56,56.99)
FB_5V: length 3.2
  TOP w0.254: PR404.2 PR407.2 23.64,3.55 PR409.1 23.64,4.62 23.09,5.18 PU400.13
FB_5VB: length 3.1
  TOP w0.254: PR416.2 269.34,8.98 269.45,9.09 270.02,9.09 270.04,9.07 270.04,9.03 PR419.2 270.04,8.92 270.04,8.45 270.08,8.41 PR421.1 270.08,6.92 PU401.13
FPR_DET#: length 220.8
  TOP w0.081: R800.2 63.72,14.04 64.35,14.04 64.88,14.58 64.88,15.25 65.57,15.95 v5(65.57,16.2)
  IN1 w0.064: v2(213.32,63.19) 213.5,63.37 v1(213.5,63.56)
  IN2 w0.051: v5(65.57,16.2) 65.66,16.29 69.21,16.29 69.44,16.52 78.65,16.52 83.77,11.41 83.77,9.79 84.31,9.25 85.01,9.25 85.18,9.41 85.69,9.41 86.13,9.85 86.13,10.05 86.63,10.55 86.63,20.03 88.88,22.27 88.88,48.31 90.78,50.21 96.97,50.21 97.48,50.72 97.48,62.22 98.17,62.92 102.64,62.92 103.45,63.73 103.45,67.71 104.82,69.07 108.15,69.07 109.27,70.19 125.84,70.19 126.01,70.02 135.47,70.02 136.31,69.18 138.54,69.18 139.07,69.72 143.47,69.72 144.29,68.9 149.36,68.9 149.66,69.2 154.24,69.2 155.3,70.25 160.32,70.25 160.9,69.68 163.6,69.68 164.38,68.9 167.29,68.9 172.27,63.92 175.25,63.92 175.57,64.23 177.65,64.23 178.36,63.52 189.42,63.52 189.85,63.95 193.24,63.95 193.79,63.41 194.69,62.51 197.68,62.51 198.03,62.15 203.21,62.15 204.48,63.43 206.66,63.43 208.7,65.47 v2(208.81,65.47) 209.2,65.07 209.7,65.07 210.01,65.39 211.08,65.39 211.49,64.98 211.49,64.64 211.91,64.22 212.33,64.22 213.14,63.41 213.27,63.41 213.32,63.36 v2(213.32,63.19)
  IN3 w0.064: v4(208.88,64.91) 208.88,65.3 208.81,65.38 v2(208.81,65.47)
  BOTTOM w0.081: v4(208.88,64.91) v3(208.88,65.78)
FPR_DET#_R: length 7
  TOP w0.081: D16.3 59.44,14.01 58.6,14.85 JFP1.1 ; D16.3 60.85,13.07 v6(61.25,12.67) ; D16.3 62.97,14.01 R800.1
FPR_SCAN#_R: length 12.4
  TOP w0.081: v1(63.04,14.57) 63.04,14.77 62.79,15.01 D16.2 60.67,15.01 60.08,14.42 v3(59.91,14.42) 59.5,14.42 58.57,15.35 JFP1.2 ; v1(63.72,13.32) 62.38,11.97 R629.1 60.05,12.18 QF2.3
  IN1 w0.064: v1(63.04,14.57) 63.04,14.01 v1(63.72,13.32)
FPR_SCAN_INT#: length 220.9
  TOP w0.081: v1(212.53,58.37) 212.7,58.2 UE1.L8 ; QF2.1 60.36,13.37 60.56,13.17 60.56,12.69 60.99,12.25 62.24,12.25 63.58,13.6 64.18,13.6 v1(64.35,13.77) ; v1(63.62,14.57) 63.95,14.24 64.28,14.24 64.69,14.65 64.69,15.8 v5(65.01,16.11)
  IN1 w0.064: v1(64.35,13.77) 63.62,14.49 v1(63.62,14.57) ; v2(212.45,58) 212.53,58.08 v1(212.53,58.37)
  IN2 w0.051: v5(65.01,16.11) 65.27,15.85 69.12,15.85 69.64,16.37 78.59,16.37 83.61,11.35 83.61,9.73 84.24,9.09 85.07,9.09 85.24,9.26 85.76,9.26 86.32,9.82 86.32,10.02 86.79,10.49 86.79,19.96 89.03,22.21 89.03,48.25 90.84,50.06 98.61,50.06 101.51,52.96 107.8,52.96 108.63,53.8 111.08,53.8 111.87,54.58 111.94,54.65 113.58,54.65 113.84,54.91 114.09,54.91 114.22,55.04 121.97,55.04 122.42,54.58 126.39,54.58 127.3,55.49 128.34,55.49 128.57,55.27 137.54,55.27 137.83,54.98 138.83,54.98 139.85,55.99 140.55,55.99 141.73,54.81 143.26,54.81 143.81,55.36 144.71,55.36 144.86,55.51 144.86,55.57 145.17,55.88 146.25,55.88 146.8,55.32 155.1,55.32 155.34,55.08 155.83,55.08 156.2,54.71 159.06,54.71 159.51,55.15 161.81,55.15 162.08,54.88 164.15,54.88 165.35,56.08 165.35,58.48 166.97,60.11 169.23,60.11 170.5,61.38 171.18,61.38 172,62.19 177.78,62.19 177.88,62.1 181.24,62.1 181.82,61.52 189.35,61.52 190.03,62.2 190.9,62.2 190.99,62.11 191.07,62.11 191.32,61.86 192.3,61.86 193.02,61.14 196.97,61.14 197.76,60.34 201.1,60.34 201.19,60.43 204.03,60.43 v2(204.26,60.65) 205.27,61.67 207.09,61.67 208.18,62.75 209.38,62.75 209.69,62.44 v2(210.22,62.44)
  IN3 w0.064: v2(204.26,60.65) 204.26,60.42 206.88,57.8 212.25,57.8 v2(212.45,58) ; v4(210.47,62.23) 210.43,62.23 v2(210.22,62.44)
  BOTTOM w0.081: v4(210.47,62.23) v3(210.47,61.38)
FSH_VREF_I: length 10
  TOP w0.081: USSD1.AA13 204.25,30.92 204.25,30.2 205.77,28.68 208.05,28.68 210.33,26.39 TP80.1
GPD7: length 5.7
  TOP w0.081: UC1.DC47 166.07,46.63 165.9,46.81 165.9,47.37 165.69,47.57 165.45,47.57 164.69,48.33 164.69,50.46 TP101.1
GPIO011: length 1
  TOP w0.081: v5(211.54,58.4) UE1.K7
  BOTTOM w0.081: v5(211.54,58.4) 211.91,58.77 TP84.1
GPIO043: length 3.4
  TOP w0.081: UE1.J12 216.31,59.14 217.48,59.14 217.9,58.73 218.39,58.73 TP112.1
GPIO100: length 2.4
  TOP w0.081: RE487.1 206.28,56.5 206.72,56.94 206.87,56.94 UE1.M1
GPIO140: length 3.7
  TOP w0.081: RE485.2 218.7,67.54 217.65,66.49 216.43,66.49 UE1.A12
GPIO167: length 4.1
  TOP w0.081: RE487.2 204.41,56.5 204.69,56.78 204.69,56.81 204.76,56.87 206.18,56.87 206.65,57.34 206.73,57.34 206.95,57.57 207.17,57.57 207.56,57.96 UE1.L2
GPP_A23: length 19.9
  IN1 w0.064: v2(167.42,46.29) 167.1,46.29 v1(166.8,45.98)
  IN2 w0.051: v2(167.42,46.29) 167.66,46.29 168.28,46.91 168.76,46.91 169.19,46.48 172.3,46.48 172.72,46.07 175.25,46.07 176.24,47.05 177.33,47.05 178.24,46.15 v2(178.91,46.15)
  IN3 w0.064: v2(178.91,46.15) 178.91,46.15 178.91,45.25 v4(179.15,45.01)
  BOTTOM w0.081: v4(179.15,45.01) 179.15,44.84 v3(180.06,43.92) 180.9,43.09 181.68,43.09 RH715.1 RH203.1
GPP_B11: length 1.8
  IN1 w0.099: v1(160.59,42.96) 160.43,42.96 v2(160.24,42.77)
  IN3 w0.064: v4(160.62,42.99) 160.46,42.99 v2(160.24,42.77)
  BOTTOM w0.081: v3(160.81,42.12) 160.62,42.31 v4(160.62,42.99)
GPP_B23: length 5.8
  TOP w0.089: v1(160.84,47.11) 160.84,47.15 160.71,47.29 UC1.CL48
  IN1 w0.064: v2(161.34,47.09) 161.32,47.12 160.87,47.12 160.86,47.11 v1(160.84,47.11)
  IN3 w0.064: v4(161.37,47.61) 161.37,47.12 v2(161.34,47.09)
  BOTTOM w0.081: v4(161.37,47.61) 161.37,50.28 v3(160.94,50.71) 160.69,50.46 RH647.1
GPP_C2: length 1.9
  IN1 w0.089: v1(170.68,35.97) 170.68,35.61 v2(170.61,35.54)
  IN3 w0.064: v4(171.04,36.13) 171.04,35.91 170.66,35.54 170.61,35.54 v2(170.61,35.54)
  BOTTOM w0.081: v4(171.04,36.13) RH692.1
GPP_C5: length 8.1
  TOP w0.081: v1(172.21,35.42) 172.18,35.39 172.18,35.25 UC1.DP22
  IN1 w0.089: v2(172.56,35.41) 172.55,35.42 v1(172.21,35.42)
  IN3 w0.064: v2(172.56,35.41) 173.05,34.91 175.69,34.91 v4(175.74,34.96)
  BOTTOM w0.081: RH666.1 RH98.1 177.61,35.47 176.63,35.47 176.12,34.96 v4(175.74,34.96) 175.17,34.96 v3(175.1,34.9)
GPP_E6: length 7.7
  TOP w0.081: RH660.1 RH661.1 177.68,25.63 v1(177.39,25.92)
  IN1 w0.064: v1(177.39,25.92) 177.39,26.25 v2(176.61,27.02)
  IN1 w0.081: 173.4,30.02 173.46,30.02 v2(173.51,30.07)
  IN1 w0.089: 173.4,30.02 v1(173.14,30.02)
  IN2 w0.051: v2(176.61,27.02) 176.56,27.08 176.56,27.12 175.39,28.3 175.3,28.3 174.69,28.91 174.69,29.18 173.8,30.07 v2(173.51,30.07)
GPP_F4: length 15.6
  TOP w0.081: RC746.2 182.15,37.6 v1(182.3,37.45) ; UC1.DJ29 169.48,37.8 v1(169.87,38.19)
  IN1 w0.064: v1(169.87,38.19) 169.88,38.19 170.51,37.55 172.19,37.55 172.67,38.03 174.42,38.03 175.4,39.01 176.57,39.01 177.07,38.51 177.77,38.51 178.74,37.54 179.39,37.54 179.54,37.69 180.06,37.69 180.76,36.99 181.2,36.99 181.52,37.3 182.16,37.3 v1(182.3,37.45)
GPP_F5: length 13.7
  TOP w0.081: v1(170.94,37.3) 170.73,37.5 170.33,37.5 UC1.DK29
  IN1 w0.064: v1(170.94,37.3) 171.02,37.38 172.26,37.38 172.74,37.86 174.48,37.86 175.47,38.84 176.48,38.84 176.98,38.35 177.7,38.35 178.67,37.37 179.46,37.37 179.61,37.53 179.99,37.53 180.69,36.82 181.27,36.82 181.47,37.02 v1(181.86,37.02)
GPP_F19: length 6.4
  TOP w0.081: v1(175.37,36.7) 175.37,37.18 175.06,37.48 174.64,37.48 174.54,37.45 174.33,37.45 174.24,37.48 173.99,37.48 173.91,37.45 173.67,37.45 173.5,37.52 172.62,37.52 172.37,37.27 171.29,37.27 170.91,36.89 UC1.DL27
  IN1 w0.064: v2(175.79,36.7) v1(175.37,36.7)
  IN3 w0.064: v2(175.79,36.7) 175.56,36.93 v4(175.53,36.93)
GPP_H0: length 0.9
  IN1 w0.089: v1(170.03,42.38) 170.03,42.47 v2(170.28,42.71)
  IN3 w0.064: v4(170.28,43.22) 170.28,43.21 v2(170.28,42.71)
GPP_H1: length 3.1
  IN1 w0.089: v1(168.73,42.38) v2(169.07,42.71)
  IN3 w0.081: v2(169.07,42.71) 169.07,43.36 168.2,44.23 v4(167.42,44.23)
GPP_H2: length 3.8
  IN1 w0.089: v2(169.68,42.66) 169.39,42.38 v1(169.38,42.38)
  IN3 w0.064: v2(169.68,42.66) 170.02,42.32 v4(170.02,42.3)
  BOTTOM w0.081: v4(170.02,42.3) RH618.1 170.66,43.69 v3(171.24,44.28)
GPP_H3: length 4
  IN1 w0.064: v1(168.73,43.29) 169,43.02 170.46,43.02 v2(170.85,42.63)
  IN3 w0.081: v4(171.11,42.9) v2(170.85,42.63)
  BOTTOM w0.081: TP57.1 171.87,43.34 171.86,43.34 171.56,43.34 v4(171.11,42.9)
GPP_R5: length 28.5
  TOP w0.089: v1(166.28,47.93) 166.11,48.1 165.96,48.1 165.8,47.94 UC1.DA49
  IN1 w0.064: v2(166.62,43.35) 166.57,43.39 166.57,43.6 166.15,44.03 165.83,44.03 165.77,44.09 165.77,44.99 165.94,45.17 165.94,45.76 166.18,46 166.18,47.84 v1(166.28,47.93)
  IN2 w0.051: v2(166.62,43.35) 166.62,42.12 166.92,41.82 169.26,41.82 169.39,41.95 171.22,41.95 171.58,41.58 172.28,41.58 172.78,42.07 174.3,42.07 174.44,41.94 178.45,41.94 178.82,41.57 v2(180.31,41.57)
  IN3 w0.064: v2(180.31,41.57) 180.31,41.75 181.33,42.77 v4(181.41,42.77)
  BOTTOM w0.081: v4(181.41,42.77) 181.79,42.39 184.75,42.39 184.88,42.52 RH202.1 184.88,43.63 v3(185,43.75)
GPP_S4: length 14.6
  IN1 w0.064: v1(167.91,42.31) 167.91,42.31 v2(168.31,42.71)
  IN2 w0.051: v2(179.04,42.45) 174.65,42.45 174.51,42.58 171.29,42.58 171.02,42.3 168.71,42.3 v2(168.31,42.71)
  IN3 w0.064: v4(180.02,42.77) 179.69,42.45 v2(179.04,42.45)
  BOTTOM w0.081: v4(180.02,42.77) RH201.1 179.1,42.77 v3(178.47,43.41)
GPP_S5: length 15.6
  IN1 w0.064: v1(166.99,42.96) 167.31,42.65 167.8,42.65 168.37,43.21 168.37,43.41 168.56,43.6 168.76,43.6 169.18,43.18 170.52,43.18 170.75,42.94 175.6,42.94 175.95,43.29 179.03,43.29 179.12,43.2 v2(179.93,43.2)
  IN3 w0.064: v4(180.6,42.77) 180.58,42.77 180.15,43.2 v2(179.93,43.2)
  BOTTOM w0.081: RH200.1 v4(180.6,42.77)
H_CATERR#: length 4.5
  TOP w0.081: RH80.1 129.19,22.9 130.01,23.72 130.01,24.5 130.64,25.13 130.64,25.33 130.53,25.44 130.53,25.6 UC1.J4
H_PROCHOT#: length 248.3
  TOP w0.081: PR1109.2 99.11,51.8 v1(99.22,51.69) ; D21.2 185.72,44.78 184.63,43.69 184.63,43.15 v1(184.82,42.96) ; v1(220.36,59.91) 220.31,59.96 220.31,60.5 RE158.2 ; RC614.1 RH96.1 123.83,19.95 v5(123.79,19.99)
  IN1 w0.064: v5(169.7,29.96) 170.05,30.31 170.71,30.31 171.03,30.63 171.03,31.04 171.58,31.6 172.63,31.6 173.55,32.52 179.38,32.52 180.5,33.65 182.88,33.65 183.65,32.87 183.96,32.87 184.18,33.09 184.47,33.09 184.63,33.25 184.63,39.4 185.03,39.8 185.03,41.05 185.3,41.32 185.3,41.39 185.64,41.73 185.64,42.57 185.25,42.96 v1(184.82,42.96) 184.82,43.6 184.49,43.92 v2(182.94,43.92) ; v1(99.22,51.69) 99.16,51.69 98.9,51.95 95.24,51.95 90.27,46.98 90.27,37.25 92.79,34.73 92.79,23.64 89.76,20.61 85.69,20.61 84.04,18.96 84.04,18.01 84.44,17.61 87.81,17.61 88.32,17.1 89.16,17.1 89.78,16.48 93.13,16.48 93.89,15.71 96.18,15.71 97.26,14.63 104.08,14.63 105.72,16.27 110.5,16.27 111.09,16.86 114.08,16.86 114.52,16.42 119.26,16.42 122.83,19.99 v5(123.79,19.99) ; v1(220.36,59.91) 220.36,58.64 220.55,58.45 220.55,53.16 219.93,52.54 219.93,45.91 216.28,42.26 216.28,40.38 213.51,37.61 213.51,36.92 211.87,35.28 210.79,35.28 210.47,34.96 210.47,33.69 v2(210.66,33.5)
  IN2 w0.051: v2(210.66,33.5) 210.33,33.83 208.79,33.83 203.36,39.27 197.16,39.27 196.45,39.98 192.82,39.98 190.77,42.03 190.77,43.26 190.27,43.76 188.88,43.76 187.69,44.96 185.66,44.96 184.63,43.92 v2(182.94,43.92)
  BOTTOM w0.081: v5(169.7,29.96) v3(169.7,28.68) 169.7,26.36 166.92,23.58 157.02,23.58 155.8,22.36 151.27,22.36 151.01,22.61 151.01,24.11 150.55,24.57 148.67,24.57 148.58,24.48 147.42,24.48 145.38,22.45 125.83,22.45 123.79,20.42 v5(123.79,19.99)
H_PROCHOT#_R: length 7.7
  TOP w0.081: CC739.1 124.09,21.16 v3(123.22,20.29) ; CC739.1 RC614.2 ; CC739.1 124.56,22.26 126.91,24.61 126.91,25.08 UC1.C3
H_THERMTRIP#: length 124.2
  TOP w0.081: v1(199.55,58.46) 199.52,58.43 QE16.3 ; v5(125.97,21.94) 125.95,21.93 RH95.1 CC738.1 126.52,23.02 127.1,23.6
  TOP w0.089: UC1.E3 127.72,25.23 127.59,25.11 127.59,24.66 127.48,24.55 127.48,23.98 127.1,23.6
  IN1 w0.064: v1(199.55,58.46) 199.31,58.22 199.31,55.96 199.1,55.74 199.1,54.11 196.94,51.95 196.94,50.63 197.19,50.37 197.19,49.54 193.4,45.75 193.4,34.16 193.51,34.05 193.51,32.61 193.83,32.29 193.83,31.66 193.51,31.34 193.51,30.58 193.14,30.2 193.14,26.26 192.89,26.01 v5(192.89,23.11)
  BOTTOM w0.081: v5(192.89,23.11) 190.23,23.11 186.87,19.74 180.76,19.74 177.48,23.02 177.48,24.39 176.58,25.29 175.81,25.29 173.28,27.82 171.51,27.82 170.44,26.75 170.44,25.92 169.01,24.48 v3(168.37,24.48) 167.08,23.19 157.18,23.19 155.96,21.97 151.11,21.97 150.63,22.45 150.63,23.95 150.39,24.19 148.83,24.19 148.69,24.04 147.52,24.04 145.42,21.94 v5(125.97,21.94)
HDA_BIT_CLK: length 3.8
  IN1 w0.064: v2(164.66,46.51) 164.86,46.31 v1(164.93,46.31)
  IN3 w0.064: v2(164.66,46.51) 164.72,46.57 164.72,46.63 164.43,46.91 164.43,47.09 164.1,47.43 164.1,47.94 v4(164.28,48.13)
  BOTTOM w0.081: RH688.1 RH113.2 163.7,48.82 164.28,48.23 v4(164.28,48.13)
HDA_BIT_CLK_L: length 177.9
  TOP w0.081: UA1.14 33.46,14.43 34.2,13.69 v1(34.2,13.66)
  IN1 w0.064: v1(34.2,13.66) 34.49,13.37 34.84,13.37 35.59,12.62 40.95,12.62 41.77,13.44 48.52,13.44 48.87,13.78 60.54,13.78 62.72,11.61 65.8,11.61 66.14,11.96 68,11.96 70.26,9.69 72.28,9.69 73.44,8.53 76.08,8.53 78.63,5.98 87.01,5.98 90.25,9.22 90.25,9.54 v2(90.23,9.55)
  IN2 w0.051: v2(163.81,48.62) 163.6,48.83 163.27,48.83 162.28,49.82 159.1,49.82 158.51,50.4 155.14,50.4 154.46,51.09 139.14,51.09 139.12,51.07 131.39,51.07 130.95,50.63 130.13,50.63 130.13,50.63 127.49,50.63 127.37,50.75 116.63,50.75 116.4,50.52 115.3,49.41 103.89,49.41 103.6,49.12 102.35,49.12 99.87,46.65 93.24,46.65 92.11,45.51 92.11,43.75 92.58,43.28 92.58,13.4 91.85,12.68 89.9,10.72 89.9,9.96 90.23,9.63 v2(90.23,9.55)
  IN3 w0.064: v2(163.81,48.62) 163.49,48.93 163.49,49.21 v4(163.7,49.41)
  BOTTOM w0.081: CH40.1 v4(163.7,49.41)
HDA_SDIN0: length 179.8
  IN1 w0.064: v2(164.49,45.45) 164.3,45.64 v1(164.3,45.98) ; v1(34.77,13.08) 34.81,13.08 35.46,12.43 41.12,12.43 41.87,13.18 48.54,13.18 48.95,13.59 59.03,13.59 61.28,11.35 65.93,11.35 66.28,11.7 67.98,11.7 70.24,9.44 72.27,9.44 73.36,8.34 76,8.34 78.61,5.73 87.03,5.73 90.57,9.27 90.57,9.81 v2(90.8,10.05)
  IN2 w0.051: v2(90.8,10.05) 90.94,10.19 90.94,10.24 93.25,12.55 93.25,44.24 94.49,45.48 99.78,45.48 101.59,47.28 102.83,47.28 104.2,48.65 115.61,48.65 116.95,49.99 125.44,49.99 126.12,49.31 134.55,49.31 135.24,50 139.13,50 139.46,50.33 143.3,50.33 144.52,49.1 146.36,49.1 147.45,50.2 153.16,50.2 154.05,49.3 155.09,49.3 155.43,49.64 158.2,49.64 158.97,48.87 158.97,48.08 159.33,47.73 160.22,47.73 160.32,47.63 160.43,47.52 161.47,47.52 161.67,47.31 161.67,46.91 161.2,46.44 161.2,46.44 160.94,46.18 160.94,45.93 161.58,45.3 161.58,44.86 162.08,44.36 163.1,44.36 163.72,44.98 164.03,44.98 v2(164.49,45.45)
  IN3 w0.064: v4(164.5,45.92) 164.5,45.45 v2(164.49,45.45)
HDA_SDIN0_L: length 2.6
  TOP w0.081: RA17.1 34.77,13.77 34.6,13.94 34.6,14.2 33.57,15.23 UA1.16
HDA_SDOUT: length 3.1
  TOP w0.089: UC1.CY47 165.13,46.96 165.26,47.09 v1(165.26,47.09)
  IN1 w0.064: v1(165.26,47.09) 164.95,47.09 v2(164.85,47.19)
  IN3 w0.064: v4(164.94,47.6) 164.94,47.28 v2(164.85,47.19)
  BOTTOM w0.081: RH112.2 RH217.2 v3(164.94,47.98) v4(164.94,47.6)
HDA_SDOUT_L: length 178.2
  TOP w0.081: UA1.17 33.46,15.63 34.07,15.02 34.2,15.02 v3(34.26,14.96) 34.32,14.96 34.87,14.41 v1(34.87,14.09)
  IN1 w0.064: v2(89.38,9.29) 89.38,8.88 86.85,6.36 78.79,6.36 76.23,8.92 73.6,8.92 72.44,10.08 70.42,10.08 68.16,12.34 65.98,12.34 65.64,11.99 62.87,11.99 60.7,14.17 48.71,14.17 48.36,13.82 41.61,13.82 40.79,13 35.75,13 34.87,13.89 v1(34.87,14.09)
  IN2 w0.051: v2(164.31,49.07) 164.19,49.07 163.09,50.18 159.24,50.18 158.66,50.76 155.35,50.76 154.66,51.45 138.99,51.45 138.97,51.42 131.24,51.42 130.8,50.98 130.28,50.98 130.27,50.99 127.64,50.99 127.52,51.11 116.49,51.11 116.28,50.9 115.15,49.77 103.27,49.77 103.03,50.01 102.35,50.01 99.34,47 93.1,47 91.75,45.66 91.75,43.6 92.22,43.13 92.22,13.55 89.38,10.7 v2(89.38,9.29)
  IN3 w0.064: v4(164.31,49.41) 164.31,49.08 v2(164.31,49.07)
  BOTTOM w0.081: CH50.1 v4(164.31,49.41)
HDA_SYNC: length 2
  TOP w0.089: v1(164.58,47.87) 164.48,47.87 164.42,47.94 UC1.CV49
  IN1 w0.064: v2(163.71,47.11) 163.82,47.22 163.93,47.22 v1(164.58,47.87)
  IN3 w0.064: v4(163.74,47.56) 163.74,47.43 163.81,47.36 163.81,47.2 v2(163.71,47.11)
HDA_SYNC_L: length 178.7
  TOP w0.081: v1(34.25,14.08) 33.5,14.83 UA1.15
  IN1 w0.064: v1(34.25,14.08) 34.44,14.08 34.68,13.84 34.68,13.81 35.67,12.81 40.87,12.81 41.69,13.63 48.44,13.63 48.79,13.97 60.62,13.97 62.8,11.8 65.72,11.8 66.06,12.15 68.08,12.15 70.34,9.89 72.36,9.89 73.52,8.72 76.16,8.72 78.71,6.17 86.93,6.17 89.72,8.96 v2(89.72,9.66)
  IN2 w0.051: v2(89.72,9.66) 89.72,10.79 91.68,12.75 92.4,13.48 92.4,43.21 91.93,43.68 91.93,45.59 93.17,46.83 99.8,46.83 102.28,49.3 103.52,49.3 103.81,49.59 115.22,49.59 116.34,50.71 116.56,50.93 127.45,50.93 127.56,50.81 130.2,50.81 130.21,50.81 130.88,50.81 131.32,51.24 139.04,51.24 139.07,51.27 154.53,51.27 155.22,50.58 158.58,50.58 159.17,50 162.9,50 164.19,48.7 164.19,48.35 163.98,48.13 163.46,48.13 163.42,48.18 v2(163.42,48.23)
  IN3 w0.064: v4(163.74,48.14) 163.53,48.14 163.44,48.23 v2(163.42,48.23)
  BOTTOM w0.081: CH51.1 v4(163.74,48.14)
HOST_DEBUG_TX: length 87.4
  TOP w0.081: UE1.G11 v1(215.52,61.01) ; RE202.2 v1(228.51,9.83)
  IN1 w0.064: v1(228.51,9.83) 228.87,10.2 v2(229.23,10.2) 229.23,9.73 229.73,9.22 230.1,8.86 230.27,8.86 230.7,8.42 230.7,8.28 231.06,7.92 231.06,7.07 v1(230.8,6.81) ; v1(215.52,61.01) 215.35,61.17 215.35,61.92 215.43,62 215.43,64.66 214.52,65.58 214.52,66.51 214.03,67 214.03,68.83 214.56,69.35 218.31,69.35 219.41,68.25 v2(220.03,68.25)
  IN2 w0.051: v2(229.23,10.2) 229.23,10.22 223.2,16.25 223.2,17.98 221.63,19.54 221.63,22.58 221.19,23.03 221.19,24.19 220.92,24.47 220.33,24.47 219.32,25.48 219.32,27.3 220.32,28.3 220.32,36.84 218.94,38.22 v2(218.94,39.02)
  IN3 w0.064: v2(218.94,39.02) 218.94,39.68 219.81,40.56 219.81,41.88 221.29,43.36 221.29,44.59 222.36,45.66 222.36,66.15 220.25,68.25 v2(220.03,68.25)
HOST_SD_WP#: length 175
  TOP w0.081: 157.07,48.41 157.07,49.13 156.43,49.77 RC717.2 ; QR1.2 279.72,31.25 v1(279.94,31.47)
  TOP w0.089: 157.07,48.41 157.07,47.31 UC1.CE47 157.42,46.74 157.79,46.37 v1(157.79,46.3)
  IN1 w0.064: v2(166.53,41.38) 166.21,41.7 160.26,41.7 159.21,42.75 159.21,42.79 159.18,42.82 159.18,43.72 159.27,43.82 159.27,45.31 158.81,45.77 158.55,45.77 158.02,46.3 v1(157.79,46.3) ; v1(279.94,31.47) 280.39,31.47 v2(280.83,31.02) ; v2(206.1,25.26) 205.9,25.46 205.9,27.21 204.86,28.25 v2(204.86,30.73)
  IN2 w0.051: v2(166.53,41.38) 166.53,41.06 166.39,40.92 166.39,40.51 166.97,39.93 168.55,39.93 168.92,39.56 169.88,39.56 170.99,40.66 172.12,40.66 172.47,40.31 174.59,40.31 175.2,40.92 176.78,40.92 176.99,40.72 180.05,40.72 180.35,40.42 183.44,40.42 185.18,38.67 186.05,38.67 189.27,35.45 189.72,35.45 192.38,32.79 193.21,32.79 193.59,32.42 197.17,32.42 198.05,31.54 204.06,31.54 v2(204.86,30.73) ; v2(206.1,25.26) 206.47,24.89 208.69,24.89 209.33,24.26 209.33,20.12 212.74,16.7 212.74,14.29 215.49,11.54 220.79,11.54 227.87,4.47 234.32,4.47 236.1,6.25 248.11,6.25 249.17,7.3 251.23,7.3 252.99,5.54 262.68,5.54 264.8,7.66 264.8,9.11 265.3,9.61 266.81,9.61 267.82,10.63 269.18,10.63 272.22,13.68 272.22,15.03 274.77,17.58 274.77,18.72 276.32,20.27 276.32,20.34 276.38,20.4 276.38,24.95 276.16,25.18 276.16,25.95 280.83,30.62 v2(280.83,31.02)
HP_PLUG#: length 79.2
  TOP w0.081: v1(21.44,20.22) 21.66,20 21.66,19.37 22.43,18.61 22.43,16.21 19.97,13.75 19.97,11.66 20.61,11.02 20.61,10.26 20.92,9.94 22.01,9.94 22.65,10.58 22.97,10.58 23.6,11.21 RA14.2 ; v5(12.29,68.43) 11.79,67.93 DA13.1 10.69,67.93 10.13,68.49 9.01,68.49 8.22,69.28 JHP1.5
  IN1 w0.064: v1(21.44,20.22) 21.5,20.28 v2(21.5,20.91)
  IN2 w0.051: v5(12.29,68.43) 12.35,68.49 14.19,68.49 14.51,68.17 14.51,67.09 15.46,66.14 15.46,54.29 15.91,53.85 17.05,53.85 18.51,52.39 18.51,39.46 17.5,38.45 17.5,37.84 17.9,37.44 17.9,34.22 16.8,33.11 16.8,27.47 18.45,25.82 v5(18.45,24.7) 18.45,24.42 19.51,23.36 19.86,23.36 21.5,21.73 v2(21.5,20.91)
  BOTTOM w0.081: v5(18.45,24.7) v3(18.98,24.7)
HPOL_CONN: length 4.8
  TOP w0.381: JHP1.1 7.59,75.73 v5(5.87,75.73)
  BOTTOM w0.381: CA84.1 6.62,75.71 LA19.2 6.02,75.58 v5(5.87,75.73) 5.37,75.23 DA5.1
HPOR_CONN: length 5.8
  TOP w0.381: LA18.2 DA4.1 CA85.1 13.35,73.15 v6(12.87,73.64) 11.4,75.1 JHP1.2
HPOUT-L: length 72.5
  TOP w0.102: v1(27.21,23.47) 27.21,24.04 v3(26.51,24.74)
  IN1 w0.381: v2(7.94,74.79) 9.03,73.7 11.78,73.7 12.64,72.84 12.64,71.7 23.02,61.31 23.02,54.14 20.11,51.23 20.11,27.9 22.77,25.25 25.43,25.25 v1(27.21,23.47) 28.04,22.64 30.09,22.64 v1(31.85,20.89)
  IN3 w0.381: v2(7.94,74.79) 7.94,75 v4(7.82,75.12)
HPOUT-L_L: length 1.4
  BOTTOM w0.381: RA6.2 CA61.1 6.99,74.53 6.8,74.73 LA19.1
HPOUT-R: length 62.8
  TOP w0.102: v1(29.62,23.47) v3(30.7,23.47)
  TOP w0.381: RA3.1 v1(15.95,69.47)
  IN1 w0.381: v1(15.95,69.47) 15.95,69.47 23.78,61.63 23.78,53.82 20.87,50.91 20.87,28.22 23.08,26.01 26,26.01 28.54,23.47 v1(29.62,23.47) 30.39,23.47 32.42,21.44 v1(32.42,20.89)
HPOUT-R_L: length 2.4
  TOP w0.102: v3(15.15,71.03) 14.93,70.81 LA18.1
  TOP w0.381: LA18.1 CA60.1 RA3.2
HRESET_L_PD: length 3.2
  TOP w0.081: RPD88.1 11.24,26.04 12.17,25.11 12.68,25.11 13.26,24.53
HRESET_R_PD: length 1.7
  TOP w0.081: UPD2.44 284.03,18.24 284.37,18.58 RPD97.1
I2C1_PD_L_CLK: length 29.7
  TOP w0.081: UPD1.27 18.55,19.24 18.66,19.24 18.74,19.16 v1(18.74,19.06)
  IN1 w0.064: v1(18.74,19.06) 18.74,19.2 18.07,19.89 18.07,21.39 18.83,22.15 18.83,22.79 19.39,23.35 19.39,24.93 19.1,25.22 18.2,25.22 14.18,29.25 10.95,29.25 10.56,29.64 10.56,34.45 9.86,35.15 9.2,35.15 v2(9.11,35.06)
  IN3 w0.064: v2(9.11,35.06) 8.9,35.27 8.7,35.27 8.68,35.27 v4(8.59,35.17)
  BOTTOM w0.081: RPD163.1 11.86,35.86 11.41,35.86 11.26,35.71 JDB1.7 10.49,35.71 10.34,35.86 10.07,35.86 9.47,35.26 8.68,35.26 v4(8.59,35.17)
I2C1_PD_L_DAT: length 29.8
  TOP w0.081: UPD1.28 18.8,19.55 18.8,19.46 18.93,19.33 v1(19.02,19.33)
  IN1 w0.064: v1(19.02,19.33) 18.88,19.33 18.26,19.97 18.26,21.31 19.02,22.07 19.02,22.71 19.58,23.27 19.58,25.01 19.17,25.42 18.28,25.42 14.26,29.44 11.03,29.44 10.75,29.72 10.75,34.53 9.94,35.34 9.37,35.34 v2(9.11,35.6)
  IN3 w0.064: v4(8.59,35.56) 8.69,35.46 8.98,35.46 v2(9.11,35.6)
  BOTTOM w0.081: v4(8.59,35.56) 8.68,35.47 9.39,35.47 9.98,36.07 10.34,36.07 10.49,36.21 JDB1.8 11.29,36.21 11.44,36.07 12.21,36.07 RPD164.1
I2C1_PD_L_INT#: length 2.9
  TOP w0.081: RPD17.1 20.31,20.52 19.93,20.9 19.52,20.9 18.95,21.48 18.83,21.48 UPD1.29
I2C1_PD_R_CLK: length 51.9
  TOP w0.081: RPD165.1 284.63,8.88 v5(284.36,9.15) 284.38,9.17 284.38,9.29 284.03,9.64 UPD2.27
  IN3 w0.064: v5(284.36,9.15) 284.56,8.95 284.56,8.68 284.81,8.42 285.85,8.42 288.13,10.7 288.13,17.2 287.56,17.77 287.56,18.13 v4(287.67,18.24)
  BOTTOM w0.081: v4(287.67,18.24) 287.64,18.24 287.56,18.32 287.56,18.52 287.29,18.79 286.31,18.79 285.8,19.3 285.8,19.68 285.42,20.06 v7(279.81,20.06) 273.7,20.06 272.51,21.25 270.31,21.25 267.09,18.02 262.56,18.02 259.41,14.88 259.41,11.07 259.23,10.88 JDB2.7
I2C1_PD_R_DAT: length 50.6
  TOP w0.081: RPD166.1 285.26,8.83 v5(284.94,9.15) 284.94,9.17 284.43,9.68 UPD2.28
  IN3 w0.064: v4(287.29,18.24) 287.37,18.16 287.37,17.69 287.94,17.12 287.94,10.78 285.77,8.61 284.89,8.61 284.75,8.76 284.75,8.95 v5(284.94,9.15)
  BOTTOM w0.081: v4(287.29,18.24) 287.35,18.31 287.35,18.43 287.21,18.58 286.23,18.58 285.59,19.21 285.59,19.59 285.34,19.85 v7(278.23,19.85) 273.61,19.85 272.42,21.04 270.4,21.04 267.18,17.82 262.65,17.82 259.62,14.79 259.62,10.96 259.73,10.85 JDB2.8
I2C1_PD_R_INT#: length 3.6
  TOP w0.081: UPD2.29 286.08,10.95 286.53,10.5 286.53,10.36 RPD109.1 287.01,9.54 v3(287.75,8.8)
I2C1_SCK_TP: length 104.1
  TOP w0.081: JIO1.34 253.55,9.41 253.35,9.61 253.35,9.89 253.85,10.38 253.85,10.68 v1(254.16,10.98) ; v1(174.95,35.56) 174.09,35.56 UC1.DU23
  IN1 w0.064: v2(207.7,26.07) 207.55,25.92 207.55,25.75 207.87,25.44 210.15,25.44 211.04,26.32 214.3,26.32 217.18,23.44 218.89,23.44 219.23,23.09 221.77,23.09 222.92,21.94 222.92,17.23 222.92,16.93 228.38,11.47 231.29,11.47 231.71,11.05 238.21,11.05 238.98,10.28 242.52,10.28 243.36,9.43 245.25,9.43 245.7,9.88 245.7,10.93 247.87,13.1 252.81,13.1 253.84,12.06 253.84,11.05 253.91,10.98 v1(254.16,10.98) ; v1(174.95,35.56) v2(175.23,35.83)
  IN2 w0.051: v2(207.7,26.07) 207.53,26.25 207.53,26.5 207.21,26.82 198.4,26.82 197.99,26.41 194.88,26.41 194.41,25.95 190.73,25.95 188.92,27.76 188.92,30.4 185.51,33.81 184.05,33.81 183.19,34.66 179.32,34.66 178.69,35.29 176.18,35.29 175.81,35.65 175.45,35.65 v2(175.23,35.83)
I2C1_SDA_TP: length 103.8
  TOP w0.081: JIO1.32 252.95,9.43 253.15,9.63 253.15,9.97 253.64,10.47 253.64,10.68 v1(253.33,10.98) ; UC1.DW23 175.08,35.26 175.35,35.52 v1(175.61,35.52)
  IN1 w0.064: v2(207.17,26.07) 207.36,25.88 207.36,25.68 207.79,25.25 210.23,25.25 211.12,26.13 214.22,26.13 217.1,23.25 218.81,23.25 219.16,22.9 221.7,22.9 222.73,21.86 222.73,17.31 222.73,16.85 228.3,11.28 231.22,11.28 231.64,10.86 238.14,10.86 238.9,10.09 242.44,10.09 243.29,9.24 245.33,9.24 245.89,9.81 245.89,10.85 247.95,12.91 252.73,12.91 253.65,11.98 253.65,11.05 253.59,10.98 v1(253.33,10.98) ; v1(175.61,35.52) 175.57,35.52 v2(175.29,35.25)
  IN2 w0.051: v2(207.17,26.07) 207.35,26.25 207.35,26.43 207.13,26.64 198.47,26.64 198.06,26.24 194.95,26.24 194.48,25.77 190.66,25.77 188.74,27.69 188.74,30.32 185.44,33.63 183.97,33.63 183.12,34.48 179.25,34.48 178.62,35.11 176.1,35.11 175.73,35.47 175.47,35.47 v2(175.29,35.25)
I2C2_PD_L_CLK: length 28.3
  TOP w0.081: v1(18.32,22.71) 18.19,22.71 17.91,22.42 17.91,22.25 UPD1.32
  IN1 w0.064: v1(18.32,22.71) 18.3,22.73 18.3,22.8 18.64,23.14 18.64,23.62 17.88,24.38 17.88,24.87 13.88,28.87 10.81,28.87 10.19,29.49 10.19,32.55 8.05,34.69 8.05,35.85 8.62,36.42 9.05,36.42 9.06,36.41 9.07,36.41 9.16,36.32 9.16,36.27 9.14,36.24 9.14,36.2 9.04,36.1 v2(8.94,36.1)
  IN3 w0.064: v2(8.94,36.1) 9.11,36.27 9.11,36.35 9.05,36.41 8.81,36.41 8.68,36.28 8.56,36.28 v4(8.37,36.09)
  BOTTOM w0.081: RPD21.1 11.86,36.74 11.78,36.82 11.78,36.93 11.71,37 11.48,37 11.19,36.71 JDB1.9 10.39,36.71 10.31,36.79 10.31,36.92 10.23,37 9.82,37 9.08,36.27 8.54,36.27 v4(8.37,36.09)
I2C2_PD_L_DAT: length 28.4
  TOP w0.081: v1(18.04,22.99) 18.04,22.95 18.02,22.93 18.02,22.83 17.75,22.56 17.65,22.56 UPD1.33
  IN1 w0.064: v1(18.04,22.99) 18.22,22.99 18.45,23.21 18.45,23.54 17.69,24.3 17.69,24.79 13.8,28.68 10.74,28.68 10,29.41 10,32.47 7.86,34.61 7.86,35.93 8.54,36.61 9.13,36.61 9.14,36.6 9.15,36.6 9.35,36.4 9.35,36.22 v2(9.47,36.1)
  IN3 w0.064: v2(9.47,36.1) 9.3,36.27 9.3,36.43 9.13,36.6 8.73,36.6 8.6,36.47 v4(8.37,36.47)
  BOTTOM w0.081: RPD22.1 12.09,37.21 JDB1.10 9.74,37.21 9,36.47 v4(8.37,36.47)
I2C2_PD_L_INT#: length 4
  TOP w0.081: UPD1.34 17.87,23.34 18.19,23.34 19.26,22.27 20.01,22.27 RPD112.1
I2C2_PD_R_CLK: length 44.8
  TOP w0.081: UPD2.32 286.07,12.15 286.6,11.62 286.77,11.62 v1(287,11.39)
  IN1 w0.064: v1(287,11.39) 286.81,11.58 286.66,11.58 286.48,11.4 v2(286.48,11.38)
  IN3 w0.064: v4(285.21,19.34) 285.34,19.21 285.67,19.21 286.18,18.71 286.18,18.63 286.93,17.88 286.93,17.32 287.56,16.69 287.56,12.04 287.07,11.55 286.65,11.55 v2(286.48,11.38)
  BOTTOM w0.081: v4(285.21,19.34) 285.15,19.4 v7(276.38,19.4) 273.4,19.4 272.19,20.61 270.67,20.61 267.43,17.37 262.86,17.37 260.36,14.88 260.36,11 260.23,10.87 JDB2.9
I2C2_PD_R_DAT: length 43.9
  TOP w0.081: UPD2.33 285.75,12.55 285.95,12.36 286.16,12.36 286.69,11.83 286.8,11.83 v1(287,12.03)
  IN1 w0.064: v2(286.48,11.91) 286.62,11.77 286.75,11.77 v1(287,12.03)
  IN3 w0.064: v2(286.48,11.91) 286.65,11.74 286.99,11.74 287.37,12.12 287.37,16.61 286.74,17.25 286.74,17.8 285.99,18.55 285.99,18.63 285.59,19.02 285.27,19.02 v4(285.21,18.96)
  BOTTOM w0.081: v4(285.21,18.96) 284.97,19.2 v7(274.92,19.2) 273.31,19.2 272.11,20.4 270.76,20.4 267.52,17.16 262.95,17.16 260.57,14.79 260.57,11.02 260.73,10.87 JDB2.10
I2C2_PD_R_INT#: length 1.8
  TOP w0.081: UPD2.34 286.71,12.95 RPD113.1
I2C2_SCL: length 4.9
  TOP w0.081: RH731.1 RH633.2 177.73,44.99 176.17,44.99 175.78,44.6 175.16,44.6 174.74,44.18 174.52,44.18 UC1.DV41
I2C2_SDA: length 5.9
  TOP w0.081: RH730.1 RH632.2 177.63,45.2 176.09,45.2 175.7,44.8 174.34,44.8 174.09,44.55 174.09,44.17 173.69,43.77
  TOP w0.089: 173.69,43.77 UC1.DU41
I2C3_PD_L_CLK: length 2.4
  TOP w0.081: 16.51,17.88 17.11,17.28 17.11,16.79 16.78,16.46 16.78,16.1 RPD194.2
I2C3_PD_L_CLK_R: length 57.3
  TOP w0.081: RPD198.1 17.35,15.49 v1(17.35,15.53)
  IN1 w0.064: v1(17.35,15.53) 17.35,15.23 v2(17.43,15.15)
  IN2 w0.051: v2(9.49,28.41) 9.33,28.58 9.07,28.58 8.97,28.47 8.97,27.11 9.27,26.82 9.27,25.22 16.48,18.01 16.48,17.18 17.73,15.93 17.73,15.71 17.56,15.53 17.42,15.53 17.39,15.51 17.33,15.47 17.3,15.41 v2(17.43,15.15)
  IN3 w0.064: v2(9.49,28.41) 9.34,28.41 v4(8.93,28.81)
  BOTTOM w0.081: RT212.2 10.19,48.11 10.19,48.19 9.98,48.4 9.98,48.95 10.3,49.27 14.56,49.27 14.91,48.91 14.91,47.94 15.19,47.66 17.5,47.66 17.94,47.22 17.94,40.13 17.26,39.45 17.26,37.59 18.72,36.13 18.72,32.4 18.03,31.71 13.64,31.71 10.87,28.93 v7(10.19,28.93) 9.05,28.93 v4(8.93,28.81)
I2C3_PD_L_DAT: length 2
  TOP w0.081: RPD142.2 17.34,17.33 17.24,17.43 17.24,17.73 UPD1.22
I2C3_PD_L_DAT_R: length 56.7
  TOP w0.081: RPD197.1 17.75,15.92 v1(17.75,15.94)
  IN1 w0.064: v1(17.75,15.94) 17.72,15.91 v2(17.05,15.91)
  IN2 w0.051: v2(9.51,28.94) 9.32,28.75 9,28.75 8.8,28.55 8.8,27.04 9.09,26.75 9.09,25.15 16.3,17.93 16.3,17.11 17.56,15.85 17.56,15.78 17.48,15.71 17.34,15.71 17.28,15.65 17.25,15.63 17.18,15.66 v2(17.05,15.91)
  IN3 w0.064: v2(9.51,28.94) 9.19,28.94 v4(8.93,29.19)
  BOTTOM w0.081: RT213.2 10.66,48.06 10.66,48.06 10.35,48.38 10.3,48.38 10.19,48.49 10.19,48.87 10.38,49.06 14.47,49.06 14.7,48.83 14.7,47.85 15.1,47.45 17.41,47.45 17.73,47.13 17.73,40.21 17.05,39.53 v7(17.05,38.9) 17.05,37.5 18.51,36.04 18.51,32.49 17.94,31.91 13.56,31.91 10.78,29.14 8.99,29.14 v4(8.93,29.19)
I2C3_PD_L_INT#: length 2
  TOP w0.081: RPD155.2 17.56,16.94 17.56,17.37 17.42,17.51 17.42,18.11 UPD1.23
I2C3_PD_L_INT#_R: length 37.4
  TOP w0.081: v1(20.68,22.44) 21.43,21.69 21.43,20.59 21.12,20.28 21.12,19.05 20.86,18.79 v3(20.86,17.69) 20.86,17.05 19.91,16.1 18.89,16.1 18.67,15.88 RPD196.1 18.58,15.93 18.57,15.93 RPD155.1
  IN1 w0.064: v1(18.7,47.32) 19.03,46.99 19.03,45.36 18.91,45.24 18.35,45.24 18.07,44.96 18.07,44.06 17.61,43.61 17.61,40.43 16.6,39.42 16.6,34.24 16.61,34.24 16.61,34.07 16.92,33.76 16.92,30.36 17.44,29.84 17.44,28.22 20.42,25.25 20.42,23.34 20.49,23.26 20.49,22.62 v1(20.68,22.44)
I2C3_PD_R_CLK: length 2.6
  TOP w0.081: RPD199.2 280.13,8.56 280.5,8.93 281.32,8.93 281.63,9.24 UPD2.21
I2C3_PD_R_CLK_R: length 62.6
  IN1 w0.064: v2(280.13,8.36) v1(280.13,7.96)
  IN2 w0.051: v2(280.13,8.36) 280.33,8.16 280.33,7.02 281.08,6.26 283.63,6.26 284.38,5.51 285.54,5.51 285.91,5.88 285.91,6.39 288.28,8.77 288.28,18.3 286.74,19.85 286.74,23.22 287.43,23.92 287.43,26.71 287.05,27.09 287.05,33.31 286.1,34.26 286.1,35.03 286.3,35.23 288.08,35.23 288.7,35.85 288.7,41.25 288.07,41.88 284.32,41.88 283.95,41.51 283.95,40.72 284.17,40.5 284.44,40.5 284.54,40.39 v2(284.54,40.33)
  IN3 w0.064: v4(280.13,8.74) v2(280.13,8.36) ; v4(277.85,40.08) 277.87,40.08 278.04,39.91 278.04,39.84 278.22,39.65 278.77,39.65 278.96,39.85 280.91,39.85 281.23,40.18 283.7,40.18 284.01,40.49 284.39,40.49 v2(284.54,40.33)
I2C3_PD_R_DAT: length 2.4
  TOP w0.081: UPD2.22 282.03,9.38 281.39,8.74 280.88,8.74 280.7,8.56 RPD146.2
I2C3_PD_R_DAT_R: length 60.9
  IN1 w0.064: v1(280.7,7.96) v2(280.7,8.36)
  IN2 w0.051: v2(284.58,40.87) 284.39,40.68 284.25,40.68 284.13,40.79 284.13,41.44 284.4,41.71 287.99,41.71 288.53,41.17 288.53,35.93 288.01,35.41 286.23,35.41 285.92,35.1 285.92,34.19 286.87,33.23 286.87,27.01 287.26,26.63 287.26,23.99 286.56,23.29 286.56,19.77 288.11,18.23 288.11,8.84 285.73,6.47 285.73,5.95 285.47,5.69 284.45,5.69 283.7,6.44 281.16,6.44 280.51,7.09 280.51,8.16 v2(280.7,8.36)
  IN3 w0.064: v2(280.7,8.36) v4(280.7,8.74) ; v2(284.58,40.87) 284.39,40.68 283.93,40.68 283.62,40.37 281.15,40.37 280.83,40.04 278.88,40.04 278.69,39.84 278.3,39.84 278.23,39.91 278.23,39.98 278.33,40.08 v4(278.42,40.08)
I2C3_PD_R_INT#: length 1.9
  TOP w0.081: UPD2.23 282.43,9.52 281.83,8.92 RPD131.2
I2C3_PD_R_INT#_R: length 58.1
  TOP w0.081: RPD202.1 281.27,8.37 281.83,7.81 RPD131.1 281.83,7.58 v1(281.66,7.4) ; v1(274.23,41.88) 274.54,42.2 RT217.2
  IN1 w0.064: v2(266.47,22.72) 266.47,21.7 266.99,21.18 266.99,17.05 267.62,16.42 267.62,15.4 268.7,14.32 271.69,14.32 272.38,15.02 274.23,15.02 274.8,14.45 276.13,14.45 276.7,13.88 276.7,13.37 276.54,13.21 275.97,13.21 275.62,12.86 275.43,12.86 274.99,12.42 274.99,11.09 275.94,10.13 275.94,8.23 276.26,7.91 277.53,7.91 278.35,8.74 281.15,8.74 281.34,8.55 281.34,7.72 v1(281.66,7.4) ; v1(274.23,41.88) 274.42,41.69 v2(274.42,41.25)
  IN2 w0.051: v2(266.47,22.72) 266.47,23.53 266.86,23.93 268.32,23.93 272.78,28.39 272.78,38.05 273.02,38.28 273.02,40.3 273.59,40.87 274.1,40.87 274.42,41.18 v2(274.42,41.25)
I2C_3_SCL_UFCAM: length 51.7
  IN1 w0.064: v2(179.4,57.51) 179.55,57.36 179.55,56.99 179.63,56.91 179.63,50.23 175.63,46.24 175.63,44.78 175.34,44.49 173.96,44.49 173.75,44.27 173.75,43.94 173.58,43.77 v1(172.81,43.77)
  IN3 w0.064: v4(164.81,77.66) 164.92,77.54 164.92,77.36 165.09,77.19 165.82,77.19 168.35,74.65 168.35,72.62 171.93,69.05 171.93,64.79 173.51,63.21 173.51,61.37 175.93,58.94 179.06,58.94 179.57,58.43 179.57,57.68 v2(179.4,57.51)
  BOTTOM w0.081: R6114.1 160.75,77.85 160.66,77.77 160.66,77.57 160.87,77.36 v7(162.08,77.36) 164.82,77.36 164.9,77.44 164.9,77.57 164.82,77.66 v4(164.81,77.66)
I2C_3_SCL_UFCAM_R: length 10.9
  TOP w0.081: v5(160.73,82.54) 160.54,82.73 160.54,83.07 160.6,83.13 160.6,83.44 160.7,83.54 JUFC1.18
  IN1 w0.064: v1(159.67,79.35) 159.67,79.54 160.22,80.08 160.37,80.24 160.69,80.24 160.95,80.5 160.95,81.48 160.73,81.7 v5(160.73,82.54)
  BOTTOM w0.081: R6114.2 160.66,78.84 160.66,79.69 160.75,79.77 161.05,79.77 ; v5(160.73,82.54) 160.54,82.35 160.54,81.71 160.71,81.55 160.71,81.27 D448.2 160.77,80.91 160.66,80.81 160.66,80.15 161.05,79.77 ; 161.05,79.77 R6129.1
I2C_3_SDA_UFCAM: length 52.3
  IN1 w0.064: v2(179.93,57.51) 179.74,57.32 179.74,57.07 179.82,56.99 179.82,50.15 175.82,46.16 175.82,44.7 175.42,44.3 174.04,44.3 173.94,44.19 173.94,43.92 174.09,43.77 v1(174.76,43.77)
  IN3 w0.064: v2(179.93,57.51) 179.76,57.68 179.76,58.51 179.14,59.13 176.01,59.13 173.7,61.45 173.7,63.29 172.12,64.87 172.12,69.13 168.54,72.7 168.54,74.73 165.89,77.38 165.17,77.38 165.11,77.44 165.11,77.58 v4(165.19,77.66)
  BOTTOM w0.081: v4(165.19,77.66) 165.11,77.58 165.11,77.36 164.9,77.15 v7(164.43,77.15) 160.79,77.15 160.46,77.48 160.46,77.77 160.38,77.85 R6115.1
I2C_3_SDA_UFCAM_R: length 12.6
  TOP w0.081: v5(160.15,82.54) 160.34,82.73 160.34,83.15 160.4,83.21 160.4,83.47 160.3,83.56 JUFC1.19
  IN1 w0.064: v5(160.15,82.54) 160.54,82.15 160.54,81.62 160.76,81.4 160.76,80.58 160.61,80.43 160.29,80.43 160.14,80.27 159.41,79.55 159.41,78.27 v1(159.67,78.01)
  BOTTOM w0.081: 160.07,79.77 160.38,79.77 160.46,79.69 160.46,78.84 R6115.2 ; 160.07,79.77 R6128.1 ; 160.07,79.77 160.46,80.15 160.46,80.75 160.29,80.91 D449.2 160.5,81.35 160.5,81.47 160.34,81.63 160.34,82.35 v5(160.15,82.54)
I2C_RT_L_INT#: length 13.9
  TOP w0.076: URT1.A10 9.06,47.23 8.44,47.84
  TOP w0.081: v1(16.75,46.24) 17.57,46.24 17.8,46.47 18.16,46.47 18.42,46.73 RT214.1 18.7,46.16 RT152.1 ; v1(8.43,48.19) 8.43,47.85 8.44,47.84
  IN1 w0.064: v1(8.43,48.19) 8.59,48.35 8.97,48.35 9.34,47.98 12.61,47.98 12.9,47.69 12.9,47.25 13.55,46.61 14.92,46.61 15.17,46.86 16.12,46.86 v1(16.75,46.24)
I2C_RT_L_SCL: length 3.1
  IN1 w0.064: v1(10.45,46.92) v2(10.7,46.67)
  IN3 w0.064: v2(10.7,46.67) 10.64,46.73 9.89,46.73 v4(9.53,47.09)
  BOTTOM w0.081: v4(9.53,47.09) 9.77,46.85 10.14,46.85 10.3,47.02 10.3,47.23 RT212.1
I2C_RT_L_SDA: length 3.5
  IN1 w0.064: v2(10.72,46.11) 10.88,46.27 v1(11.1,46.27)
  IN3 w0.064: v4(9.53,46.46) 10.03,46.46 10.37,46.11 v2(10.72,46.11)
  BOTTOM w0.081: v4(9.53,46.46) 9.72,46.65 10.23,46.65 10.51,46.93 10.51,47.24 RT213.1
I2C_RT_R_INT#: length 4.1
  TOP w0.081: RT217.1 RT199.1
  TOP w0.093: RT199.1 275.34,41.6 275.34,41.51 arc(275.35,41.47) 275.37,41.44 275.62,41.19 275.79,41.19 276.25,40.74 276.25,39.48 276.43,39.3 URT2.A10
I2C_RT_R_SCL: length 3.5
  IN1 w0.064: v1(278.32,38.99) v2(278.64,39.31)
  IN3 w0.064: v2(278.64,39.31) 278.42,39.1 278.33,39.1 278.11,39.1 277.72,38.71 277.57,38.71 v4(277.38,38.9)
  BOTTOM w0.076: RT215.1 278.02,39.32 278.02,38.85 277.9,38.72 277.55,38.72 v4(277.38,38.9)
I2C_RT_R_SDA: length 3.9
  IN1 w0.064: v1(278.97,38.34) v2(278.63,38.69)
  IN3 w0.064: v2(278.63,38.69) 278.42,38.91 278.33,38.91 278.19,38.91 277.8,38.52 277.57,38.52 v4(277.38,38.33)
  BOTTOM w0.076: v4(277.38,38.33) 277.46,38.33 277.65,38.52 277.98,38.52 278.23,38.76 278.23,39.3 RT216.1
I2C_SCK_EDP: length 6.9
  TOP w0.081: JEDP1.32 v1(128.5,83.39)
  IN1 w0.064: v1(128.5,83.39) 128.07,82.97 128.07,82.41 127.86,82.2 127.86,80.59 127.09,79.82 127.09,78.82 126.22,77.95 v1(126.21,77.95)
I2C_SDA_EDP: length 5.1
  TOP w0.081: JEDP1.18 134.1,83.09 133.75,82.74 v1(133.75,82.15)
  IN1 w0.064: v1(133.75,82.15) 134.08,81.82 134.08,81.58 134.08,81.58 134.08,81.3 134.45,80.93 134.45,79.87 v1(134.91,79.41)
I_ADP: length 5.5
  TOP w0.081: PR234.2 217.34,66.67 216.08,66.67 215.51,66.1 215.51,65.58 UE1.B11
I_BATT: length 30.5
  TOP w0.081: PR233.2 v1(218.45,68.55)
  IN1 w0.064: v2(218.44,52.81) 218.98,52.81 220.02,53.84 220.02,57.21 219.18,58.05 219.18,59.78 218.65,60.31 218.65,61.71 219.33,62.4 219.33,63.32 219.24,63.41 219.24,64.38 219.12,64.5 219.12,65.67 219.35,65.9 219.35,66.66 219.83,67.14 219.83,67.6 218.88,68.55 v1(218.45,68.55) ; v1(208.76,51.46) 209.01,51.46 209.08,51.52 v2(209.08,51.54)
  IN3 w0.064: v2(209.08,51.54) 209.62,51.54 210.42,52.34 212.49,52.34 213.3,51.52 217.32,51.52 218.44,52.65 v2(218.44,52.81)
I_BATT_R: length 10
  TOP w0.081: UE1.J4 209.18,59.24 v1(209.18,57.7) ; v3(210.62,51.33) 210.62,51.74 209.99,52.37 CE106.1 v1(208.76,52.37)
  IN1 w0.064: v1(209.18,57.7) 209.02,57.53 209.02,52.63 v1(208.76,52.37)
I_SYS: length 155.7
  TOP w0.081: v1(92.64,43.6) v3(92.64,43.09)
  TOP w0.254: PR229.2 v1(87.16,18.6) ; PR1103.1 92.97,43.93 v1(92.64,43.6)
  IN1 w0.064: v1(208.76,53.24) 208.76,53.19 v2(208.5,52.93)
  IN1 w0.254: v2(92.45,44.07) 92.64,43.88 v1(92.64,43.6) 92.64,35.74 93.25,35.13 93.25,23.45 89.69,19.89 87.64,19.89 87.16,19.41 v1(87.16,18.6)
  IN2 w0.051: v2(208.5,52.93) 208.16,52.93 207.67,52.44 205.47,52.44 205.25,52.65 204.04,52.65 203.82,52.44 200.24,52.44 199.9,52.78 196.81,52.78 196.45,53.14 195.54,53.14 195.36,52.96 193.36,52.96 193.03,52.63 191.95,52.63 191.39,52.07 188.92,52.07 188.22,51.37 187.87,51.37 187.31,51.92 176.76,51.92 176.23,51.39 174.12,51.39 171.91,49.18 171.91,49.01 171.61,48.7 169.66,48.7 169.63,48.68 169.36,48.68 169.34,48.7 167.04,48.7 166.16,47.82 164.52,47.82 164.3,47.6 162.7,47.6 162.47,47.82 160.59,47.82 160.11,48.3 160.11,48.84 159.64,49.31 158.99,49.31 158.33,49.97 154.93,49.97 154.24,50.66 139.32,50.66 138.99,50.33 133,50.33 132.87,50.2 129.95,50.2 129.95,50.2 127.31,50.2 127.19,50.32 116.81,50.32 115.48,48.98 104.07,48.98 103.32,48.24 102.07,48.24 99.65,45.81 94.19,45.81 v2(92.45,44.07)
I_SYS_R: length 7.5
  TOP w0.081: RE126.1 CE107.1 210.05,54.15 210.09,54.11 RE159.1 210.41,54.77 209.84,55.35 209.84,59.1 209.92,59.18 UE1.J5
IMON: length 3.8
  TOP w0.081: PR1133.1 102,43.95 v3(101.91,43.86)
  TOP w0.203: PU1100.9 100.85,46.56 101.69,45.72 PC1107.1 PR1133.1
IMVP_SMBCLK: length 141.3
  IN1 w0.064: v1(97.44,53.44) 97.73,53.44 97.81,53.52 97.81,54.04 97.98,54.21 98.35,54.21 v2(98.52,54.38) ; v2(211.9,62.29) v1(211.9,61.96)
  IN2 w0.051: v2(211.9,62.29) 211.9,62.75 211.34,63.3 209.82,63.3 209.33,63.79 208.28,63.79 207.36,62.88 204.69,62.88 203.05,61.25 201,61.25 200.72,61.53 200.3,61.53 200.02,61.25 198.15,61.25 197.45,61.96 194.46,61.96 192.99,63.42 190.1,63.42 189.02,62.34 182.4,62.34 181.77,62.97 178.16,62.97 177.43,63.7 175.84,63.7 175.56,63.43 175.56,63.08 175.19,62.71 171.78,62.71 171.3,62.22 169.95,62.22 169.43,62.74 169.43,64.71 165.77,68.36 164.16,68.36 163.38,69.14 159.02,69.14 158.44,69.72 155.6,69.72 154.41,68.53 152.35,68.53 152.18,68.36 151.31,68.36 151,68.66 149.88,68.66 149.58,68.37 144.07,68.37 143.3,69.14 139.99,69.14 139.49,68.64 134.21,68.64 133.36,69.49 125.73,69.49 125.56,69.66 109.75,69.66 108.63,68.54 105.07,68.54 104.01,67.48 104.01,63 103.33,62.33 98.36,62.33 98.01,61.98 98.01,54.41 98.22,54.2 98.34,54.2 v2(98.52,54.38)
  IN3 w0.064: v2(211.9,62.29) 211.9,61.98 v4(211.93,61.95)
IMVP_SMBCLK_VR: length 4.4
  TOP w0.203: PR1112.2 97.15,52.53 PR1118.1 97.44,52.41 98.27,51.59 98.27,50.09 98.41,49.94 PU1100.18
IMVP_SMBDAT: length 142.5
  IN1 w0.064: v1(211.1,65.16) v2(211.1,64.83) ; v1(98.33,53.44) 98.05,53.44 98,53.49 98,53.96 98.06,54.02 98.35,54.02 v2(98.52,53.85)
  IN2 w0.051: v2(211.1,64.83) 211.1,64.51 211.55,64.05 211.55,63.66 211.37,63.48 209.89,63.48 209.39,63.98 208.21,63.98 207.29,63.05 204.61,63.05 202.98,61.42 201.07,61.42 200.79,61.71 200.23,61.71 199.95,61.43 198.23,61.43 197.52,62.13 194.53,62.13 193.07,63.6 190.03,63.6 188.94,62.51 182.47,62.51 181.84,63.14 178.23,63.14 177.5,63.88 175.76,63.88 175.39,63.5 175.39,63.16 175.11,62.88 171.71,62.88 171.22,62.4 170.02,62.4 169.6,62.81 169.6,64.78 165.85,68.54 164.23,68.54 163.45,69.32 159.09,69.32 158.51,69.9 155.53,69.9 154.34,68.71 152.28,68.71 152.11,68.54 151.38,68.54 151.08,68.84 149.8,68.84 149.5,68.54 144.14,68.54 143.37,69.32 139.91,69.32 139.42,68.82 134.28,68.82 133.44,69.67 125.81,69.67 125.64,69.84 109.68,69.84 108.56,68.72 104.99,68.72 103.83,67.55 103.83,63.08 103.26,62.5 98.28,62.5 97.83,62.05 97.83,54.34 98.15,54.02 98.35,54.02 v2(98.52,53.85)
  IN3 w0.064: v4(211.04,65.31) 211.04,64.88 v2(211.1,64.83)
  BOTTOM w0.081: RE459.1 v4(211.04,65.31)
IMVP_SMBDAT_VR: length 4.3
  TOP w0.203: PR1113.2 98.98,53 98.51,52.53 PR1121.1 98.33,52.04 98.65,51.73 98.65,50.29 98.81,50.13 PU1100.17
IMVP_VR_ON_EC: length 70.2
  TOP w0.081: RE10.1 175.78,19.28 U15.2 178.93,19.28 179.01,19.35 179.01,20.06 179.38,20.43 180.52,20.43 181.2,21.12 189.21,21.12 v3(189.47,20.86) v1(189.95,20.38) ; UE1.N7 211.9,54.94 212.1,54.74 212.1,54.33 v1(212.31,54.11)
  IN1 w0.064: v2(206.54,28.88) 206.73,29.07 206.73,29.53 205.81,30.45 205.81,31.24 205.33,31.72 205.33,37.33 209.52,41.51 211.75,41.51 212.08,41.84 212.08,45.26 211.51,45.83 211.51,49.47 212.15,50.11 212.15,52.91 211.93,53.14 211.93,53.73 v1(212.31,54.11) ; v1(189.95,20.38) 189.99,20.38 190.83,21.22 v2(190.83,22.24)
  IN3 w0.064: v2(206.54,28.88) 206.11,28.45 202.14,28.45 201.97,28.29 196.46,28.29 192.12,23.95 192.12,23.82 191.19,22.89 191.19,22.6 v2(190.83,22.24)

# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MIPI60_CFG_STB0_DN: length 2.2
  IN1 w0.064: v2(134.48,26.56) 134.71,26.79 v1(134.71,26.88)
  IN3 w0.064: v2(134.48,26.56) 134.82,26.9 v4(135,26.9)
  BOTTOM w0.081: v3(134.74,25.94) 135,26.21 v4(135,26.9)
MIPI60_CFG_STB0_DP: length 45.2
  IN1 w0.064: v1(134.71,27.53) 134.42,27.24 v2(134.43,27.24)
  IN2 w0.051: v2(134.43,27.24) 134.42,27.24 134.12,26.94 134.12,25.84 134.25,25.72 134.25,21.91 135.81,20.34 135.81,17.07 130.6,11.86 116.32,11.86 114.18,9.73 114.18,8.83 114.12,8.77 113.59,8.77 113.53,8.71 113.53,8.63 113.59,8.57 114.12,8.57 114.18,8.51 114.18,8.34 114.07,8.23 113.46,8.23 113.38,8.15 v2(113.38,7.4)
  IN3 w0.064: v2(113.38,7.4) 113.58,7.6 113.58,9.17 113.04,9.71 v4(113.04,10.49)
  BOTTOM w0.081: JMIPI60.13 113,10.52 v4(113.04,10.49)
MIPI60_CFG_STB1_DN: length 4.4
  TOP w0.089: v1(135.24,26.55) 135.3,26.55 UC1.Y6
  IN1 w0.064: v1(135.24,26.55) 135.32,26.55 135.48,26.71 135.87,26.71 v2(136,26.58)
  IN3 w0.064: v2(136,26.58) 136,25.61 136.11,25.5 v4(136.11,25.37)
  BOTTOM w0.081: R660.2 135.61,26.33 136.02,25.91 v3(136.02,25.87) 136.11,25.78 136.11,25.37 v4(136.11,25.37)
MIPI60_CFG_STB1_DP: length 45.5
  TOP w0.081: UC1.Y7 135.42,27.32
  TOP w0.089: 135.42,27.32 135.08,26.98 v1(135.08,26.88)
  IN1 w0.064: v2(135.41,27.04) 135.25,26.88 v1(135.08,26.88)
  IN3 w0.064: v4(128.11,19.72) 129.56,21.17 131.51,21.17 131.58,21.24 131.58,22.71 131.66,22.78 131.76,22.78 131.84,22.71 131.84,21.24 131.91,21.17 132.02,21.17 132.09,21.24 132.09,22.71 132.17,22.78 132.27,22.78 132.35,22.71 132.35,22.44 132.41,22.38 132.54,22.38 132.6,22.44 132.6,22.71 132.7,22.81 135.28,22.81 135.34,22.87 135.34,23.04 135.27,23.12 134.09,23.12 134.01,23.19 134.01,23.3 134.09,23.37 135.27,23.37 135.34,23.44 135.34,23.55 135.27,23.62 134.09,23.62 134.01,23.7 134.01,23.8 134.09,23.88 135.27,23.88 135.34,23.95 135.34,24.06 135.27,24.13 134.09,24.13 134.01,24.21 134.01,24.31 134.09,24.39 135.27,24.39 135.34,24.46 135.34,24.57 135.27,24.64 134.09,24.64 134.01,24.71 134.01,24.82 134.09,24.89 135.27,24.89 135.34,24.97 135.34,25.07 135.27,25.15 134.09,25.15 134.01,25.22 134.01,25.33 134.09,25.4 135.27,25.4 135.34,25.48 135.34,25.58 135.27,25.66 134.09,25.66 134.01,25.73 134.01,25.84 134.09,25.91 135.27,25.91 135.34,25.98 135.34,26.56 135.41,26.63 v2(135.41,27.04)
  BOTTOM w0.081: v4(128.11,19.72) v3(128.39,19.43) 129.47,18.35 129.47,15.56 127.35,13.44 125.83,13.44 125.79,13.39 124.62,13.39 124.5,13.28 JMIPI60.59
MIPI60_CPU_JTAG_TCLK: length 50.1
  TOP w0.081: RC145.1 134.08,23.98 133.51,24.55 133.22,24.55 133.06,24.71 133.06,24.89 v1(132.77,25.18)
  IN1 w0.102: v2(132.49,24.54) 132.49,24.74 132.77,25.01 v1(132.77,25.18)
  IN2 w0.051: v2(132.49,24.54) 132.49,24.28 132.73,24.05 132.73,22.9 131.98,22.15 130.48,22.15 130.18,21.85 130.18,20.61 131.63,19.16 131.63,16.98 129.43,14.78 110.21,14.78 110.18,14.81 110.18,15.41 110.12,15.47 110.04,15.47 109.98,15.41 109.98,14.51 109.92,14.45 109.84,14.45 109.78,14.51 109.78,15.41 109.72,15.47 109.63,15.47 109.57,15.41 109.57,14.51 109.51,14.45 109.43,14.45 109.37,14.51 109.37,15.22 107.01,17.58 107.01,17.89 v2(106.84,18.06)
  IN3 w0.064: v4(106.99,17.67) 106.99,17.91 v2(106.84,18.06)
  BOTTOM w0.081: R190.2 107.13,14.54 106.99,14.68 106.99,16.59 106.72,16.86 v6(106.72,17.3) 106.72,17.41 v4(106.99,17.67)
MIPI60_CPU_JTAG_TDI: length 46
  TOP w0.089: v5(130.42,26.37) 130.63,26.16 UC1.K5
  IN2 w0.051: v2(107.84,18.09) 107.84,18.1 107.84,18.59 108.07,18.82 108.63,18.82 109.56,17.89 109.56,17.5 109.75,17.3 110.89,17.3 112.35,18.77 113.82,18.77 116.3,16.29 123.1,16.29 123.16,16.35 123.16,17.19 123.22,17.25 123.3,17.25 123.36,17.19 123.36,16.35 123.42,16.29 123.51,16.29 123.57,16.35 123.57,17.19 123.63,17.25 123.71,17.25 123.77,17.19 123.77,16.35 123.83,16.29 123.91,16.29 123.97,16.35 123.97,17.19 124.03,17.25 124.12,17.25 124.18,17.19 124.18,16.35 124.23,16.29 124.32,16.29 124.38,16.35 124.38,17.19 124.44,17.25 124.52,17.25 124.58,17.19 124.58,16.35 124.64,16.29 124.96,16.29 127.31,18.63 128.14,18.63 129.42,19.91 129.42,23.12 130.64,24.34 130.64,26.15 v5(130.42,26.37)
  IN3 w0.064: v2(107.84,18.09) 107.87,18.07 v4(107.87,17.75)
  BOTTOM w0.081: v4(107.87,17.75) 107.87,17.74 107.87,14.87 108.19,14.55 R191.2 ; RC146.1 130.79,26.73 v5(130.42,26.37) 130.1,26.37 v6(129.79,26.67)
MIPI60_CPU_JTAG_TDO: length 50.7
  TOP w0.081: v1(130.85,25.51) 130.85,25.42 131.11,25.17 131.11,23.39 v5(131.29,23.21) 132.05,22.45 RC150.1
  IN1 w0.064: v1(130.85,25.51) v2(131.19,25.51)
  IN2 w0.051: v2(131.19,25.51) 131.57,25.12 133.07,25.12 133.48,24.71 133.48,21.59 135.05,20.03 135.05,17.38 130.29,12.62 113.85,12.62 109.9,8.67 109.9,5.61 109.08,4.8 v2(108.54,4.8)
  IN3 w0.064: v2(108.54,4.8) 108.87,4.47 v4(108.87,3.11)
  BOTTOM w0.081: v5(131.29,23.21) v6(130.72,23.21)
MIPI60_CPU_JTAG_TMS: length 48.2
  IN1 w0.064: v1(132.77,25.83) v2(132.77,26.16)
  IN2 w0.051: v2(107.53,4.28) 107.71,4.1 108.82,4.1 110.2,5.48 110.2,8.25 114.27,12.32 130.41,12.32 135.35,17.26 135.35,20.15 133.79,21.72 133.79,24.84 132.77,25.86 v2(132.77,26.16)
  IN3 w0.064: v4(107.6,3.11) 107.6,4.21 v2(107.53,4.28) ; v4(132.81,26.73) 132.81,26.21 v2(132.77,26.16)
  BOTTOM w0.081: v4(107.6,3.11) 107.26,2.77 v6(106.59,2.77)
MIPI60_CPU_JTAG_TRST#: length 38
  IN1 w0.064: v2(132.09,23.74) 132.09,23.74 132.09,24.1 v1(132.2,24.2)
  IN2 w0.051: v2(132.09,23.74) 132.27,23.56 132.27,23.09 131.79,22.6 130.29,22.6 129.72,22.04 129.72,20.42 131.17,18.97 131.17,17.17 129.24,15.24 111.38,15.24 109.27,17.35 109.02,17.35 v2(108.74,17.63)
  IN3 w0.064: v2(108.74,17.63) 109.12,17.63 v4(109.15,17.6)
  BOTTOM w0.081: R192.2 109.83,14.93 109.83,17.3 v6(109.69,17.44) 109.53,17.6 v4(109.15,17.6)
MIPI60_DBRESET#: length 2.7
  BOTTOM w0.081: R236.2 111,4.1 JMIPI60.6
MIPI60_DBRESET#_R: length 196.2
  TOP w0.081: v1(189.66,36.33) 188.84,36.33 188.66,36.16 188.66,35.31 188.44,35.09 188.44,34.45 188.23,34.25 186.71,34.25 RC430.1 186.43,33.96 186.71,33.68 187.75,33.68 188.13,33.3 UC29.1
  IN1 w0.064: v1(189.66,36.33) 189.66,36.52 v2(189.54,36.64)
  IN3 w0.064: v4(190.6,51.22) 190.49,51.11 190.49,50.65 190.3,50.46 190.3,49.23 190.65,48.88 190.65,48.44 191.38,47.71 191.38,42.06 189.83,40.51 189.83,36.94 v2(189.54,36.64) ; v4(104.35,7.62) 104.73,7.24 107.52,7.24 110.1,4.67 110.87,4.67 111.41,4.12 v4(111.41,3.11)
  BOTTOM w0.081: v4(104.35,7.62) 103.86,8.11 103.86,18.21 105.01,19.35 105.01,23.54 103.11,25.44 97.83,25.44 96.76,26.51 94.28,26.51 92.49,28.3 92.49,42.31 94.98,44.8 99.94,44.8 103.05,47.92 103.05,55.25 104.58,56.78 107.96,56.78 108.57,57.39 109.64,57.39 110.24,56.78 119.14,56.78 119.79,57.44 120.63,57.44 122.88,55.2 v3(127.03,55.2) 137.29,55.2 138.85,53.63 155.22,53.63 155.65,53.2 163.25,53.2 163.62,53.57 166.59,53.57 168.48,51.68 177.22,51.68 180.84,55.3 186.98,55.3 190.32,51.96 190.68,51.96 190.93,51.71 190.93,51.49 190.66,51.22 v4(190.6,51.22) ; R176.2 C200.2 v4(111.41,3.11)
MIPI60_HOOK2_CPU_BOOT_STALL: length 16.3
  TOP w0.081: v5(114.77,7.88) v3(112.36,10.29) v1(112.36,15.9)
  IN1 w0.064: v2(111.94,15.9) v1(112.36,15.9)
  IN3 w0.064: v4(112.3,15.81) 112.05,15.81 111.95,15.9 v2(111.94,15.9)
  BOTTOM w0.081: v5(114.77,7.88) 114.77,7.68 114.93,7.52 118.92,7.52 119,7.44 JMIPI60.38 ; v4(112.3,15.81) R230.1
MIPI60_MBP0#: length 24.5
  TOP w0.081: v5(128.08,15.61) v3(127.5,15.61)
  IN1 w0.064: v5(128.08,15.61) 128.42,15.28 131.56,15.28 132.73,16.44 132.73,17.57 138.06,22.91 138.06,25.41 136.68,26.79 136.68,26.84 135.89,27.64 135.76,27.64 135.69,27.71 135.68,27.71 135.21,28.18 v1(133.8,28.18)
  BOTTOM w0.081: R195.2 R274.2 127.88,15.81 v5(128.08,15.61)
MIPI60_MBP0#_R: length 4.9
  BOTTOM w0.081: JMIPI60.55 123.5,12.95 124.25,13.7 125.23,13.7 v3(125.24,13.71) 125.95,13.71 R195.1
MIPI60_MBP1#: length 26.4
  IN1 w0.064: v5(128.78,15.7) 129.04,15.44 131.5,15.44 132.56,16.51 132.56,17.64 137.9,22.98 137.9,25.34 136.52,26.72 136.52,26.77 135.82,27.47 135.69,27.47 135.62,27.54 135.61,27.54 135.14,28.02 134.01,28.02 133.8,27.81 v1(133.8,27.53)
  BOTTOM w0.081: v5(128.78,15.7) 128.78,15.71 128.56,15.92 128.38,15.92 128.31,15.99 127.75,15.99 126.88,16.86 125.92,16.86 125.61,16.56 125.61,16.22 R178.2 R194.2
MIPI60_MBP1#_R: length 4.7
  BOTTOM w0.081: JMIPI60.53 123,13.09 123.22,13.31 123.34,13.31 v3(123.74,13.71) 123.82,13.79 124.08,13.79 124.18,13.89 124.86,13.89 125.18,14.21 125.68,14.21 R194.1
MIPI60_OVERRIDE#: length 68.5
  TOP w0.081: v1(111.01,18.35) 111.01,11.44 110.4,10.83 110.4,6.64 v1(110.87,6.17)
  IN1 w0.064: v1(111.01,18.35) 111.01,18.4 111.09,18.48 v2(111.09,18.79) ; v1(155.41,17.52) 154.9,18.03 151.71,18.03 150.84,17.16 141.95,17.16 140.83,16.04 139.33,16.04 136.51,13.23 136.51,12.92 136.21,12.63 135.42,12.63 132.79,9.99 128.8,9.99 123.09,4.28 120.93,4.28 119.07,6.13 110.9,6.13 v1(110.87,6.17)
  IN3 w0.064: v2(111.09,18.79) 111.09,18.55 v4(111.01,18.46)
  BOTTOM w0.081: R335.1 R410.2 111.16,16.19 v3(111.16,17.31) 111.16,18.31 v4(111.01,18.46)
MIPI60_PCH_JTAG_TCLK: length 42.6
  IN1 w0.064: v2(133.21,26.5) 133.21,26.27 v1(133.33,26.16) 133.33,25.83 133.41,25.75 133.68,25.75 133.74,25.82 133.74,26.38 133.81,26.44 134.03,26.44 134.14,26.55 134.14,26.91 133.92,27.13 133.92,27.28 134.06,27.42 134.06,27.79 134.12,27.85 135.07,27.85 135.17,27.75 135.17,27.44 135.24,27.38 135.55,27.38 135.62,27.31 135.75,27.31 135.86,27.2 135.86,26.98 135.92,26.92 136.14,26.92 136.35,26.71 136.35,26.66 137.5,25.51 137.5,25.21 137.57,25.14 137.67,25.14 137.73,25.08 137.73,24.96 137.66,24.88 137.58,24.88 137.5,24.81 137.5,24.7 137.58,24.63 137.66,24.63 137.73,24.56 137.73,24.33 137.66,24.26 137.59,24.26 137.52,24.19 137.52,24.08 137.59,24.01 137.66,24.01 137.73,23.93 137.73,23.83 137.66,23.75 137.59,23.75 137.52,23.68 137.52,23.57 137.59,23.5 137.66,23.5 137.73,23.42 137.73,23.15 137.67,23.09 137.57,23.09 137.5,23.02 137.5,22.81 132.4,17.71 132.4,17.54 132.33,17.48 131.89,17.48 131.83,17.41 131.83,17.25 131.89,17.19 132.31,17.19 132.4,17.1 132.4,16.58 131.95,16.13 131.81,16.13 131.74,16.19 131.74,16.36 131.69,16.41 131.53,16.41 131.46,16.35 131.46,15.67 131.4,15.61 131.23,15.61 131.16,15.68 131.16,16.78 131.09,16.86 130.98,16.86 130.91,16.78 130.91,15.68 130.83,15.61 130.67,15.61 130.59,15.68 130.59,16.81 130.52,16.89 130.41,16.89 130.34,16.81 130.34,15.68 130.26,15.61 130.1,15.61 130.02,15.68 130.02,17.05 130.07,17.09 130.22,17.09 130.28,17.16 130.28,17.46 130.2,17.54 129.84,17.54 129.77,17.47 129.77,15.72 129.71,15.65 129.55,15.65 129.48,15.72 129.48,15.97 129.42,16.04 129.02,16.04 v5(128.8,16.26)
  IN3 w0.064: v2(133.21,26.5) 133.44,26.73 v4(133.45,26.73)
  BOTTOM w0.081: v5(128.8,16.26) 128.64,16.1 128.46,16.1 128.14,16.42 128.02,16.42 127.86,16.26 127.74,16.26 127.6,16.4 127.6,16.54 127.74,16.68 v3(127.74,16.82) 127.65,16.91 127.51,16.91 127.37,16.77 127.23,16.77 126.95,17.05 125.84,17.05 125.43,16.63 125.43,16.03 125.51,15.95 125.62,15.95 125.7,15.87 125.7,15.21 125.62,15.12 R193.2
MIPI60_PCH_JTAG_TDI: length 41.9
  TOP w0.081: 130.85,23.6 130.85,23.31 130.91,23.26 CC736.1 RC151.1 ; v1(108,17.68) 107.79,17.88 v3(107.79,18.02)
  TOP w0.089: 130.85,23.6 v1(130.85,24.2)
  IN1 w0.064: v1(108,17.68) 108,17.7 108.16,17.86 v2(108.3,17.86) ; v1(130.85,24.2) v2(130.85,23.87)
  IN2 w0.051: v2(130.85,23.87) 131.26,24.28 132.07,24.28 132.42,23.92 132.42,23.02 131.85,22.45 130.35,22.45 129.88,21.98 129.88,20.48 131.32,19.04 131.32,17.11 129.3,15.09 111.32,15.09 109.42,16.99 108.74,16.99 108.3,17.44 v2(108.3,17.86)
  IN3 w0.064: v4(108.14,17.52) 108.3,17.68 v2(108.3,17.86)
  BOTTOM w0.081: v4(108.14,17.52) 108.14,16.77 108.19,16.73 R312.2
MIPI60_PCH_JTAG_TDO: length 49
  TOP w0.081: 130.39,23.6 130.39,23.33 130.33,23.28 CC735.1 RC202.1
  TOP w0.089: v1(130.85,24.85) 130.39,24.39 130.39,23.6
  IN1 w0.064: v1(130.85,24.85) v2(131.19,24.85)
  IN2 w0.051: v2(108.95,5.13) 109.74,5.92 109.74,8.73 113.79,12.78 130.22,12.78 134.89,17.45 134.89,19.96 133.33,21.53 133.33,24.65 133.01,24.97 131.3,24.97 v2(131.19,24.85)
  IN3 w0.064: v2(108.95,5.13) 109.5,4.57 109.5,3.11 v4(109.51,3.11)
MIPI60_PCH_JTAG_TMS: length 49.8
  TOP w0.081: RC203.1 133.32,23.4 132.64,24.08 132.64,24.89 132.2,25.33 v1(132.2,25.51)
  IN1 w0.064: v1(132.2,25.51) 132.2,25.75 v2(132.34,25.88)
  IN2 w0.051: v2(108.17,4.45) 108.37,4.25 108.75,4.25 110.05,5.55 110.05,8.61 113.91,12.47 130.35,12.47 135.2,17.32 135.2,20.09 133.64,21.65 133.64,24.77 132.85,25.56 132.62,25.56 132.34,25.85 v2(132.34,25.88)
  IN3 w0.064: v2(108.17,4.45) 108.17,3.17 v4(108.24,3.11)
MIPI60_PCH_JTAG_TRST#: length 36.4
  TOP w0.089: UC1.N5 132.17,26.16 v5(131.8,25.78)
  IN2 w0.051: v2(108.86,18.12) 108.88,18.12 109.28,17.71 109.28,17.56 109.69,17.15 110.95,17.15 112.42,18.62 113.76,18.62 116.24,16.13 125.03,16.13 127.37,18.48 128.2,18.48 129.57,19.85 129.57,23.06 130.79,24.28 130.79,25.77 131.01,25.98 131.59,25.98 v5(131.8,25.78)
  IN3 w0.064: v4(109.38,18.02) 109.35,18.05 108.95,18.05 108.88,18.12 v2(108.86,18.12)
  BOTTOM w0.081: RC201.1 132.18,26.16 v5(131.8,25.78) ; R213.2 110.22,17.55 109.75,18.02 v4(109.38,18.02)
MIPI60_PCH_JTAGX: length 44
  TOP w0.081: RC344.1 132.68,23.53 132.46,23.76 132.46,24.71 132.31,24.85 v1(132.2,24.85)
  IN1 w0.064: v2(131.95,24.64) 131.99,24.64 v1(132.2,24.85)
  IN2 w0.051: v2(131.95,24.64) 131.95,24.61 132.57,23.99 132.57,22.96 131.91,22.3 130.42,22.3 130.03,21.91 130.03,20.55 131.48,19.1 131.48,17.04 129.37,14.94 111.25,14.94 109.35,16.84 107.96,16.84 107.34,17.46 v2(107.34,17.98)
  IN3 w0.064: v4(107.34,17.65) v2(107.34,17.98) ; v2(131.95,24.64) 132.14,24.83 v4(132.14,25.18)
  BOTTOM w0.081: v3(107.73,18.96) 107.6,18.84 107.6,18.14 107.34,17.87 v4(107.34,17.65) 107.34,16.4 R244.2
MIPI60_PRDY#: length 42.7
  IN1 w0.064: v1(132.6,26.79) 132.38,26.57 v2(132.36,26.57)
  IN2 w0.051: v2(112.5,9) 112.52,9 115.69,12.17 130.48,12.17 135.5,17.19 135.5,20.22 133.94,21.78 133.94,25.59 133.81,25.72 133.81,27.4 133.71,27.51 132.94,27.51 132.36,26.92 v2(132.36,26.57)
  IN3 w0.064: v2(112.5,9) 112.5,9.02 v4(112.5,10.51)
  BOTTOM w0.081: JMIPI60.11 v4(112.5,10.51)
MIPI60_PREQ#: length 46.4
  TOP w0.081: v5(111.79,7.78) v3(111.79,8.29)
  IN1 w0.064: v1(131.95,26.79) v2(131.95,27.12)
  IN2 w0.051: v5(111.79,7.78) 112.62,8.61 112.63,8.61 116.03,12.02 130.54,12.02 135.66,17.13 135.66,20.28 134.09,21.84 134.09,25.65 133.97,25.78 133.97,27.46 133.77,27.66 133.64,27.66 132.87,27.66 132.33,27.12 v2(131.95,27.12)
  BOTTOM w0.081: v5(111.79,7.78) 111.86,7.78 112,7.64 JMIPI60.10 112,4.91 112.32,4.59 112.32,4.05 R112.2
MIPI60_PRESENT1#: length 4.4
  BOTTOM w0.081: R188.2 111.73,13.71 v3(111.75,13.71) 112.16,13.31 113.42,13.31 113.5,13.23 JMIPI60.15
MIPI60_PRESENT2#: length 4.3
  BOTTOM w0.081: R335.2 112.36,13.71 v3(113.25,13.71) 113.53,13.71 114,13.25 JMIPI60.17
MIPI60_SPI0_IO2: length 111.7
  IN2 w0.051: v2(110.5,18.29) 110.52,18.29 110.76,18.53 110.76,18.98 109.36,20.38 108.68,20.38 100.32,28.74 100.32,30.45 100.82,30.95 100.82,33.31 101.23,33.72 101.23,36.47 102.47,37.72 102.47,38.95 101.47,39.95 101.47,41.95 102.79,43.27 v2(103.3,43.27) ; v2(106.39,47.99) 106.41,48.02 115.66,48.02 117.15,49.51 125.24,49.51 125.92,48.82 143.85,48.82 144.05,48.62 146.56,48.62 147.65,49.71 152.87,49.71 153.84,48.75 156.65,48.75 157.07,49.16 158,49.16 158.49,48.67 158.49,47.88 159.3,47.07 v2(159.35,47.07)
  IN3 w0.064: v4(159.93,46.33) 159.93,46.49 v2(159.35,47.07) ; v2(103.3,43.27) 103.64,43.6 103.64,45.03 106.39,47.78 v2(106.39,47.99) ; v2(110.5,18.29) 110.51,18.27 110.59,18.27 v4(110.85,18.01)
  BOTTOM w0.081: v4(159.93,46.33) 160.2,46.05 162.25,46.05 162.75,46.55 168.89,46.55 169.56,45.87 169.91,45.87 v6(170.09,45.69) 170.09,45.44 169.45,44.8 169.42,44.8 RH634.1 ; v4(110.85,18.01) 110.74,17.9 110.74,17.59 110.65,17.5 110.65,16.23 110.9,15.98 R188.1
MIPI60_SPI0_MOSI: length 159
  IN3 w0.064: 170.52,47.6 170.71,47.79 v4(170.71,49.41) ; v4(104.65,8.29) 104.67,8.31 107.91,8.31 110.61,5.61 112,5.61 112.52,5.08 115.89,5.08 116.49,4.48 v4(116.49,3.11)
  IN3 w0.081: 170.52,47.6 169.17,47.6 167.93,46.35 167.93,46.2 167.58,45.86 v4(167.1,45.86)
  BOTTOM w0.081: v4(116.49,3.11) R261.2 ; v4(170.71,49.41) 170.48,49.64 169.38,49.64 168.82,50.2 168.82,50.78 166.39,53.21 163.77,53.21 163.4,52.84 155.5,52.84 155.07,53.27 138.7,53.27 137.39,54.58 128.52,54.58 127.83,53.9 126.89,53.9 126.21,54.58 v3(124.05,54.58) 122.97,54.58 120.49,57.06 120.05,57.06 119.4,56.42 110.06,56.42 109.47,57.01 108.74,57.01 108.15,56.42 104.73,56.42 103.42,55.1 103.42,47.77 100.09,44.44 95.13,44.44 92.85,42.16 92.85,28.45 94.43,26.87 96.91,26.87 97.98,25.8 103.26,25.8 105.37,23.69 105.37,19.2 104.23,18.06 104.23,8.71 v4(104.65,8.29)
MIPI60_TCLK: length 6.2
  BOTTOM w0.081: JMIPI60.3 110.5,13.01 110.21,13.31 108.43,13.31 v3(108.11,13.63) 107.74,14 107.74,14.75 107.36,15.12 R190.1 R244.1
MIPI60_TCLK1: length 4.5
  BOTTOM w0.081: R193.1 124.85,14.13 124.15,14.13 124.03,14.01 123.53,14.01 123.28,13.77 123.17,13.77 122.5,13.1 JMIPI60.51
MIPI60_TDI: length 5.7
  BOTTOM w0.081: R312.1 R191.1 108.19,15.11 108.51,14.79 108.51,14.18 109.06,13.63 v3(109.38,13.63) 110.33,13.63 111,12.95 JMIPI60.5
MIPI60_TDO: length 3.6
  BOTTOM w0.081: JMIPI60.4 110.5,4.77 v3(110.26,4.52) 109.51,3.77 R156.1 R201.1
MIPI60_TMS: length 4.3
  BOTTOM w0.081: R300.1 R247.1 108.3,3.69 108.63,4.03 109.18,4.03 110,4.85 JMIPI60.2
MIPI60_TRST#: length 4.6
  BOTTOM w0.081: R213.1 R192.1 110.58,14.76 110.58,14.29 111.61,13.26 111.62,13.26 112,12.88 JMIPI60.9
MONO_IN: length 4.8
  TOP w0.203: v1(28.61,19.91) 28.54,19.85 UA1.34
  IN1 w0.064: v1(25.03,20.55) 25.36,20.88 27.64,20.88 v1(28.61,19.91)
MSCLK: length 119.3
  TOP w0.081: v1(215.55,60.62) 215.32,60.62 215.24,60.7 214.96,60.7 214.62,60.36 UE1.H10 ; RE201.2 v1(226.82,9.7)
  IN1 w0.064: v1(215.55,60.62) 215.66,60.73 215.83,60.73 216.5,61.4 216.5,64.11 214.88,65.73 214.88,66.67 214.4,67.15 214.4,68.68 214.71,68.98 217.18,68.98 v2(217.95,68.21) ; v1(230.8,5.81) 230.09,6.53 v2(230.09,8.33) 229.08,8.33 228.25,9.16 227.36,9.16 v1(226.82,9.7)
  IN2 w0.051: v2(230.09,8.33) 230.09,8.36 229.97,8.48 229.96,8.48 220.17,18.27 219.73,18.27 218.85,19.15 218.85,24.88 218.61,25.12 218.61,27.6 219.61,28.59 219.61,36.55 218.34,37.82 217.46,37.82 216.63,38.64 216.63,40.46 v2(217.74,41.57)
  IN3 w0.064: v4(197.58,62.65) 197.59,62.66 200.42,62.66 202.24,64.49 203.39,64.49 204.24,65.33 206.22,65.33 207.98,67.09 208.74,67.09 209,66.84 210.29,66.84 210.63,67.17 213.81,67.17 215.11,68.48 217.69,68.48 v2(217.95,68.21) 220.31,65.85 220.31,63.65 221.46,62.51 221.46,47.5 218.22,44.27 218.22,43.06 217.74,42.57 v2(217.74,41.57)
  BOTTOM w0.081: v4(197.58,62.65) v3(197.58,63.67) 196.69,64.55 196.12,64.55 195.99,64.43 UW2.2
MSDATA: length 109.2
  TOP w0.081: v1(229.65,9.83) RE205.1
  IN1 w0.064: v2(213.67,67.73) 213.67,66.84 214.02,66.49 214.02,64.74 213.77,64.49 213.77,63.89 214.02,63.65 214.02,63.1 214.09,63.03 214.09,62.26 213.93,62.1 213.93,61.59 v1(213.5,61.16) ; v1(230.8,6.31) 230.9,6.41 230.92,6.41 231.43,6.92 231.43,8.07 231.22,8.29 231.07,8.44 231.07,8.58 230.27,9.38 v2(230.1,9.38) v1(229.65,9.83)
  IN2 w0.051: v2(230.1,9.38) 229.57,9.38 220.32,18.63 219.88,18.63 219.21,19.3 219.21,25.03 218.97,25.27 218.97,27.45 219.96,28.44 219.96,36.69 218.48,38.17 217.6,38.17 216.99,38.79 216.99,40.08 v2(217.77,40.87)
  IN3 w0.064: v2(217.77,40.87) 218.1,41.2 218.1,42.41 218.59,42.9 218.59,44.11 221.82,47.35 221.82,65.44 218.42,68.85 214.78,68.85 v2(213.67,67.73) 213.47,67.54 210.48,67.54 210.14,67.2 209.15,67.2 208.9,67.46 207.83,67.46 206.07,65.7 204.08,65.7 203.24,64.85 202.09,64.85 200.27,63.03 v4(197.96,63.03)
  BOTTOM w0.081: v4(197.96,63.03) 197.96,61.89 v3(197.68,61.6) 196.88,60.81 196.88,59.98
  BOTTOM w0.089: RW45.1 196.88,59.98
MUX_L_ENA_R: length 1.5
  TOP w0.081: UM1.16 12.67,55.89 RM2.2
MUX_L_ENB_R: length 2.7
  TOP w0.081: UM1.10 17.79,55.89 18.13,56.23 v3(18.44,56.23) 18.69,56.23 19.27,55.65 RM1.2
MUX_L_FLIP#: length 71.2
  TOP w0.081: v1(12.61,27.44) 12.35,27.18 12.35,26.91 12.67,26.59 12.67,26.58 12.69,26.56 RPD128.1 RPD129.1 13.74,27.11 14.49,27.11 RPD127.1 ; RM13.1 14.37,58.91 v1(14.05,58.91) ; RM14.1 17.6,58.39 17.69,58.31 17.69,57.57 19.03,56.22 19.13,56.22 19.97,55.38 19.97,53 v5(20.23,52.74)
  IN1 w0.064: v1(12.61,27.44) 11.94,27.44 10.61,26.11 8.86,26.11 v2(8.55,26.41) ; v1(14.05,58.91) 13.84,58.7 v2(13.84,58.62)
  IN3 w0.064: v2(8.55,26.41) 8,26.41 7.3,27.11 7.3,37.72 7.27,37.86 7.27,38.42 5.5,40.19 5.5,42.5 5.5,42.72 5.5,42.72 5.5,43.54 3.47,45.57 3.47,47.22 4.32,48.07 4.32,49.89 7.17,52.74 v4(9.24,52.74) 9.94,53.44 9.94,53.93 12.12,56.11 13.05,56.11 14.19,57.25 14.19,58.27 v2(13.84,58.62)
  BOTTOM w0.081: v4(9.24,52.74) 9.88,52.11 19.59,52.11 v5(20.23,52.74) v3(22.51,52.74)
MUX_L_FLIP#_R: length 2.6
  TOP w0.081: RPD127.2 14.92,26.68 14.92,26.29 14.88,26.25 14.88,26.11 15.48,25.51 15.48,24.91 15.1,24.53
MUX_L_SAI: length 1.3
  TOP w0.081: RM13.2 14.89,57.5 15.19,57.21 UM1.14
MUX_L_SBI: length 2.1
  TOP w0.081: UM1.12 15.99,57.62 RM14.2
MUX_R_ENA_R: length 3.7
  TOP w0.081: UM2.16 272.09,54.86 271.5,54.27 v3(270.23,54.27) 270.01,54.48 RM18.2
MUX_R_ENB_R: length 3.8
  TOP w0.081: UM2.10 272.09,59.07 272.01,59.16 271.69,59.16 271.18,58.65 270.26,58.65 RM17.2 v3(270.01,59.87)
MUX_R_FLIP#: length 88.1
  TOP w0.081: v1(269.42,57.63) 269.16,57.63 269.08,57.55 269.08,56.44 269.16,56.36 RM15.1 ; v5(286.89,15.25) 286.94,15.25 RPD135.1 RPD136.1 RPD137.1
  IN1 w0.064: v1(269.42,57.63) v2(269.09,57.63)
  IN2 w0.051: v2(261.21,15.34) 261.74,15.87 261.74,21.81 265.56,25.63 268.94,25.63 272,28.69 272,37.15 272.26,37.41 272.26,40.61 272.96,41.31 273.53,41.31 274.29,42.07 274.29,44.54 273.53,45.29 273.53,53.19 v2(269.09,57.63)
  IN3 w0.064: v4(261.65,15.28) 261.27,15.28 v2(261.21,15.34)
  BOTTOM w0.081: v5(286.89,15.25) 286.89,16.5 v3(285.04,18.35) 284.58,18.81 273.15,18.81 271.99,19.98 270.99,19.98 267.88,16.86 267.88,15.47 267.62,15.21 264.78,15.21 264.13,15.86 262.24,15.86 v4(261.65,15.28)
MUX_R_FLIP#_R: length 1.7
  TOP w0.081: UPD2.41 286.41,15.75 286.49,15.84 286.61,15.84 286.62,15.85 RPD135.2
MUX_R_SAI: length 1.5
  TOP w0.081: UM2.14 270.37,56.72 RM15.2
MUX_R_SBI: length 1.4
  TOP w0.081: RM16.2 270.12,57.52 UM2.12
NB_LID#: length 101.2
  TOP w0.081: v3(214.47,46.39) 214.47,46.56 v1(214.09,46.94) 214,47.03 212.34,47.03 DE5.1 DE1.1 211.07,47.66 210.57,48.16 210.57,50.21 211.25,50.9 UE6.2 ; JIO1.43 256.25,6.9 v5(255.87,7.28) ; v1(216.69,46.2) 216.72,46.2 216.91,46.01 DE3.1
  IN1 w0.064: v2(209.46,28.3) 209.96,28.8 209.96,32 208.14,33.82 208.14,37.96 210.16,39.98 212.34,39.98 213.65,41.29 213.65,44.36 213.96,44.68 213.96,46.81 v1(214.09,46.94) 215.42,46.94 216.05,46.32 216.58,46.32 v1(216.69,46.2)
  IN2 w0.051: v5(255.87,7.28) 255.51,7.64 253.62,7.64 252.24,9.03 248.45,9.03 247.4,7.97 233.88,7.97 232.5,6.59 231.84,6.59 231.52,6.27 228.51,6.27 221.51,13.27 218.6,13.27 215.82,16.05 215.82,16.61 212.02,20.41 212.02,21.88 212.49,22.35 212.49,23.63 211.21,24.92 211.21,26.55 v2(209.46,28.3)
NB_LID#_FPR: length 4.7
  TOP w0.081: R808.1 62.35,15.53 v3(59.17,15.53) 59.03,15.53 58.7,15.85 JFP1.3
NB_MODE#: length 81.6
  TOP w0.081: UE1.J6 210.69,59.35 v1(210.67,59.36) ; RH610.2 176.56,41.34 v1(176.09,41.34) 175.91,41.34 175.46,40.9 174.65,40.9 174.54,40.94 174.34,40.94 174.2,40.9 173.07,40.9 UC1.DT36
  IN1 w0.064: v1(176.09,41.34) 176.17,41.25 v2(176.56,41.25) ; v2(210.78,59.69) 210.67,59.59 v1(210.67,59.36)
  IN2 w0.051: v2(176.56,41.25) 176.68,41.38 178.26,41.38 178.56,41.08 180.12,41.08 180.48,40.72 183.56,40.72 185.31,38.97 186.18,38.97 189.4,35.76 189.85,35.76 191.66,33.95 v2(192.69,33.95)
  IN3 w0.064: v2(210.78,59.69) 210.82,59.64 213.7,59.64 214.22,59.13 214.22,58.29 214.58,57.93 215.58,57.93 217,59.36 217.62,59.36 218.07,58.91 218.47,58.91 218.61,58.76 218.61,55.55 216.77,53.71 213.38,53.71 213.27,53.82 206.41,53.82 205.77,53.19 205.77,52.55 204.54,51.32 201.12,51.32 200.62,50.82 198.74,50.82 198.57,50.65 197.72,50.65 196.34,49.26 195.65,49.26 194.88,48.49 194.88,35.86 194.23,35.21 193.96,35.21 v2(192.69,33.95)
NB_MUTE#: length 267.2
  TOP w0.081: v1(27.21,13.31) 27.21,12.55 27.59,12.17 DA10.1 27.59,11.02 28.19,10.43 RA66.2 ; v5(209.61,66.45) 209.5,66.33 UE1.A4
  IN1 w0.064: v1(27.21,13.31) 27.34,13.18 31.95,13.18 33.95,15.17 35.29,15.17 36.37,14.09 40.34,14.09 41.16,14.91 47.74,14.91 49.98,17.15 50.86,17.15 52.47,15.54 59.83,15.54 63.02,12.35 65.49,12.35 65.84,12.69 68.31,12.69 70.57,10.43 72.59,10.43 73.75,9.27 76.38,9.27 78.93,6.72 86.69,6.72 88.68,8.7 88.68,9.52 88.26,9.94 88.13,9.94 87.92,10.14 87.09,10.14 86.29,9.35 85.33,9.35 v2(84.91,9.77)
  IN2 w0.051: v5(209.61,66.45) 208.76,66.45 207.53,65.21 206.84,65.21 206.29,64.67 205.29,64.67 203.23,62.61 198.22,62.61 197.87,62.97 194.88,62.97 194.5,63.35 193.98,63.87 193.58,64.26 189.51,64.26 189.23,63.97 178.34,63.97 177.65,64.66 175.57,64.66 175.13,64.22 172.4,64.22 167.4,69.22 166.48,69.22 164.32,71.39 160.42,71.39 159.59,70.56 155.17,70.56 154.12,69.5 149.49,69.5 149.19,69.2 144.42,69.2 143.6,70.02 138.95,70.02 138.41,69.48 136.44,69.48 135.59,70.33 126.14,70.33 125.97,70.5 109.15,70.5 108.03,69.38 104.69,69.38 103.15,67.84 103.15,63.86 102.51,63.22 97.99,63.22 97.17,62.4 97.17,50.84 96.84,50.51 90.65,50.51 88.58,48.44 88.58,22.4 86.33,20.15 86.33,11.19 v2(84.91,9.77)
  BOTTOM w0.081: v5(209.61,66.45) 209.78,66.28 210.17,66.28 v3(210.51,65.94)
NRB_BIT: length 3.2
  TOP w0.081: RH621.1 157.07,49.58 157.32,49.33 157.32,48.29 158.05,47.56 UC1.CF48
PANEL_BKEN_EC: length 63.6
  TOP w0.081: D2.2 189.72,38.92 v3(189.72,37.26) 189.72,36.82 189.95,36.6 189.95,34.2 190.18,33.97 190.18,32.08 190.35,31.9 192.74,31.9 v1(192.82,31.98)
  IN1 w0.064: v1(213.5,59.56) 213.55,59.56 213.86,59.26 213.86,58.71 213.58,58.44 213.58,58.16 213.76,57.99 213.76,57.98 213.83,57.91 213.83,57.13 212.95,56.24 212.95,55.5 213.2,55.24 213.2,54.55 212.15,53.49 212.15,53.15 212.32,52.98 212.32,50.04 211.68,49.4 211.68,45.9 212.24,45.33 212.24,41.77 211.82,41.35 209.59,41.35 205.49,37.26 205.49,31.94 207.76,29.67 v2(207.76,29.57) ; v2(192.82,31.63) 192.82,31.64 v1(192.82,31.98)
  IN2 w0.051: v2(192.82,31.63) 192.98,31.47 193.55,31.47 193.7,31.63 196.88,31.63 197.73,30.77 203.22,30.77 204.23,29.77 206.35,29.77 206.7,29.41 207.36,29.41 207.52,29.57 v2(207.76,29.57)
PANEL_BKLEN: length 29.8
  TOP w0.081: D2.3 188.74,40.6 188.56,40.42 188.56,39.25 189.4,38.41 189.4,37.9 188.48,36.97 188.48,35.39 188.37,35.28 185.83,35.28 185.77,35.34 v3(185.39,35.34) 185.39,35.28 184.79,34.68 183.65,34.68 183.57,34.6 183.57,33.69 183.74,33.52 v1(183.79,33.52) 183.95,33.69 184.6,33.69 RH732.2 ; UC1.DL19 170.68,32.76 171,32.44 171,32.11 v1(171.1,32.01)
  IN1 w0.064: v1(171.1,32.01) 171.2,31.91 172.34,31.91 173.32,32.89 179.22,32.89 180.35,34.02 183.1,34.02 183.61,33.51 183.78,33.51 183.78,33.52 v1(183.79,33.52)
PANEL_MONITOR: length 134.8
  IN1 w0.064: v2(219.64,69.4) 221.2,67.84 v2(221.2,65) ; v1(212.7,57.16) v2(212.46,56.92)
  IN2 w0.051: v2(221.2,65) 221.08,65.12 219.35,65.12 218.5,64.27 218.5,63.47 217.3,62.28 217.3,60.22 215.79,58.71 214.45,58.71 213.6,57.86 213.28,57.86 212.46,57.04 v2(212.46,56.92)
  IN3 w0.064: v2(219.64,69.4) 219.64,69.73 218.54,70.84 213.27,70.84 211.2,72.91 204.56,72.91 203.56,71.91 203.56,69.96 202.88,69.28 199.8,69.28 199.11,68.58 197.55,68.58 197.45,68.49 196.76,68.49 195.62,67.36 190.24,67.36 189.5,68.1 178.93,68.1 177.97,69.06 176.02,69.06 175.56,69.53 175.56,70.24 170.75,75.04 170.75,77.9 167.26,81.39 159.11,81.39 157.91,80.19 154.32,80.19 152.9,78.76 152.9,77.85 152.32,77.27 152.32,74.99 151.57,74.24 145.44,74.24 144.47,75.21 144.47,78.29 144.23,78.53 137.32,78.53 136.94,78.15 134.07,78.15 133.69,78.53 129.82,78.53 129.53,78.24 129.53,77.79 128.87,77.13 128.43,77.13 v4(128.15,77.4)
  BOTTOM w0.081: v4(128.15,77.4) 128.15,76.41 v3(128.35,76.21)
PANEL_PWRGD: length 1.3
  BOTTOM w0.081: QV21.1 128.65,79.68 v3(128.28,80.05)
  vias: v4(124.59,78.29) v4(124.59,77.91) v4(128.15,77.99) v4(128.72,77.99)
PBAT_CHARGER_SMBCLK: length 269.3
  TOP w0.081: PR214.1 83.6,12.28 83.6,11.49 83.41,11.3 83.41,7.74 83.07,7.4 v7(82.7,7.4) 82.37,7.4 81.52,6.55 81.52,5.61 83.8,3.33 83.8,3 v5(83.96,2.84) ; v1(42.55,9.87) 42.54,9.87 42.35,10.06 PD100.2 ; UE1.N2 207.9,56.47 207.81,56.55 207.62,56.55 207.54,56.47 207.54,56.19 207.74,55.98 207.95,55.98 208.03,55.9 208.03,55.76 206.82,54.55 206.82,54.33 v1(206.6,54.11)
  IN1 w0.064: v1(42.55,9.87) 42.94,10.27 43.9,10.27 45.87,8.29 53.69,8.29 58.14,3.85 60.42,3.85 61.79,5.21 68.29,5.21 68.84,5.76 71.61,5.76 75.11,2.26 81.55,2.26 82.74,3.45 83.55,3.45 83.75,3.25 83.75,3.05 v5(83.96,2.84) 83.72,2.6 83.72,2.4 83.87,2.26 87.55,2.26 89.19,3.9 91.1,3.9 92.55,2.45 109.13,2.45 109.63,1.94 111.28,1.94 111.86,2.51 111.86,4.04 113.04,5.22 117.82,5.22 120.3,2.74 126.37,2.74 128.56,4.93 132.43,4.93 134.37,2.99 159.26,2.99 159.8,2.45 206.85,2.45 210.26,5.85 210.26,11.06 211.4,12.2 211.4,13.97 212.47,15.04 212.47,16.31 212.19,16.59 211.62,16.59 210.34,17.87 199.23,17.87 197.6,19.49 197.6,26.12 196.84,26.88 196.84,30.01 197.78,30.96 197.78,36.71 197.06,37.43 197.06,44.49 198.2,45.63 198.2,46.03 198.2,46.41 198.2,46.41 198.2,46.57 199.92,48.28 200.07,48.28 201.5,48.28 201.67,48.45 204.3,48.45 206.23,50.38 206.23,52.29 206.82,52.89 206.82,53.89 v1(206.6,54.11)
PBAT_CHARGER_SMBDAT: length 268.9
  TOP w0.081: PD100.3 43.35,10.14 43.22,10.01 v1(43.21,10.01) 43.21,9.95 PR108.2 ; v1(207.23,54.11) 207.02,54.32 207.02,54.46 208.24,55.67 208.24,56.98 208.41,57.16 UE1.M3 ; v5(83.38,2.84) 83.59,3.05 83.59,3.25 81.31,5.52 81.31,6.64 82.29,7.61 82.98,7.61 83.2,7.83 v7(83.2,10.24) 83.2,11.39 83.39,11.58 83.39,12.23 PR213.1
  IN1 w0.064: v1(207.23,54.11) 207.01,53.89 207.01,52.81 206.42,52.22 206.42,50.3 204.38,48.26 201.75,48.26 201.58,48.09 199.99,48.09 198.39,46.49 198.39,46.11 198.39,45.55 197.25,44.41 197.25,37.51 197.97,36.79 197.97,30.88 197.03,29.94 197.03,26.96 197.79,26.2 197.79,19.57 199.31,18.06 210.42,18.06 211.7,16.78 212.27,16.78 212.66,16.39 212.66,14.96 211.59,13.89 211.59,12.12 210.45,10.98 210.45,5.77 206.93,2.26 159.72,2.26 159.18,2.8 134.29,2.8 132.35,4.74 128.64,4.74 126.44,2.54 120.22,2.54 117.74,5.03 113.12,5.03 112.05,3.96 112.05,2.43 111.36,1.75 109.55,1.75 109.05,2.26 92.47,2.26 91.02,3.71 89.27,3.71 87.63,2.07 83.79,2.07 83.53,2.32 83.53,2.68 v5(83.38,2.84) 83.56,3.02 83.56,3.17 83.47,3.26 82.82,3.26 81.63,2.07 75.03,2.07 71.53,5.57 68.91,5.57 68.37,5.02 61.87,5.02 60.5,3.66 58.06,3.66 53.61,8.1 45.8,8.1 43.89,10.01 v1(43.21,10.01)
PBAT_PRES#: length 16.1
  TOP w0.081: QE23.1 215.87,71.92 RE521.2 215.04,72.75 212.7,72.75 212.57,72.62 212.57,71.87 212.62,71.82 v1(212.62,70.35) ; v1(213.11,61.96) 213.14,61.96 UE1.F9
  IN1 w0.064: v1(213.11,61.96) 213.01,62.06 213.01,62.73 212.78,62.96 212.78,63.68 213.14,64.04 213.14,64.7 213.48,65.04 213.48,66.27 213.13,66.62 213.13,69.07 212.62,69.58 212.62,70.35 v1(212.62,70.35)
PCH_3.3V_TS_EN: length 35.7
  IN1 w0.064: v1(159.92,46.31) 159.92,46.14 160.37,45.69 ; 165.55,45.69 166.03,46.18 166.03,48.05 166.18,48.21 167.24,48.21 167.4,48.36 169.55,48.36 169.74,48.56 170.2,48.56 171.98,50.33 173.12,50.33 175.13,52.34 175.13,55.27 174.84,55.55 174.84,56.84 175.29,57.29 175.29,58.86 174.8,59.35 174.8,59.63 174.96,59.8 175.45,59.8 176.34,60.69 176.34,62.3 175.94,62.7 175,62.7 174.09,63.61 v1(174.09,64.83)
  IN1 w0.081: 165.55,45.69 164.52,44.67 163.17,44.67 162.47,45.38 160.69,45.38 160.37,45.69
PCH_BATLOW#: length 3.1
  TOP w0.081: RH460.1 169.01,50.06 168.76,49.82 168.76,48.47 ; UC1.DH48 169,47.55 169,47.93
  TOP w0.089: 168.76,48.47 168.76,48.17 169,47.93
PCH_DMIC_CLK12: length 27.5
  IN3 w0.064: v4(162.4,74.84) 161.92,74.84 161.86,74.78 161.86,74.69 162.48,74.06 162.77,74.06 165.26,71.58 165.26,70.61 169.59,66.28 169.59,62.66 170.27,61.98 170.27,58.61 171.3,57.58 171.3,57.43 171.99,56.74 172.23,56.74 173.27,55.7 174.09,55.7 174.4,55.39 v4(174.4,54.96)
  BOTTOM w0.081: v4(162.4,74.84) 162.4,75.37 R634.1 ; CC654.1 v4(174.4,54.96)
PCH_DMIC_DATA12: length 28.4
  IN3 w0.064: v4(160.88,74.85) 161.42,74.85 162.4,73.87 162.69,73.87 165.07,71.5 165.07,70.53 169.4,66.2 169.4,62.58 170.08,61.9 170.08,58.53 171.11,57.51 171.11,57.35 171.91,56.55 172.15,56.55 173.19,55.51 174.01,55.51 174.16,55.37 174.16,55.29 v4(173.83,54.96)
  BOTTOM w0.081: v4(160.88,74.85) 160.88,75.21 R655.1 160.57,75.36 160.12,74.9 v3(159.67,74.9)
PCH_DPWROK: length 58.8
  TOP w0.081: UC1.DR48 172.36,47.15 173.15,46.35 174.24,46.35 174.34,46.46 175.11,46.46 177.4,48.75 CH48.1 RH575.1 180.04,48.75 182.06,50.77 v5(182.06,50.79)
  BOTTOM w0.081: RE248.1 212.06,60.64 212.06,59.47 211.17,58.58 211.17,57.44 v6(211.3,57.31) 211.3,56.11 210.65,55.46 209.17,55.46 207,57.63 206.37,57.63 205.11,58.89 199.4,58.89 198.6,58.09 198.6,56.79 197.02,55.21 197.02,53 197.35,52.67 197.35,49.72 195.7,48.07 191.03,48.07 190.54,48.56 189.13,48.56 187.22,50.47 182.38,50.47 v5(182.06,50.79)
PCH_DPWROK_EC: length 1.8
  IN1 w0.064: v1(212.7,61.96) 212.7,62.27 v2(212.67,62.29)
  IN3 w0.064: v4(212.69,61.86) 212.69,62.27 v2(212.67,62.29)
  BOTTOM w0.081: v3(212.92,62.74) 212.69,62.52 v4(212.69,61.86)
PCH_IST_TP_0: length 2.8
  TOP w0.081: v5(166.15,38.5) 165.76,38.89 165.29,38.89 164.71,39.48 UC1.CW33
  BOTTOM w0.081: TP66.1 v5(166.15,38.5)
PCH_IST_TP_1: length 3
  TOP w0.081: UC1.CY32 165.52,39.07 166.1,39.07 166.53,38.65 v5(166.53,37.93)
  BOTTOM w0.081: TP65.1 166.11,37.5 166.53,37.92 v5(166.53,37.93)
PCH_OPI_RCOMP: length 5
  TOP w0.305: RH5.1 177.83,24.36 177.7,24.49 v1(177.61,24.49)
  IN1 w0.305: v1(177.61,24.49) 176.3,24.49 175.31,25.48 v1(173.49,25.48)
PCH_PCIE_WAKE#: length 38.5
  TOP w0.081: RH207.2 v1(178.44,47.14) ; v1(204.99,57.25) 205.71,57.25 206.42,57.96 UE1.L1
  IN1 w0.064: v2(177.96,47.31) 178.12,47.14 v1(178.44,47.14) ; v1(204.99,57.25) 205.15,57.08 205.21,57.08 205.41,56.89 205.41,55.9 205.02,55.51 v2(205.02,54.89)
  IN3 w0.064: v2(205.02,54.89) 204.98,54.86 204.59,54.86 203.02,56.42 201.63,56.42 201.14,55.93 201.13,55.93 197.75,55.93 197.53,55.71 194.82,55.71 194.08,54.97 192.7,54.97 190.97,53.24 v4(183.87,53.24) ; v4(177.96,47.78) v2(177.96,47.31)
  BOTTOM w0.081: v4(183.87,53.24) v3(183.42,53.24) 182.57,53.24 177.96,48.63 v4(177.96,47.78)
PCH_PLTRST#: length 23.8
  TOP w0.081: UH1.2 177.07,54.58 177.17,54.49 177.17,54.03 177.07,53.93 v1(176.56,53.93) ; 160.55,48.41 160.54,48.42 v5(160.5,48.42) 160.5,48.78 160.24,49.03 RH690.2
  TOP w0.089: UC1.CM49 161.17,47.79 160.55,48.41
  IN1 w0.064: v1(176.56,53.93) 176.56,53.61 v2(176.59,53.58)
  IN2 w0.051: v2(176.59,53.58) 175.88,53.58 171.86,49.57 168.51,49.57 167.8,48.86 166.97,48.86 166.09,47.97 164.46,47.97 164.23,47.75 162.82,47.75 162.44,48.13 160.78,48.13 v5(160.5,48.42)
PCH_PLTRST#_5105: length 29.8
  TOP w0.081: 205.22,57.71 v1(205.52,58.01) ; v1(204.15,67.92) 203.43,67.92 203.37,67.98 201.52,67.98 201.18,67.64 RE183.1 201.18,67.53 UE5.4 ; R470.1 198.58,51.47 198.02,52.03 198.02,54.9 198.26,55.13 198.89,55.13 199.32,54.7 201.67,54.7 201.83,54.86 201.83,55.47 202.01,55.66 202.58,55.66 203.36,56.45 203.36,56.77 204.07,57.48 204.07,57.49 204.23,57.64 204.3,57.64
  TOP w0.102: 204.3,57.64 205.15,57.64 205.22,57.71
  IN1 w0.064: v1(204.15,67.92) 204.33,67.74 204.95,67.74 205.77,66.92 205.77,66 205.58,65.81 205.58,63.04 205.78,62.84 205.78,60.86 205.39,60.47 205.39,58.14 v1(205.52,58.01)
PCH_PLTRST#_EC: length 555
  TOP w0.081: v1(277.29,28.21) 277.32,28.21 277.49,28.04 UCR1.1 ; v1(176.07,54.91) 176.07,54.93 175.76,55.23 UH1.4 173.98,55.23 RH46.1 ; v1(213.43,4.05) 214.75,5.37 214.75,6.46 214.63,6.58 U712.17 ; R471.1 197.95,51.49 v5(197.97,51.51) ; UE5.2 203.4,67.03 203.67,66.77 v5(204.14,66.77)
  IN1 w0.064: v2(213.09,4.23) 213.27,4.05 v1(213.43,4.05) 214.14,4.05 214.95,3.24 219.96,3.24 221.57,4.85 223.63,4.85 226.35,2.13 233.73,2.13 236.67,5.07 237,5.07 v2(237.47,5.54) ; v5(204.14,66.77) 204.14,65.81 203.33,65 203.33,64.58 203.45,64.46 203.45,63.82 203.74,63.54 v2(203.74,55.15) 203.74,55.11 204.43,54.42 204.43,52.94 202.46,50.97 202.43,50.97 201.75,50.28 201.75,50.17 200.95,49.38 199.09,49.38 195.41,45.7 195.41,37.8 196.84,36.37 196.84,32.58 196.05,31.79 196.05,30.64 195.9,30.5 195.9,26.49 196.45,25.95 v2(196.45,24.04) ; v1(182.27,57.02) 182.4,56.89 182.4,54.86 v2(182.3,54.75) ; v1(176.07,54.91) 176.26,54.91 v2(176.56,54.61) ; v1(4.05,49.05) v2(3.55,49.05) ; v1(277.29,28.21) 277.12,28.21 276.94,28.02 v2(276.94,26.26)
  IN2 w0.051: v2(196.45,24.04) 197.32,24.04 198.95,25.66 203.61,25.66 204.3,24.98 205.91,24.98 206.15,24.74 208.63,24.74 209.18,24.19 209.18,20.05 212.59,16.64 212.59,14.23 215.43,11.39 220.73,11.39 227.8,4.32 234.38,4.32 235.6,5.54 v2(237.47,5.54) 247.62,5.54 249.23,7.15 251.16,7.15 252.93,5.38 262.74,5.38 264.96,7.6 264.96,9.05 265.37,9.46 266.87,9.46 267.89,10.48 269.24,10.48 272.38,13.61 272.38,14.97 274.92,17.52 274.92,18.66 277.04,20.78 277.04,22.54 277.16,22.66 277.16,23.99 276.94,24.2 276.76,24.2 276.54,24.43 276.54,25.09 276.32,25.31 276.32,25.65 v2(276.94,26.26) ; v2(102.46,43.41) 101.32,42.26 101.32,39.66 97.58,35.93 97.58,29.45 98.67,28.36 100.49,28.36 107.79,21.06 v5(107.79,20.57) 107.54,20.32 106.32,20.32 104.81,18.81 104.81,9.23 103.77,8.19 98.77,8.19 98.02,7.44 96.55,7.44 95.39,6.28 82.75,6.28 82.13,6.89 81.92,6.89 80.82,7.99 80.82,8.77 79.57,10.02 79.57,10.48 77.16,12.89 32.07,12.89 31.39,13.58 24.33,13.58 20,17.91 20,19.24 15.4,23.85 15.4,32.79 17.11,34.5 17.11,37.12 16.73,37.5 16.73,38.81 17.49,39.57 17.49,43.39 15.72,45.16 15.72,46.01 15.01,46.72 15.01,49.49 14.31,50.19 4.69,50.19 v2(3.55,49.05) ; v2(203.74,55.15) 202.62,55.15 201.76,56.02 194.9,56.02 194.85,56.07 193.45,56.07 192.39,55 182.54,55 v2(182.3,54.75) 181.98,54.44 180.46,54.44 180.44,54.42 176.75,54.42 v2(176.56,54.61) 176.37,54.42 175.81,54.42 171.64,50.24 167.33,50.24 166.12,49.03 165.77,49.03 165.44,49.36 164.58,49.36 163.58,50.35 159.32,50.35 158.73,50.94 155.42,50.94 154.74,51.62 138.92,51.62 138.89,51.6 131.17,51.6 130.73,51.16 130.35,51.16 130.35,51.17 127.71,51.17 127.59,51.28 116.41,51.28 116.28,51.15 116.28,51.15 115.08,49.95 104.81,49.95 v2(104.62,50.14)
  IN3 w0.064: v5(197.97,51.51) 198.39,51.94 199.44,51.94 199.67,51.71 200.25,51.71 200.75,52.21 203.54,52.21 204.44,53.11 204.44,54.27 203.74,54.97 v2(203.74,55.15) ; v4(276.94,26.59) v2(276.94,26.26) ; v2(213.09,4.23) 212.06,5.25 v4(206.39,5.25) ; v2(102.46,43.41) 103.26,44.21 103.26,46.64 105.32,48.7 105.32,49.44 v2(104.62,50.14)
  BOTTOM w0.081: v5(204.14,66.77) 204.82,66.09 v3(205.91,66.09) 207.35,67.54 209.2,67.54 209.83,66.91 210.02,66.91 210.69,66.24 211.21,66.24 211.55,66.58 RE193.1 ; v5(197.97,51.51) 198.14,51.68 198.14,54.95 201.28,58.09 203.84,58.09 LED2.1 ; v5(107.79,20.57) 108.09,20.27 108.09,18.9 107.79,18.6 107.79,18.33 108.42,17.7 108.42,16.87 108.51,16.79 108.51,15.6 108.87,15.24 R544.2 ; RT163.2 274.76,32.33 277.27,29.82 277.27,26.93 v4(276.94,26.59)
PCH_PRIM_EN: length 6.9
  TOP w0.081: RC508.1 214.13,17.46 214.47,17.12 v3(215.49,17.12)
  TOP w0.254: PU500.11 211.13,19.77 211.36,19.53 213.76,19.53 CC511.1 RC505.2 214.08,17.65 RC508.1
PCH_PRIM_EN_R: length 91.7
  TOP w0.081: v3(216.44,18.06) 216.24,18.26 215.06,18.26 RC505.1 215.35,18.68 v1(215.41,18.68) ; RC699.2 RC698.2 v1(181.13,52.84)
  IN1 w0.064: v1(215.41,18.68) 215.32,18.58 212.79,18.58 210.34,21.03 210.34,22.59 209.79,23.14 209.79,23.66 208.91,24.54 207.43,24.54 207.3,24.67 207.3,25.22 206.89,25.63 206.6,25.63 206.3,25.93 206.3,26.21 208.78,28.69 208.78,29.11 209.44,29.77 209.44,31.62 207.59,33.47 207.59,38.18 209.93,40.52 212.16,40.52 213.08,41.44 213.08,41.99 213.08,47.73 213.94,48.59 213.94,52.26 214.43,52.75 214.43,54.36 v2(214.56,54.49) ; v2(180.91,53.34) 181.13,53.11 v1(181.13,52.84)
  IN2 w0.051: v2(180.91,53.34) 191.15,53.34 191.32,53.5 191.5,53.69 192.59,53.69 193.43,54.53 194.23,54.53 194.33,54.63 195.09,54.63 195.51,54.21 196.89,54.21 197.24,53.86 200.04,53.86 200.24,54.06 201.8,54.06 202.49,54.75 202.89,54.75 203.21,54.43 203.21,54.1 203.44,53.87 205.13,53.87 205.41,54.15 210.22,54.15 211.28,55.21 213.85,55.21 v2(214.56,54.49)
PCH_PWROK: length 16.6
  TOP w0.081: UH6.4 174.11,58.33 v1(173.71,58.74) 173.35,58.74 173.2,58.59 173.2,56.05 172.8,55.65 172.8,52.28 172.12,51.6 172.12,49.72 171.79,49.39 171.79,48.59 171.45,48.24 171.45,46.89 UC1.DN47
  IN1 w0.064: v2(173.36,58.89) 173.52,58.74 v1(173.71,58.74)
  IN3 w0.064: v2(173.36,58.89) 173.39,58.89 v4(173.71,58.57)
  BOTTOM w0.081: v4(173.71,58.57) 173.84,58.44 173.84,57.62 v6(173.97,57.49)
PCH_PWROK_P: length 85.6
  TOP w0.081: v5(101.77,51.42) 101.47,51.12 PR1125.2 ; v1(173.13,59.6) 173.41,59.32 RH625.1 174.11,59.32 174.66,58.77 175.17,58.77 175.36,58.58 175.36,57.71 176.03,57.03 UH6.1 177.08,57.03 177.16,56.95 177.16,56.42 176.89,56.16 RH733.1
  IN1 w0.064: v1(173.13,59.6) 173.13,59.38 v2(173,59.25)
  IN2 w0.051: v2(173,59.25) 173,59.24 172.21,59.24 171.51,58.55 170.29,58.55 169.29,57.55 169.29,57.22 168.77,56.69 167.47,56.69 163.73,52.94 156.04,52.94 155.53,53.45 150.4,53.45 150.29,53.34 144.55,53.34 144.44,53.45 135.58,53.45 134.7,54.33 132.98,54.33 132.1,53.45 128.31,53.45 128.03,53.17 115.16,53.17 114.8,53.53 114.19,53.53 112.9,52.25 110.84,52.25 110.76,52.34 108.68,52.34 108.24,51.9 102.25,51.9 v5(101.77,51.42)
  BOTTOM w0.081: v5(101.77,51.42) v6(101.19,51.42)
PCH_RSMRST#: length 80.4
  TOP w0.081: RC644.1 173.53,18.17 173.53,17.82 v1(173.52,17.82) 173.52,17.79 173.2,17.46 173.2,16.42 173.67,15.95 UC2.1 174.26,15.95 174.34,15.87 174.34,15.19 R466.2 173.46,15.06 v3(173.16,14.76) ; v1(210.3,57.16) 210.3,56.8 210.61,56.49 210.61,56.16 211.04,55.73 RE472.2
  IN1 w0.064: v1(173.52,17.82) v2(173.76,17.58) ; v1(210.3,57.16) 209.69,56.55 209.69,52.64 209.13,52.08 208.35,52.08 207.72,51.45 207.72,50.39 205.01,47.68 202.07,47.68 201.89,47.51 200.5,47.51 200.19,47.2 200.19,47.06 200.19,46.2 200.37,46.02 200.37,45.37 200.12,45.13 200.12,31.33 199.49,30.69 199.49,26.83 198.91,26.26 198.91,25.83 198.9,25.82 198.9,22.76 v2(198.6,22.45)
  IN2 w0.051: v2(173.76,17.58) 173.76,17.93 174.45,18.63 186.08,18.63 190.54,23.09 192.15,23.09 193.08,22.15 193.08,21.75 193.26,21.56 197.71,21.56 v2(198.6,22.45)
PCH_RSMRST#_AND: length 109.8
  TOP w0.081: UC2.4 172.48,17.25 172.63,17.4 v1(172.63,17.56) 172.63,17.82 172.35,18.1 RC247.1 RC644.2 ; RH591.1 RH592.1 168.43,48.12 168.69,47.87 v1(168.69,47.58)
  IN1 w0.064: v2(173.09,17.77) 172.84,17.77 v1(172.63,17.56) ; v1(168.69,47.58) 168.63,47.58 v2(168.4,47.34)
  IN2 w0.051: v2(168.4,47.34) 168.77,47.34 169.25,46.86 172.14,46.86 172.78,46.22 175.19,46.22 176.17,47.2 177.4,47.2 178.12,46.48 179.05,46.48 179.29,46.24 179.29,46.14 181.37,44.07 182.33,44.07 182.83,43.57 184.77,43.57 185.81,44.6 187.46,44.6 189.51,42.55 189.75,42.55 v2(191.56,40.75) ; v2(185.18,29.06) 185.58,29.06 186.11,28.52 186.11,23.88 183.33,21.1 176.42,21.1 175.93,20.61 175.93,20.61 v2(173.09,17.77)
  IN3 w0.064: v4(193.24,52.2) 193.1,52.06 193.1,51.57 192.36,50.84 192.09,50.84 191.77,50.52 191.77,48.48 192.2,48.05 192.2,41.71 191.56,41.07 v2(191.56,40.75) 191.54,40.75 190.89,40.09 190.89,36.37 190.26,35.75 190.26,35.11 190.71,34.65 190.71,33.59 186.92,29.79 185.92,29.79 v2(185.18,29.06) ; v4(206.63,60.04) 206.63,60.37 205.63,61.36 201.33,61.36 201.12,61.57 199.91,61.57 199.7,61.36 198.27,61.36 196.88,62.75 195.12,62.75 194.55,62.18 194.55,58.72 194.71,58.56 194.71,57.11 v4(194.94,56.88)
  BOTTOM w0.081: v4(193.24,52.2) v3(193.66,52.2) 194.42,52.2 195.76,53.54 195.76,56.67 195.55,56.88 v4(194.94,56.88)
PCH_RTCRST#: length 105.4
  TOP w0.081: R271.2 185.02,18.45 v1(185.02,16.74) ; v5(175.04,49.5) 174.98,49.56 174.83,49.56 173.76,48.49 173.53,48.49 173.32,48.28 173.32,47.69 172.93,47.29 UC1.DT47
  IN1 w0.064: v1(185.02,16.74) 190.47,16.74 194.3,20.56 194.3,22.77 193.97,23.09 193.52,23.09 193.07,22.64 192.75,22.64 192.24,23.15 192.24,31.34 192.38,31.48 192.38,31.91 192.24,32.05 192.24,34.17 192.59,34.52 192.59,46.09 194.51,48.01 v2(194.51,49.24)
  IN2 w0.051: v5(175.04,49.5) 175.09,49.55 175.09,50 175.36,50.27 180.59,50.27 181.16,49.69 183.2,49.69 183.29,49.6 183.65,49.6 183.65,49.6 186.54,49.6 187.6,48.55 190.77,48.55 191.31,49.08 193.85,49.08 194.01,49.24 v2(194.51,49.24)
  IN3 w0.064: v4(217.39,58.77) 218.17,58 218.17,55.81 216.9,54.54 214.99,54.54 214.69,54.85 213.72,54.85 213.14,54.27 213.1,54.27 213.1,54.27 206.22,54.27 203.72,51.76 200.94,51.76 200.43,51.26 198.49,51.26 198.34,51.12 197.56,51.12 196.69,50.25 195.52,50.25 v2(194.51,49.24)
  BOTTOM w0.081: v5(175.04,49.5) 175.04,49.91 174.85,50.1 v6(172.63,50.1) CH47.2 RH573.2
PCH_RTCX1: length 6.8
  TOP w0.081: YC1.1 171.61,52.55 171.34,52.28 CH12.1 171.34,51.68 171.33,51.66 RH16.1 171.33,49.69 171.15,49.52 171.15,48.42 170.85,48.12 170.85,47.56 UC1.DL48
PCH_RTCX2: length 4.3
  TOP w0.081: UC1.DL49 170.58,48.28 170.68,48.38 170.68,48.6 170.69,48.62 170.69,49.71 170.75,49.76 RH16.2 170.75,51.66 170.7,51.72 RH637.2
PCH_RTCX2_R: length 2.2
  TOP w0.081: YC1.2 169.11,52.7 169.46,52.35 CH13.1 RH637.1
PCH_SPI_CLK: length 61.4
  IN1 w0.099: v1(166.08,44.26) 166.09,44.26 166.26,44.42 v2(166.72,44.42)
  IN2 w0.051: v2(207.39,31.81) 207.37,31.83 205.81,31.83 203.12,34.52 198.28,34.52 197.92,34.89 195.55,34.89 195.33,35.11 193.58,35.11 192.92,35.76 192,35.76 189.91,37.86 189.76,37.86 187.31,40.31 185.81,40.31 183.72,42.4 182.36,42.4 182.02,42.73 180.97,42.73 180.08,43.62 177.97,43.62 177.83,43.48 171.49,43.48 171.09,43.89 168.71,43.89 168.17,44.42 v2(166.72,44.42)
  IN3 w0.064: v4(213.71,25.91) 212.78,25.91 210.27,28.42 210.27,29.87 209.38,30.76 208.15,30.76 207.39,31.52 v2(207.39,31.81)
  IN3 w0.081: v4(166.41,44.64) v2(166.72,44.42)
  BOTTOM w0.081: RH719.2 213.27,25.46 v4(213.71,25.91) ; v4(166.41,44.64) 166.41,44.64 RC734.1
PCH_SPI_CLK_R: length 46.4
  IN2 w0.051: v2(215.39,21.11) 215.39,21.48 216.21,22.3 216.21,26.24 209.58,32.87 208.39,32.87 202.95,38.3 196.65,38.3 196.2,38.75 195.39,38.75 195.13,38.48 192.48,38.48 190.83,40.13 190.73,40.13 187.87,42.99 v2(187.02,42.99)
  IN3 w0.064: v2(215.39,21.11) 215.36,21.08 214.96,21.08 214.8,21.25 213.48,21.25 213.27,21.46 v4(213.27,21.52) ; v4(186.43,43.01) 187,43.01 v2(187.02,42.99)
  BOTTOM w0.081: v4(213.27,21.52) 213.27,21.09 213.01,20.84 RH24.2 R703.1
PCH_SPI_CLK_TPM: length 43.1
  TOP w0.081: U712.19 215.23,7.58 R648.2 215.64,7.38 216.31,8.05 v1(216.43,8.05)
  IN1 w0.064: v1(216.43,8.05) 216.43,7.34 216.63,7.14 217.77,7.14 217.9,7.27 217.9,7.66 217.77,7.78 217.32,7.78 217.13,7.97 217.13,9.1 217.85,9.82 218.24,9.82 218.36,9.93 218.36,10.07 218.26,10.16 217.81,10.16 217.71,10.25 217.71,10.38 217.81,10.48 218.57,10.48 218.66,10.57 218.66,10.7 218.57,10.79 217.81,10.79 217.71,10.89 217.71,11.02 217.81,11.11 218.24,11.11 218.33,11.2 218.33,11.34 218.24,11.43 217.81,11.43 217.71,11.52 217.71,11.65 217.81,11.75 218.24,11.75 218.33,11.84 218.33,11.97 218.24,12.06 217.81,12.06 217.71,12.16 217.71,12.29 217.81,12.38 218.24,12.38 218.33,12.47 218.33,15.94 218.17,16.1 217.91,16.1 217.85,16.17 217.85,16.86 217.91,16.93 219.54,16.93 219.73,17.11 219.73,19.5 219.46,19.77 217.99,19.77 216.94,20.81 216.94,21.62 217.08,21.76 217.77,21.76 217.83,21.82 217.83,22.2 217.77,22.26 217.23,22.26 216.5,22.99 216.28,22.99 215.93,22.64 215.93,22.33 216.35,21.91 216.35,21.31 216.22,21.18 216.09,21.18 216,21.28 216,21.71 215.91,21.8 215.13,21.8 215.05,21.72 215.05,21.28 214.96,21.18 214.82,21.18 214.73,21.28 214.73,21.72 214.45,22.01 214.45,22.33 214.33,22.45 212.86,22.45 212.68,22.27 v2(212.68,20.71)
  IN3 w0.064: v4(212.44,19.99) 212.44,20.47 v2(212.68,20.71)
PCH_SPI_CS0#: length 64.2
  IN1 w0.099: v1(166.08,44.91) 166.34,45.17 v2(166.34,45.19)
  IN2 w0.051: v2(166.34,45.19) 166.91,45.19 167.29,45.57 167.61,45.57 167.79,45.74 168.32,45.74 168.54,45.53 170.71,45.53 171.08,45.16 172.96,45.16 173.01,45.11 180.06,45.11 181.44,43.72 182.42,43.72 182.75,43.39 184.12,43.39 185.43,42.09 186.3,42.09 186.88,41.5 187.52,41.5 190.19,38.84 190.29,38.84 192.4,36.73 194.93,36.73 195.46,36.19 197.94,36.19 198.56,36.82 202.64,36.82 206.38,33.07 v2(206.38,32.98)
  IN3 w0.064: v4(215.89,26.43) 215.56,26.43 214.39,27.6 213.07,27.6 211.67,29 211.67,30.45 209.13,32.98 v2(206.38,32.98)
  BOTTOM w0.081: RH736.2 216.54,25.78 v4(215.89,26.43)
PCH_SPI_CS0#_R: length 78.1
  TOP w0.081: v1(224.44,7.98) 224.38,8.05 224.38,15.66 224.82,16.1 UH8.1
  IN1 w0.064: v1(224.44,7.98) 224.08,8.34 223.84,8.34 223.21,8.97 223.21,12.6 223.14,12.67 221.47,12.67 221.39,12.75 221.39,12.85 221.47,12.93 222.86,12.93 222.93,13 222.93,13.11 222.86,13.18 220.58,13.18 220.5,13.26 220.5,13.36 220.58,13.44 222.34,13.44 222.41,13.51 222.41,13.62 222.34,13.69 220.7,13.69 220.59,13.79 v2(220.59,15.62)
  IN2 w0.051: v2(187.34,42.02) 187.76,42.02 190.41,39.37 190.51,39.37 192.8,37.08 194.99,37.08 195.26,37.35 203.04,37.35 208.13,32.26 209.33,32.26 215.29,26.29 215.29,22.85 v2(215.44,22.69)
  IN3 w0.064: v4(216.89,22.69) v2(215.44,22.69) ; v4(220.81,16.53) 220.81,15.84 v2(220.59,15.62) ; v2(187.34,42.02) 187.34,42.05 186.88,42.51 v4(186.43,42.51)
  BOTTOM w0.081: v4(216.89,22.69) 216.89,21.87 RH736.1 216.54,21.37 217.04,20.88 217.04,20.03 217.28,19.78 219.73,19.78 v6(220.11,19.4) 220.81,18.71 v4(220.81,16.53)
PCH_SPI_CS1#: length 59.2
  IN1 w0.064: v2(168.01,43.3) 167.91,43.41 v1(167.91,43.61)
  IN2 w0.051: v2(168.01,43.3) 170.81,43.3 171.25,42.86 178.57,42.86 178.7,42.99 179.36,42.99 180.22,42.12 181.77,42.12 182.11,41.79 183.47,41.79 185.59,39.66 186.48,39.66 188.98,37.16 189.74,37.16 191.94,34.96 192.86,34.96 193.91,33.91 202.87,33.91 205.56,31.22 208.42,31.22 v2(208.76,31.56)
  IN3 w0.064: v2(208.76,31.56) 209.48,31.56 210.9,30.13 210.9,28.68 212.76,26.82 213.77,26.82 214.13,26.47 214.13,26.24 v4(214.54,25.83)
  BOTTOM w0.081: RH735.2 v4(214.54,25.83)
PCH_SPI_CS1#_R: length 46.5
  IN2 w0.051: v2(215.42,22.17) 215.47,22.17 215.77,22.48 215.77,26.06 209.4,32.43 208.21,32.43 203.12,37.53 195.19,37.53 194.92,37.26 192.87,37.26 190.59,39.55 190.48,39.55 187.63,42.4 185.99,42.4 v2(185.98,42.42)
  IN3 w0.064: v2(185.98,42.42) 185.98,41.89 v4(185.84,41.74) ; v2(215.42,22.17) 214.97,21.73 214.74,21.73 v4(214.54,21.52)
  BOTTOM w0.081: v4(185.84,41.74) 185.54,41.74 v3(185.34,41.94) 185.34,42.32 185.44,42.42 185.44,43.87 186.08,44.51 JSPI1.1
PCH_SPI_CS2#: length 62
  IN1 w0.064: v1(166.08,43.61) v2(166.08,43.01)
  IN2 w0.051: v2(214.45,20.9) 213.78,21.56 213.78,26.38 209.46,30.71 205.35,30.71 202.66,33.4 193.7,33.4 192.83,34.28 191.58,34.28 189.92,35.93 189.49,35.93 186.27,39.15 185.38,39.15 183.64,40.9 180.55,40.9 180.19,41.25 178.63,41.25 178.3,41.58 174.25,41.58 174.12,41.72 172.93,41.72 172.51,41.3 171.29,41.3 171.01,41.57 169,41.57 168.85,41.63 168.6,41.68 166.86,41.68 166.08,42.46 v2(166.08,43.01)
  IN3 w0.064: v2(214.45,20.9) 214.29,20.75 v4(214.29,20.59)

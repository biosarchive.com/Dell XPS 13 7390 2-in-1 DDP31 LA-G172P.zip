# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5VALWB_R_TBT:
  vias: v1(276.58,18.7) v1(276.58,18.39) v1(276.88,18.7) v1(276.88,18.39) v1(276.94,17.11) v1(276.94,16.8) v1(278.29,16.85) v1(278.29,16.55) v1(278.59,16.85) v1(278.59,16.55) v1(283.23,9.2) v1(283.23,8.88) v1(283.23,8.45) v2(277.85,16.67) v2(277.85,16.17) v2(278.42,17.25) v2(278.48,16.17) v2(281.96,8.73) v2(281.96,8.28) v2(281.96,7.84) v3(278.25,18.13)
+5VALWBP: length 21.1
  TOP w0.081: v6(286.29,8.36) 286.29,8.16 284.89,6.77 284.89,6.39
  TOP w0.254: PR416.1 269.27,9.96 269.36,10.04 v1(269.36,10.58)
  IN1 w0.254: v1(269.36,10.58) 270.38,9.56 271.37,9.56 271.94,8.99 275.37,8.99 275.62,8.74 275.62,7.97 276.07,7.53 280.07,7.53 280.4,7.2 280.4,5.42 281.08,4.74 v1(283.31,4.74)
+5VALWP: length 17.2
  TOP w0.254: PR404.1 24.48,2.22 v1(24.14,1.88)
  IN1 w0.254: v1(24.14,1.88) 18.64,1.88 17.18,3.34 15.53,3.34 12.61,6.26 v1(12.61,9.24)
  vias: v6(18.26,12.42)
+5VBS: length 40.3
  TOP w1.016: 236.82,8.8 238.96,6.67 238.96,5.21 241.14,3.02 258.29,3.02 ; 262.62,13.44 262.8,13.61 262.8,18.77
  IN1 w1.016: 263,11.68 263.24,11.44 263.24,7.47 262.8,7.02 262.1,7.02 260.95,5.88 260.19,5.88 259.24,4.93 259.24,4.16
  vias: v1(259.05,3.15) v1(259.43,3.15) v1(262.53,12.46) v1(262.91,12.46) v6(262.54,19.59)
+5VBS_FAN2: length 1.4
  TOP w0.102: JFAN2.1 v6(237.65,1.48)
+5VBS_R:
  vias: v3(266.29,18.13)
+5VS: length 25
  IN3 w1.016: 91.6,3.4 90.03,3.4 88.76,4.67 73.63,4.67 71.66,6.64 68.56,6.64
  BOTTOM w0.102: v5(92.49,3.54) v6(91.92,3.54)
  vias: v5(67.09,6.62) v5(67.72,6.62) v5(93.12,3.54)
+5VS_AUDIO: length 195.9
  IN1 w0.508: v5(163.02,75.69) 163.02,74.38 161.88,73.24 154.14,73.24 153.65,72.75 143.11,72.75 142.87,72.51 136.09,72.51 135.63,72.05 124.75,72.05 124.51,71.8 107.67,71.8 106.59,72.88 97.81,72.88 93.03,68.11 90.49,68.11 86.64,71.96 v2(85.31,71.96)
  IN2 w0.508: 40.48,16.36 48.67,16.36 49.52,17.21 53.14,17.21 54.71,18.77 65.13,18.77 66.65,20.29 66.99,21.12 67.14,21.86 70.26,24.98 70.26,69.31 72.91,71.96 v2(85.31,71.96)
  BOTTOM w0.102: 163.57,74.9 165.66,74.9 v6(165.77,75)
  BOTTOM w2.032: 24.99,10.77 29.43,10.77 32.54,13.88 38.94,13.88
  vias: v5(21.11,10.96) v5(21.18,10.39) v5(21.69,10.96) v5(21.75,10.39) v5(38.26,16.36) v5(38.83,16.36) v5(39.4,16.36) v5(39.97,16.36)
+5VS_AUDIO_R:
  vias: v6(44.09,13.48)
+5VS_FAN1: length 0.6
  BOTTOM w0.081: v5(67.28,3.96) 67.28,4.36 v6(67.45,4.53)
+5VS_R: length 3.7
  TOP w0.081: v3(93.43,8.31) 93.35,8.23 93.35,6.48 93.51,6.32 94.28,6.32 94.65,5.95 R6182.1
+8.4V_BATT+:
  vias: v6(90.2,18.26)
+AVDD1: length 21.9
  TOP w0.203: UA1.40 26.33,17.23 26.26,17.3
  TOP w0.254: v1(24.04,17.74) 24.56,17.74 24.63,17.66 24.78,17.66 CA23.1 25.53,17.65 v3(25.78,17.4) 25.89,17.3 26.26,17.3 ; LA1.1 38.21,17.88 37.88,17.55 v1(37.05,17.55)
  IN1 w0.254: 28.99,19.28 28.8,19.09 26.98,19.09 25.64,17.74 v1(24.04,17.74) ; 28.99,19.28 28.99,21.06 28.32,21.73 v1(28.1,21.73) ; 28.99,19.28 34.77,19.28 36.49,17.55 v1(37.05,17.55)
+DVDD: length 50.3
  TOP w0.203: UA1.3 28.54,12.74 28.73,12.55
  TOP w0.254: RA29.2 31.66,10.83 v1(31.78,10.96) ; v1(51.53,18.32) 51.53,15.56 49.5,13.53 v3(49.5,13.23) 49.24,12.97 v1(49.24,12.89) ; RA13.2 26.64,12.17 v1(26.77,12.29) ; CA54.1 30.25,11.66 30.06,11.85 29.43,11.85 28.73,12.55
  IN1 w0.254: v1(66.29,18.93) 65.99,18.64 60.18,18.64 59.6,19.22 57.64,19.22 56.75,18.32 v1(51.53,18.32) ; v1(26.77,12.29) 31.21,12.29 31.72,11.78 31.72,11.02 v1(31.78,10.96) 31.85,10.9 35.84,10.9 36.67,11.72 41.32,11.72 42.14,12.54 48.89,12.54 v1(49.24,12.89)
+DVDD_MIC: length 162.3
  TOP w0.203: v5(167.08,81.94) 166.72,81.94 166.43,82.23 166.43,83.51 166.3,83.64 JUFC1.4
  TOP w0.254: F1.2 68.32,20.9 v5(68.49,20.74)
  IN1 w0.254: v2(73.82,25.78) 73.82,26.35 73.69,26.48 73.69,53.68 74.71,54.7 74.71,58.2 73.69,59.22 73.69,64.16 74.35,64.82 74.35,71.13 75.73,72.52 86.8,72.52 90.72,68.59 92.83,68.59 97.61,73.37 106.97,73.37 108.05,72.29 124.16,72.29 124.43,72.55 135.27,72.55 135.71,72.99 142.6,72.99 144.02,74.41 156.75,74.41 160.27,77.94 161.14,77.94 161.94,77.13 162.65,77.13 163.28,77.76 163.86,77.76 164.12,78.01 v1(165.64,78.01) 166.05,78.01 166.8,78.77 166.8,79.72 166.54,79.97 166.54,80.28 166.59,80.33 166.59,80.34 167.08,80.82 v5(167.08,81.94)
  IN2 w0.254: v2(73.82,25.78) 73.53,25.78 v5(68.49,20.74)
  BOTTOM w0.356: v5(167.08,81.94) 167.04,81.94 166.4,81.3 C1540.1
+DVDDIO: length 5.2
  TOP w0.203: UA1.18 33.57,16.03
  TOP w0.254: RA18.2 RA41.2 CA38.1 35.95,14.87 CA36.1 35.17,14.87 34.32,15.72 33.87,15.72 33.57,16.03
+PVDD:
  vias: v6(25.43,14.58)
+V1.05A_BYPASS: length 17.2
  IN1 w0.254: v1(169.38,31.4) 168.82,30.83 168.82,29.77 169.07,29.52 169.56,29.52 170.68,28.4 172.56,28.4 174.69,26.27 175.62,26.27 176.12,26.77 176.12,27.14 177.2,28.22 v5(177.28,28.22)
  BOTTOM w0.254: v5(177.28,28.22) 177.35,28.29 v3(177.35,29.12) RC595.2
+V1.05A_MIPI60: length 34.9
  TOP w0.254: v5(108.22,18.47) 109.06,17.62 109.06,4.84 109.67,4.24 115.02,4.24 v5(115.16,4.38)
  BOTTOM w0.254: v5(115.16,4.38) 115.16,3.36 114.9,3.11 R114.1
  BOTTOM w0.356: v5(108.22,18.47) 108.22,18.41 108.74,17.88 108.74,17 108.87,16.88 R270.2 ; 105.97,15.9 105.97,15.14 R111.2
  BOTTOM w0.508: v5(108.22,18.47) 108.49,18.74 108.49,20.85 108.22,21.12 R123.2 107.58,21.25 v3(107.21,20.87) 107.21,18.58 105.97,17.33 105.97,15.9
+V1.05A_VREF_DEBUG: length 5.8
  BOTTOM w0.279: R111.1 C1544.1 106.59,13.94 v3(106.84,13.69) 107.6,12.93 109.72,12.93 110,12.65 JMIPI60.1
+V3.3A_1.8A_PCH_SPI: length 102.2
  IN1 w0.254: v2(165.85,40.61) 166.08,40.39 v1(166.08,40.36)
  IN2 w0.254: v2(155.76,22.99) 156.18,22.57 156.18,21.56 155.35,20.74 151.9,20.74 146.63,15.47 137.68,15.47 131.89,9.68 127.1,9.68 122.78,5.36 120.01,5.36 119.12,4.46 v2(115.86,4.46) ; v2(165.85,40.61) 166.09,40.85 166.09,41.56 165.65,42 165.65,45.48 v2(166.49,46.33)
  IN3 w0.254: v4(156.23,23.46) v2(155.76,22.99) ; v4(166.85,46.28) 166.8,46.33 v2(166.49,46.33) ; v4(165.83,41.82) 166.06,41.59 166.06,40.82 v2(165.85,40.61) 165.85,40.47 v4(166.4,39.91) ; v4(115.86,3.69) v2(115.86,4.46)
  BOTTOM w0.254: v3(167.8,26.52) 167.8,25.96 165.88,24.05 156.82,24.05 v4(156.23,23.46) ; RH643.2 165.83,46.02 166.09,46.28 v4(166.85,46.28) 168.78,46.28 169.01,46.05 RH141.2 ; RH635.2 v4(165.83,41.82)
  BOTTOM w0.381: 167.89,38.24 168.26,38.24 168.49,38.46 175.33,38.46 175.86,37.93 RC583.2 176.3,37.6 176.65,37.25 RC582.2 176.88,37.27 CC30.1 ; 167.89,38.24 167.89,37.67 167.44,37.23 167.44,31.49 168.09,30.85 168.09,26.8 v3(167.8,26.52) ; 167.89,38.24 167.89,38.49 166.7,39.68 166.64,39.68 v4(166.4,39.91)
+VBATT: length 10.3
  TOP w0.508: PR236.2 87.01,19.35 v1(87.9,19.35)
  IN1 w0.508: v1(87.9,19.35) 97.3,19.35 v1(97.33,19.33)
  vias: v6(96.49,16.93)
+VCC1.05_OUT_FET: length 50.2
  TOP w0.762: 133.95,14.96 134.59,15.59 134.59,16.48 ; 133.95,14.96 132.48,14.96 ; 133.95,14.96 134.54,14.37 134.89,14.37
  IN1 w0.508: v1(131.93,16.8) 131.69,16.8 131.25,17.25 v2(130.67,17.25)
  IN1 w0.762: 149.45,22.05 151.78,22.05 153.19,23.47
  IN2 w0.508: v2(130.67,17.25) 130.04,17.88 127.31,17.88 125.18,15.75 116.08,15.75 113.65,18.18 v2(112.88,18.18)
  IN3 w0.508: v2(112.88,18.18) 112.88,20.28 111.46,21.7 109.5,21.7 109.14,21.34 v4(109.14,21.25)
  BOTTOM w0.762: 135.1,18.01 136.75,19.66 146.57,19.66 147.39,20.48
  vias: v1(155.01,24.7) v1(154.97,24.36) v5(134.27,17.98) v5(134.27,17.4) v5(148.24,20.66) v5(148.83,20.66) v6(148.94,21.31)
+VCC1.05_OUT_PCH: length 1.5
  IN1 w0.254: v2(168.17,38.06) v1(168.73,38.06)
  IN3 w0.254: v2(168.17,38.06) 167.92,37.82 v4(167.36,37.82)
+VCC1P05_OUTPUT_PLL: length 3.8
  TOP w0.254: UC1.CD2 UC1.CD1 156.75,23.73 156.75,22.73 157.23,22.25 CC147.1 CC148.1
+VCC1P8A:
  vias: v1(149.56,27.91) v1(149.89,27.91) v1(150.59,27.91) v1(150.91,27.91) v1(153.58,25.25) v1(153.67,25) v1(154.34,25.21) v1(154.36,24.91)
+VCC1V8_TBT_L_LDO: length 1.8
  TOP w0.203: 17.59,23.63 UPD1.35
  TOP w0.254: CPD6.1 17.59,23.77 17.59,23.63
+VCC1V8_TBT_R_LDO: length 1.9
  TOP w0.203: 285.96,13.35 UPD2.35
  TOP w0.254: 285.96,13.35 286.4,13.35 286.6,13.55 CPD16.1
+VCC3V3_TBT_L_LDO: length 123.4
  TOP w0.203: UPD1.9 11.09,16.56 CPD4.1
  TOP w0.381: v1(10.52,15.95) 10.54,15.95 CPD4.1 ; v1(14.06,12.92) 14.14,12.83 14.68,12.83 RPD170.2 ; RPD183.2 15.8,26.88 14.96,27.72 13.53,27.72 v1(13.22,27.42)
  TOP w0.508: v5(54.77,7.91) 54.77,9.12 54.39,9.5 52.83,9.5 52.33,10.01 RTCD4.2 ; v1(21.43,18.78) 21.43,16.67 20.43,15.67 19.25,15.67 RPD196.2 RPD197.2 RPD198.2 18.21,14.45 16.77,13.01 16.29,13.01 16.29,13.01 RPD170.2
  IN1 w0.254: v1(13.22,27.42) 12.78,26.98 11.99,26.98 10.8,25.79 v2(8.18,25.79)
  IN1 w0.381: v1(21.43,18.78) 21.43,18.93 21.39,18.97 v2(21.39,19.41)
  IN1 w0.508: v1(14.06,12.92) 14.06,13.03 11.13,15.95 v1(10.52,15.95) 9.81,15.24 v2(9.81,14.96) 9.94,14.83 v1(9.94,14.36)
  IN2 w0.254: v2(8.18,25.79) 8.08,25.89 v2(8.08,27.42)
  IN2 w0.508: v5(54.77,7.91) 54.45,8.23 44.93,8.23 44.74,8.04 43.21,8.04 42.9,8.36 37.18,8.36 36.61,7.78 35.85,7.78 34.73,8.9 27.57,8.9 27.08,8.42 27.08,6.96 26.32,6.2 23.78,6.2 20.61,3.02 15.08,3.02 12.16,5.94 12.16,13.56 10.76,14.96 v2(9.81,14.96)
  IN3 w0.254: v4(9.75,27.72) 9.18,27.72 8.87,27.42 v2(8.08,27.42) 8.08,28.23 8.41,28.56 8.41,30.06 8.69,30.34 9.23,30.34 9.74,30.85 9.74,31.27 v4(9.94,31.47)
  IN3 w0.457: v4(21.37,19.79) 21.37,19.43 v2(21.39,19.41)
  BOTTOM w0.254: v4(9.94,31.47) 10.13,31.66 11.78,31.66 12.25,32.13 RT169.2
  BOTTOM w0.305: JDB1.1 11.73,32.71 11.77,32.68 RT169.2
  BOTTOM w0.356: RPD11.1 20.48,21.71 20.48,22.01 19.21,23.28 ; RPD13.1 10.71,27.72 v4(9.75,27.72)
  BOTTOM w0.381: CPD1.1 v3(16.12,25.97) 18.44,23.66 18.83,23.66 19.21,23.28 ; RPD11.1 21.37,20.45 v4(21.37,19.79) 20.42,18.83 19.89,18.83 RPD12.1 RPD14.1
  BOTTOM w0.508: 12.95,26.42 UPD3.8
+VCC3V3_TBT_R_LDO: length 227.7
  TOP w0.254: 277.53,7.53 279.69,7.53 279.75,7.47 280.96,7.47 281.27,7.78 RPD202.2
  TOP w0.381: RPD137.2 RPD184.2 286.35,17.56 v5(286.29,17.63) ; v1(277.44,8.38) 277.56,8.51 277.94,8.51 RPD168.2
  TOP w0.508: v5(180.26,9.04) 180.26,9.16 179.61,9.82 RTCD5.2
  IN1 w0.381: v2(277.21,9.05) 277.21,8.99 277.44,8.77 v1(277.44,8.38)
  IN1 w0.508: v1(276.31,13.68) 275.8,13.68 275.43,13.31 275,13.31 273.91,12.22 v1(273.91,12.17) 273.84,12.17 273.78,12.1 v2(273.27,12.1) 265.84,12.1 263.84,14.1 263.84,15.84 263.47,16.22 262.52,16.22 262.15,15.85 v2(262.15,15.33)
  IN2 w0.508: v5(286.29,17.63) 286.29,18.13 283.05,21.37 278.99,21.37 275.69,18.07 275.69,17.37 273.27,14.96 v2(273.27,12.1) 271.75,12.1 268.26,8.61 267.21,8.61 263.3,4.7 252.64,4.7 251.03,6.31 249.44,6.31 247.49,4.35 235.39,4.35 234.67,3.63 227.52,3.63 222.89,8.26 222.37,8.26 220.99,6.88 218.2,6.88 218,7.09 214.77,7.09 214.16,7.69 204.41,7.69 203.84,7.12 203.84,6.44 203.3,5.89 201.97,5.89 200.78,7.09 199.94,7.09 189.59,17.44 177.65,17.44 177.14,16.93 177.14,12.37 180.26,9.25 v5(180.26,9.04) ; v2(251.94,15.35) 253.16,14.13 255.87,14.13 258.16,16.42 260.07,16.42 260.45,16.04 260.45,15.02 260.74,14.73 261.65,14.73 262.15,15.22 v2(262.15,15.33)
  IN3 w0.254: v2(277.21,9.05) 277.34,8.93 278.67,8.93 279.37,9.63 v4(279.5,9.63) ; v2(251.94,15.35) v4(251.61,15.35)
  IN3 w0.508: v2(273.27,12.1) 273.72,12.1 276.77,9.05 v2(277.21,9.05)
  BOTTOM w0.102: v4(279.5,9.63) v3(278.92,9.63)
  BOTTOM w0.254: UPD4.8 233.75,12.17 233.23,11.64 CPD11.1 ; CPD11.1 RT170.2 233.04,12.33 233.64,12.93 236.32,12.93 236.95,13.56 244.32,13.56 244.57,13.31 ; CPD11.1 232.49,11.64 232.29,11.44 232.29,10.55 232.47,10.37 RPD61.1 ; 251.56,13.31 251.56,15.3 v4(251.61,15.35) ; 251.56,13.31 253.72,11.15 255.94,11.15 256.23,10.86 JDB2.1 ; 251.56,13.31 244.57,13.31 ; 244.57,13.31 244.57,12.31 244.39,12.13 RPD59.1 RPD60.1 243.75,11.31 243.96,11.1 243.96,10.03 243.72,9.79 RPD62.1
  BOTTOM w0.381: v4(279.5,9.63) 279.8,9.32 RPD203.2 RPD201.2
+VCC_SFR_OC: length 53.7
  IN1 w0.254: v1(158.51,43.61) 158.33,43.61 v2(158.08,43.86) ; v1(158.51,44.26) v2(158.25,44.52)
  IN2 w1.016: 107.35,44.42 112.39,44.42 114,42.81 120.02,42.81 123.06,45.85 126.08,45.85 127.35,47.12 131.45,47.12 132.73,45.83 134.6,45.83 135.24,46.47 138.37,46.47 138.49,46.59 142.7,46.59 142.79,46.51 147.29,46.51 147.33,46.56 155.51,46.56 155.99,46.07
  BOTTOM w0.102: v5(107.54,45.31) v6(107.54,44.74)
  vias: v5(106.9,45.31)
+VCC_SFR_OC_R: length 3.6
  TOP w0.081: v3(106.09,44.94) 105.7,45.33 RC643.1 105.86,46.36 UC27.6
+VCCA_CLKLDO_1P8:
  vias: v3(178.53,31.72)
+VCCDPHY_1P24: length 2.7
  TOP w0.254: CC184.1 176.37,39.61 175.7,38.94 175.34,38.94 175.22,39.05 174.58,39.05 UC1.DW32
+VCCDSW_1P05: length 13.1
  TOP w0.254: UC1.DD34 v1(166.49,40.36)
  IN1 w0.254: v1(166.49,40.36) 166.69,40.56 v2(166.69,40.69)
  IN2 w0.254: v2(166.69,40.69) 166.9,40.9 167.77,40.9 168.3,40.37 169.91,40.37 170.59,41.06 172.78,41.06 v2(173.1,41.38)
  IN3 w0.254: v2(173.1,41.38) 173.1,41.37 173.39,41.37 v4(173.51,41.25)
  BOTTOM w0.102: v6(176.84,42.9) CC183.1
  BOTTOM w0.254: CC183.1 176.31,41.88 175.68,41.25 v4(173.51,41.25)
+VCCIN: length 75
  TOP w0.127: UC1.V13 134.92,30.61 ; UC1.V13 134.59,30.53 134.59,30.67 ; UC1.V13 134.92,30.2 ; UC1.V13 134.59,30.28 134.59,30.06 ; UC1.CG34 158.29,40.57 ; UC1.CG34 158.71,40.57 ; UC1.CG34 158.29,40.15 ; UC1.CG34 158.71,40.15 ; 131.07,33.05 UC1.K19 ; UC1.K19 131.07,33.46 ; UC1.K19 130.4,33.71 UC1.J20 ; UC1.K19 130.85,33.26 UC1.J18 ; UC1.CD10 157.34,28.44 ; UC1.CD10 156.92,28.86 ; UC1.CD10 157.34,28.85 ; UC1.CD10 156.92,28.43 ; UC1.J20 130.18,33.5 ; UC1.J20 130.85,34.17 UC1.K21 ; UC1.J20 130.22,33.89 ; UC1.J32 130.39,39.21 130.21,39.03 ; UC1.J32 130.4,39.21 UC1.K31 ; UC1.J32 130.56,39.37 130.65,39.37 ; UC1.J32 130.24,39.36 130.14,39.36 ; UC1.CH10 159.17,28.44 ; UC1.CH10 158.75,28.86 ; UC1.CH10 158.75,28.43 ; UC1.CH10 159.17,28.85 ; 130.21,35.72 130.39,35.55 UC1.J23 ; UC1.CB10 156.02,28.84 ; UC1.CB10 156.01,28.43 ; UC1.CB10 156.43,28.85 ; UC1.CB10 156.43,28.44 ; UC1.BT11 153.22,28.9 ; UC1.BT11 152.8,29.32 ; UC1.BT11 152.8,28.89 ; UC1.CC36 156.47,41.17 ; UC1.CC36 156.47,41.6 ; UC1.CC36 156.88,41.59 ; UC1.CC36 156.88,41.18 ; UC1.CJ34 159.88,40.57 ; UC1.CJ34 159.46,40.57 ; UC1.CJ34 159.46,40.15 ; UC1.CJ34 159.88,40.15 ; UC1.J30 130.4,38.29 UC1.K29 ; UC1.J30 130.85,38.75 UC1.K31 ; UC1.J30 130.18,38.08 ; UC1.BR10 152.76,28.44 ; UC1.BR10 152.76,28.85 ; UC1.BR10 152.35,28.86 ; UC1.BR10 152.35,28.43 ; UC1.BW9 155.05,28.39 ; UC1.BW9 154.63,28.39 ; UC1.BW9 155.05,27.97 ; UC1.BW9 154.63,27.97 ; UC1.BT9 153.22,27.97 ; UC1.BT9 152.8,28.39 ; UC1.BT9 153.22,28.39 ; UC1.BT9 152.8,27.97 ; UC1.AC12 136.79,29.73 ; UC1.AC12 137.21,29.74 ; UC1.AC12 136.79,30.16 ; UC1.AC12 137.21,30.15 ; UC1.CC9 156.46,27.97 ; UC1.CC9 156.88,27.97 ; UC1.CC9 156.46,28.39 ; UC1.CC9 156.88,28.39 ; UC1.AB13 136.75,30.61 ; UC1.AB13 136.75,30.2 ; UC1.AB13 136.33,30.19 ; UC1.AB13 136.33,30.62 ; UC1.CT33 162.66,39.69 ; UC1.CT33 162.66,40.11 ; UC1.CT33 163.08,40.11 ; UC1.CT33 163.08,39.69 ; UC1.K27 130.86,36.92 UC1.J26 ; UC1.K27 131.07,37.13 ; UC1.K27 131.07,36.71 ; UC1.K27 130.4,37.38 UC1.J28 ; UC1.Y13 135.84,30.61 ; UC1.Y13 135.84,30.2 ; UC1.Y13 135.42,30.19 ; UC1.Y13 135.42,30.62 ; UC1.CJ11 159.21,29.32 ; UC1.CJ11 159.21,28.89 ; UC1.CJ11 159.63,28.9 ; UC1.CJ11 159.63,29.31 ; UC1.CF33 158.26,39.69 ; UC1.CF33 157.84,40.11 ; UC1.CF33 157.84,39.69 ; UC1.CF33 158.26,40.11 ; UC1.BV9 153.72,27.97 ; UC1.BV9 154.14,28.39 ; UC1.BV9 154.14,27.97 ; UC1.BV9 153.72,28.39 ; UC1.J22 130.4,34.62 130.19,34.42 ; UC1.J22 130.18,34.84 ; UC1.J22 130.85,35.09 UC1.K23 ; UC1.J22 130.4,34.63 UC1.K21 ; 154.07,28.75 154.28,28.75 UC1.BW10 ; UC1.CC11 156.46,29.32 ; UC1.CC11 156.46,28.89 ; UC1.CC11 156.88,29.31 ; UC1.CC11 156.88,28.9 ; UC1.BW10 154.6,28.44 ; UC1.BW10 154.18,28.43 ; UC1.BW10 154.6,28.85 ; UC1.CL35 160.37,40.8 ; UC1.CL35 160.79,41.22 ; UC1.CL35 160.79,40.8 ; UC1.K31 131.07,38.95 ; UC1.K31 131.07,38.54 ; UC1.CR34 162.2,40.57 ; UC1.CR34 162.62,40.57 ; UC1.CR34 162.2,40.15 ; UC1.CR34 162.62,40.15 ; 155.97,41.18 UC1.CA36 155.97,41.59 ; UC1.CE11 157.38,29.32 ; UC1.CE11 157.38,28.89 ; UC1.CE11 157.8,28.9 ; UC1.CE11 157.8,29.31 ; UC1.BU10 153.26,28.43 ; UC1.BU10 153.26,28.86 ; UC1.BU10 153.57,28.74 153.74,28.74 ; UC1.BU10 153.68,28.44 ; UC1.CE34 157.8,40.15 ; UC1.CE34 157.38,40.57 ; UC1.CE34 157.8,40.57 ; UC1.CE34 157.38,40.15 ; UC1.W12 134.96,29.73 ; UC1.W12 135.38,29.74 ; UC1.W12 134.96,30.16 ; UC1.W12 135.38,30.15 ; UC1.BY10 155.1,28.85 ; UC1.BY10 155.09,28.43 ; UC1.BY10 155.51,28.85 ; UC1.BY10 155.51,28.44 ; UC1.BV36 154.14,41.18 ; UC1.BV36 154.09,41.54 154.21,41.54 ; UC1.BV36 153.72,41.17 ; UC1.J18 130.18,32.59 ; UC1.J18 130.18,33.01 ; UC1.J18 130.4,32.8 UC1.K17 ; UC1.K23 130.4,35.55 UC1.J23 ; UC1.K23 131.07,35.29 ; UC1.K23 131.07,34.88 ; UC1.CR35 162.2,41.22 ; UC1.CR35 162.2,40.8 ; UC1.CR35 162.62,40.8 ; UC1.K24 130.65,35.79 ; UC1.K24 130.4,36.46 UC1.J26 ; UC1.K24 131.07,36.21 ; UC1.K24 131.07,35.79 ; UC1.CL34 160.37,40.57 ; UC1.CL34 160.79,40.15 ; UC1.CL34 160.79,40.57 ; UC1.CL34 160.37,40.15 ; 154.6,41.54 154.62,41.55 154.68,41.55 UC1.BW36 154.63,41.17 ; UC1.K29 130.85,37.83 UC1.J28 ; UC1.K29 131.07,38.04 ; UC1.K29 131.07,37.63 ; UC1.CF10 157.84,28.43 ; UC1.CF10 158.25,28.85 ; UC1.CF10 157.84,28.86 ; UC1.CF10 158.25,28.44 ; UC1.J23 130.18,35.33 ; UC1.J23 130.6,35.75 ; UC1.BP9 152.31,27.97 ; UC1.BP9 151.89,27.97 ; UC1.BP9 151.89,28.39 ; UC1.BP9 152.31,28.39 ; UC1.K21 131.07,33.97 ; UC1.K21 131.07,34.38 ; UC1.CA9 155.97,28.39 ; UC1.CA9 155.55,27.97 ; UC1.CA9 155.97,27.97 ; UC1.CA9 155.55,28.39 ; 159.88,40.8 UC1.CJ35 159.46,40.8 ; 158.29,40.8 UC1.CG35 158.71,40.8 ; UC1.CT34 163.54,40.57 ; UC1.CT34 163.12,40.15 ; UC1.CT34 163.54,40.15 ; UC1.CT34 163.12,40.57 ; UC1.J28 130.18,37.16 ; UC1.J28 130.18,37.59 ; UC1.BP11 151.89,28.89 ; UC1.BP11 152.31,29.31 ; UC1.BP11 152.31,28.9 ; 163.54,40.8 UC1.CT35 163.12,40.8 ; UC1.CN34 161.29,40.57 ; UC1.CN34 161.29,40.15 ; UC1.CN34 161.71,40.15 ; UC1.CN34 161.71,40.57 ; UC1.CN35 161.29,41.22 ; UC1.CN35 161.29,40.8 ; UC1.CN35 161.71,40.8 ; UC1.CN35 161.71,41.22 ; UC1.K17 130.65,32.13 ; UC1.K17 131.07,32.55 ; UC1.K17 131.07,32.14 ; UC1.J26 130.22,36.28 ; UC1.J26 130.18,36.67 ; 151.85,28.44 UC1.BN10 151.85,28.85 ; UC1.CE35 157.8,40.8 ; UC1.CE35 157.38,40.8 ; UC1.CE35 157.38,41.22 ; UC1.CU33 163.58,39.69 ; UC1.CU33 163.58,40.11 ; UC1.CU33 164,40.11 ; UC1.CU33 164,39.69 ; UC1.AA12 136.3,29.74 ; UC1.AA12 135.88,29.73 ; UC1.AA12 135.88,30.16 ; UC1.AA12 136.3,30.15 ; UC1.CP33 162.17,39.69 ; UC1.CP33 161.75,40.11 ; UC1.CP33 162.17,40.11 ; UC1.CG11 158.29,29.32 ; UC1.CG11 158.29,28.89 ; UC1.CG11 158.71,28.9 ; UC1.CG11 158.71,29.31 ; 159.67,28.43 UC1.CK10 159.67,28.86
  TOP w0.254: PR1119.1 123.92,40.74 124.56,40.11 124.56,38.96
  vias: v2(125.9,28.62) v5(114.57,34.49) v5(114.57,33.93) v5(114.57,32.18) v5(114.57,31.62) v5(115.13,34.49) v5(115.13,33.93) v5(115.13,32.18) v5(115.13,31.62) v5(115.7,37.76) v5(115.7,35.57) v5(115.74,32.5) v5(115.68,30.38) v5(116.24,30.38) v5(116.26,37.73) v5(116.26,35.57) v5(116.3,32.5) v5(116.82,37.73) v5(116.82,35.57) v5(116.8,30.38) v5(116.86,32.5) v5(117.38,37.74) v5(117.38,35.56) v5(117.42,32.49) v5(117.36,30.36) v5(117.94,37.74) v5(117.94,35.56) v5(117.91,30.36) v5(117.98,32.49) v5(118.5,37.74) v5(118.5,35.56) v5(118.54,32.49) v5(118.47,30.36) v5(119.04,30.39) v5(119.07,37.77) v5(119.07,35.58) v5(119.11,32.51) v5(119.63,37.77) v5(119.63,35.57) v5(119.6,30.38) v5(119.67,32.5) v5(120.19,37.77) v5(120.19,35.57) v5(120.23,32.5) v5(120.16,30.38) v5(120.49,27.53) v5(120.75,37.76) v5(120.75,35.57) v5(120.72,30.38) v5(120.78,32.5) v5(120.94,27.09) v5(121.3,37.76) v5(121.3,35.57) v5(121.34,32.5) v5(121.28,30.38) v5(121.84,30.38) v5(121.86,37.76) v5(121.86,35.57) v5(121.9,32.5) v5(122.36,27.84) v5(122.46,36.5) v5(122.92,27.84) v5(123.03,38.78) v5(123.1,36.5) v5(123.49,37.63) v5(123.49,27.85) v5(123.54,27.25) v5(124.05,27.85) v5(124.06,37.62) v5(124.1,27.25) v5(124.84,34.66) v5(125.57,34.66) v5(125.7,37.41) v5(126.33,34.62) v5(126.36,37.39) v5(126.36,32.82) v5(127.02,37.36) v5(127.02,36.47) v5(127.02,32.82) v5(127.65,37.39) v5(127.68,36.47) v5(127.65,32.82) v5(128.3,37.38) v5(128.32,36.47) v5(128.3,35.56) v5(128.98,37.39) v5(128.98,36.47) v5(128.95,34.64) v5(129.64,37.39) v5(129.62,36.47) v5(129.61,34.64) v5(129.69,31.86) v5(131.11,38.3) v5(131.11,37.36) v5(131.08,36.45) v5(131.08,35.56) v5(131.11,34.62) v5(131.11,33.68) v5(131.11,32.82) v5(131.11,31.88) v5(131.29,39.09) v5(131.54,23.91) v5(131.85,23.26) v5(135.17,30.63) v5(136.09,30.63) v5(137.21,30.48) v5(137.61,30) v5(152.12,29.67) v5(152.57,29.31) v5(152.57,27.94) v5(153,29.69) v5(153.49,27.96) v5(153.89,40.77) v5(154.86,40.77) v5(155.77,40.77) v5(155.8,29.75) v5(156.23,29.34) v5(156.69,29.75) v5(156.81,39.77) v5(157.02,40.97) v5(157.02,40.38) v5(157.14,29.34) v5(157.45,39.8) v5(157.58,29.75) v5(158.06,40.64) v5(158.06,29.31) v5(158.44,29.77) v5(158.92,29.35) v5(159.05,40.66) v5(159.3,29.77) v5(160.12,40.55) v5(161.01,40.62) v5(162.91,40.66) v5(163.74,40.71) v6(162.28,33.12)
+VCCIN_AUX: length 34.4
  TOP w0.127: UC1.T13 133.59,30.19 ; UC1.T13 134.01,30.61 ; UC1.T13 134.01,30.2 ; UC1.T13 133.59,30.62 ; 161.14,28.47 160.96,28.47 UC1.CL10 ; UC1.P13 132.81,30.24 ; UC1.P13 132.39,30.24 ; UC1.P13 132.39,30.66 ; UC1.P13 132.81,30.66 ; UC1.AY9 145.9,27.97 ; UC1.AY9 145.48,27.97 ; UC1.AY9 145.24,28.64 ; UC1.AY9 146.15,28.64 ; UC1.AT9 143.67,28.37 ; UC1.AT9 144.32,28.64 ; UC1.AT9 143.65,27.97 ; UC1.AT9 144.07,27.97 ; UC1.DC11 166.95,28.9 ; UC1.DC11 166.55,28.91 ; UC1.DC11 166.53,29.32 ; UC1.DC11 166.95,29.31 ; 160.58,28.43 UC1.CL10 ; UC1.CL10 160.58,28.86 ; UC1.CL10 161,28.85 ; UC1.BB9 146.82,27.97 ; UC1.BB9 146.82,28.39 ; UC1.BB9 146.4,27.97 ; UC1.BB9 146.15,28.64 146.15,28.64 ; 132.87,29.95 133,29.82 133.22,29.82 UC1.R12 ; UC1.CT11 162.87,29.32 ; UC1.CT11 163.29,29.31 ; UC1.CT11 162.87,28.89 ; UC1.CT11 163.29,28.9 ; UC1.CU10 163.33,28.43 ; UC1.CU10 163.33,28.86 ; UC1.CU10 163.74,28.44 ; UC1.CU10 163.74,28.85 ; 146.15,28.64 UC1.BA10 ; 144.32,28.64 UC1.AV9 ; 144.32,28.64 UC1.AU10 ; 145.24,28.64 UC1.AV9 ; 145.24,28.64 UC1.AW10 ; 145.69,29.1 145.69,29.1 UC1.AW10 ; 145.69,29.1 UC1.AY11 145.9,29.31 ; 145.69,29.1 UC1.BA10 ; 164.24,28.43 UC1.CW10 ; UC1.CW10 164.24,28.86 ; UC1.CW10 164.66,28.44 ; UC1.CW10 164.66,28.85 ; UC1.AU10 143.87,29.1 UC1.AT11 ; UC1.AU10 144.53,28.85 ; UC1.CM11 161.46,28.9 ; UC1.CM11 161.04,28.89 ; UC1.CM11 161.46,29.31 ; UC1.CM11 161.04,29.32 ; UC1.R12 133.47,29.82 133.7,29.82 133.76,29.88 133.8,29.84 134.16,29.84 UC1.U12 134.05,30.16 ; UC1.R12 133.55,30.15 ; UC1.R12 133.13,30.16 ; UC1.AT11 143.65,29.32 ; UC1.AT11 144.07,29.31 ; UC1.AT11 143.67,28.91 ; UC1.AV9 144.99,27.97 ; UC1.AV9 144.57,27.97 ; UC1.CR10 162.41,28.86 ; UC1.CR10 162.83,28.85 ; UC1.CR10 162.41,28.43 ; UC1.CR10 162.83,28.44 ; UC1.CN10 161.92,28.44 ; UC1.CN10 161.5,28.43 ; UC1.CN10 161.5,28.86 ; UC1.CN10 161.92,28.85 ; UC1.CP11 161.95,29.32 ; UC1.CP11 162.37,28.9 ; UC1.CP11 162.37,29.31 ; UC1.CP11 161.95,28.89 ; UC1.DF12 167.87,29.97 ; UC1.DF12 168.29,29.55 ; UC1.DF12 167.87,29.55 ; UC1.DF12 168.29,29.97 ; UC1.CY11 164.7,29.32 ; UC1.CY11 165.12,29.31 ; UC1.CY11 164.7,28.89 ; UC1.CY11 165.12,28.9 ; 167.22,29.55 UC1.DE12 ; UC1.DE12 167.22,29.97 ; UC1.DE12 167.64,29.97 ; UC1.DE12 167.64,29.55 ; UC1.AW10 145.24,28.64 145.04,28.84 ; UC1.BA10 146.36,28.85 ; 160.54,29.31 UC1.CK11 ; UC1.CK11 160.54,28.9 ; UC1.CK11 160.12,29.32 ; 163.78,28.89 UC1.CV11 ; UC1.CV11 164.2,29.31 ; UC1.CV11 163.78,29.32 ; UC1.CV11 164.2,28.9
  IN1 w0.254: v1(156.72,14.27) 156.72,14.99 156.22,15.49 v1(155.95,15.49)
  BOTTOM w0.081: v6(161.45,30.26) 161.54,30.17 v5(161.54,29.73)
  vias: v2(145.45,25.79) v2(149.87,25.68) v2(150.34,25.12) v2(150.92,25.29) v2(160.09,20.04) v2(163.61,20.42) v5(132.81,30.01) v5(133.19,30.58) v5(141.35,23.84) v5(143.45,29.39) v5(143.88,29.75) v5(144.32,29.36) v5(145.71,29.74) v5(146.15,29.34) v5(154.46,7.21) v5(155.04,7.21) v5(155.61,7.21) v5(156.18,7.21) v5(156.75,7.21) v5(158.08,9.24) v5(158.08,8.67) v5(158.66,9.24) v5(158.66,8.67) v5(159.23,9.24) v5(159.23,8.67) v5(159.8,9.24) v5(159.8,8.67) v5(160.81,7.28) v5(161.39,7.28) v5(161.96,7.28) v5(162.15,29.74) v5(162.53,7.28) v5(162.71,29.74) v5(163.1,7.28) v5(163.28,29.77) v5(163.88,29.77) v5(164.24,9.24) v5(164.24,8.67) v5(164.46,29.77) v5(164.82,9.24) v5(164.82,8.67) v5(165.07,29.74) v5(165.39,9.24) v5(165.39,8.67) v5(165.64,12.04) v5(165.64,11.47) v5(165.96,9.24) v5(165.96,8.67) v5(166.21,12.04) v5(166.21,11.47) v5(166.78,12.04) v5(166.78,11.47) v5(166.97,10.26) v5(166.97,9.69) v5(167.04,7.34) v5(167.36,12.04) v5(167.36,11.47) v5(167.55,10.26) v5(167.55,9.69) v5(167.61,7.34) v5(168.12,10.26) v5(168.12,9.69) v5(168.18,7.34) v5(168.69,10.26) v5(168.69,9.69) v5(168.75,7.34) v5(169.32,7.34)
+VCCIO_OUT: length 262.9
  TOP w0.254: v1(137.83,27.72) 137.65,27.72 UC1.AD7 ; QE15.1 200.08,56.62 199.83,56.36 v5(199.83,55.26)
  IN1 w0.254: v2(113.94,4.46) 114.29,4.46 114.97,3.79 118.32,3.79 120.03,2.08 126.64,2.08 126.89,2.34 158.99,2.34 159.53,1.8 207.21,1.8 210.94,5.52 210.94,10.73 212.11,11.9 212.11,13.4 v5(213.86,15.15) ; v2(136.73,20.59) 136.73,20.67 v1(137.1,21.04) ; v2(137.95,28.04) 137.83,27.91 v1(137.83,27.72)
  IN2 w0.254: v2(136.73,20.59) 136.65,20.59 136.21,20.15 136.21,16.76 130.83,11.38 116.63,11.38 115.92,10.66 115.92,7.53 113.95,5.56 113.95,4.48 v2(113.94,4.46)
  IN3 w0.254: v2(113.94,4.46) 113.95,4.45 v4(113.95,3.11) ; v4(126.02,16.39) v4(126.02,17.32) 127.65,17.32 130.15,19.81 135.88,19.81 136.65,20.59 v2(136.73,20.59) ; v4(134.08,28) 134.12,28.04 v2(137.95,28.04)
  BOTTOM w0.254: v4(126.02,17.32) 125.12,17.32 124.43,18.01 120.94,18.01 119.75,16.82 112.73,16.82 R246.1 ; v5(199.83,55.26) 199.83,50.58 196.21,46.96 193.69,46.96 193.34,46.61 193.34,29.04 194.49,27.89 197.15,27.89 v3(198.37,26.67) 199.85,25.19 202.5,25.19 203.12,24.57 207.88,24.57 208.3,24.99 209.9,24.99 211.26,26.35 211.56,26.35 212.74,27.53 216.22,27.53 217.76,26 217.76,25.33 218.47,24.62 220.97,24.62 221.62,23.98 221.62,21.54 222.46,20.7 222.46,16.85 220.97,15.37 214.08,15.37 v5(213.86,15.15) ; v4(134.08,28) RC724.1
  BOTTOM w0.381: v4(126.02,16.39) R274.1
+VCCLDOSTD_OUT_0P85: length 3.3
  TOP w0.254: CC185.1 CC260.1 176.36,42.77 175.4,41.81 UC1.DW37
+VCCPFUSE_3P3: length 4.9
  IN1 w0.254: v1(166.54,39.9) 166.85,39.9 v2(167.25,40.3)
  IN3 w0.254: v4(167.46,40.77) 167.25,40.56 v2(167.25,40.3)
  BOTTOM w0.508: v4(167.46,40.77) 168.16,40.77 168.82,41.42 v6(168.82,41.95) RC747.2
+VCCPRIM_1P8: length 13.6
  TOP w0.127: UC1.DF17 167.87,32.46 ; UC1.DF17 168.29,32.46 ; UC1.DF17 167.89,32.06 ; UC1.DF17 168.29,32.04 ; UC1.DF18 167.89,32.89 ; UC1.DF18 167.87,33.29 ; UC1.DF18 168.29,33.29 ; UC1.DF18 168.29,32.87 ; UC1.DF20 167.89,33.72 ; UC1.DF20 168.29,34.12 ; UC1.DF20 168.29,33.7 ; UC1.DF20 167.87,34.12 ; UC1.DF15 168.29,31.63 ; UC1.DF15 168.29,31.21 ; UC1.DF15 167.87,31.63 ; UC1.DF15 167.89,31.23 ; UC1.DG18 168.94,32.87 ; UC1.DG18 168.54,32.89 ; UC1.DG18 168.94,33.29 ; UC1.DG18 168.52,33.29 ; UC1.DG17 168.54,32.06 ; UC1.DG17 168.94,32.04 ; UC1.DG17 168.94,32.46 ; UC1.DG17 168.52,32.46 ; UC1.DG20 168.94,34.12 ; UC1.DG20 168.54,33.72 ; UC1.DG20 168.52,34.12 ; UC1.DG20 168.94,33.7
  TOP w0.254: v1(167.91,40.36) 167.66,40.11 167.27,40.11 167.03,39.87 167.03,38.58 v5(166.91,38.47)
  IN1 w0.254: v1(167.91,40.36) 167.91,40.51 167.4,41.01 v1(166.99,41.01)
  IN3 w0.254: v4(176.52,33.09) 176.78,33.09 v2(176.91,33.23)
  BOTTOM w0.081: v4(183.48,32.61) 183.55,32.68 CC175.1 ; v5(166.45,34.66) v3(166.45,35.15)
  vias: v1(181.58,33.2) v1(181.58,32.94) v1(181.9,33.2) v1(181.9,32.94) v1(182.21,33.2) v1(182.21,32.94) v2(181.26,32.49) v2(181.77,32.55) v2(182.21,32.55) v2(182.66,32.55) v4(182.28,33.34) v4(182.91,33.34) v4(183.04,32.93) v4(183.36,32.93) v5(166.45,34.03) v5(166.45,33.39) v5(166.45,32.76) v5(166.45,32.12)
+VCCPRTC_3P3: length 0.8
  IN1 w0.254: v2(169.01,39.94) 168.96,39.94 168.74,39.72 v1(168.73,39.72)
  IN3 w0.254: v4(169.39,39.98) 169.04,39.98 v2(169.01,39.94)
  vias: v3(170.28,39.85)
+VCCST_CPU: length 20.7
  TOP w0.635: RC630.2 RC592.1 137.7,19.15 137.95,18.9 138.15,18.9 v3(139.35,17.69) 139.48,17.56 v1(139.99,17.56)
  IN1 w0.762: v1(139.99,17.56) 141.03,18.61 149.48,18.61 150.34,19.47 154.47,19.47 155.08,20.09
  vias: v1(155.38,21.44) v1(155.38,20.8)
+VCCST_R:
  vias: v3(134.08,19.34)
+VCCSTG_CPU: length 52.1
  TOP w1.016: 128.77,17.52 127.86,17.52 v3(122.23,11.89) v5(122.23,7.87)
  IN1 w0.381: v1(122.27,7.05) v1(122.71,7.05) v2(123.29,7.05)
  IN2 w0.762: v5(122.23,7.87) 124.67,10.31 131.66,10.31 138.85,17.5 147.8,17.5 152.5,22.2 154.53,22.2
  vias: v1(154.69,21.44) v1(154.69,20.8) v2(155.23,22.13) v2(155.54,22.52)
+VCCSTG_OUT: length 5.2
  TOP w0.127: 134.47,40.72 UC1.U35 134.05,40.71 ; UC1.V34 134.92,40.26 ; UC1.V34 134.5,40.25 ; UC1.V34 134.5,40.68 ; UC1.V34 134.92,40.67 ; v1(136.55,40.46) 136.75,40.26 ; v1(136.55,40.46) 136.34,40.68 ; v1(136.55,40.46) 136.34,40.25 ; UC1.T34 133.59,40.25 ; UC1.T34 133.59,40.68 ; UC1.T34 134.01,40.67 ; UC1.T34 134.01,40.26 ; 133.55,40.72 UC1.R35 133.13,40.71
  IN1 w0.254: v1(136.55,40.46) v2(136.55,40.11)
  IN3 w0.254: v4(136.24,39.85) 136.29,39.85 v2(136.55,40.11)
  vias: v5(133.26,40.42) v5(134.27,40.3) v5(135.16,40.3) v6(132.38,39.95)
+VCCSTG_OUT_LGC: length 6.4
  TOP w0.762: RC659.1 128.43,20.4 128.41,20.42 128.41,23.28 v1(128.73,23.6)
  IN1 w0.762: v1(128.73,23.6) 128.54,23.78 128.54,25.81 128.4,25.96 v1(128.4,26.2)
+VCCSTG_R:
  vias: v3(129.76,15.72)
+VDDQ_MEM: length 46.6
  TOP w0.25: v5(120.33,56.66) UD4.W12 ; v5(154.71,66.41) v1(156.01,66.41) ; v5(124.37,66.41) UD3.D1 ; UD2.W12 141.83,66.41 v5(141.19,65.77) ; UD1.D1 166.07,56.66 v5(166.28,56.87) ; v5(109.12,66.41) UD4.D1 ; v5(151.75,56.57) 151.66,56.66 UD2.D1
  TOP w0.254: v5(165.53,66.69) 165.48,66.69 165.2,66.41 UD1.W1 ; UD2.D12 142.24,56.66 v5(141.99,56.91) 141.28,56.91 141.11,56.74 CD91.1 ; UD4.W1 109.51,56.66 v5(109.1,56.25) 109.06,56.21 CD26.1 ; CD41.1 120.9,66.67 v5(120.56,66.33) 120.13,66.33 120.05,66.41 v1(119.22,66.41) ; UD2.W5 v1(147.77,66.13) ; UD3.D12 135.11,66.41 v5(135.22,66.3) ; UD4.F3 112.1,65.11 v1(112.31,64.9) ; v1(126.58,65.35) 126.6,65.35 UD3.F3 ; UD3.W1 124.53,56.66 v5(124.52,56.65) 124.35,56.65 123.84,56.13 CD39.1 ; CD42.1 135.73,56.2 v5(135.21,56.71) 135.16,56.66 UD3.W12 ; v1(151.23,66.41) v5(152.52,66.41) ; v5(124.37,66.41) 123.82,66.95 CD40.1
  TOP w0.356: CD78.1 v5(158.38,71.23)
  IN1 w0.203: v2(157.95,57.77) 157.95,57.76 157.76,57.76 v1(157.61,57.91)
  IN1 w0.254: v1(116.02,67.71) v2(115.54,67.71) ; v1(116.02,66.41) v2(115.54,66.41) ; v1(112.31,64.9) 112.3,64.91 111.67,64.91 v2(111.65,64.9) ; v2(151.59,68.87) 151.59,69.81 151.18,70.23 v1(151.18,70.71) ; v1(161.61,66.41) 161.66,66.41 v2(161.96,66.71) ; v2(129.37,66.66) 129.12,66.41 v1(128.48,66.41) ; v1(145.63,56.66) 145.94,56.66 v2(146.07,56.79) ; v2(146.08,66.71) 145.78,66.41 v1(145.63,66.41) ; v2(157.26,65.45) 157.26,65.37 157.56,65.07 v1(157.59,65.07) ; v1(128.48,67.71) 128.73,67.71 v2(128.81,67.79) ; v2(159.67,67.41) 159.37,67.71 v1(159.21,67.71) ; v2(159.67,66.84) 159.24,66.41 v1(159.21,66.41) ; v1(113.62,67.71) v2(113.96,67.71) ; v2(147.28,68.03) 147.28,68.03 147.28,68.03 147.7,68.03 v1(148.03,67.71) ; v2(144.61,69.92) 144.52,70.01 144.52,70.7 v1(144.53,70.71) ; v2(130.53,66.71) 130.83,66.41 v1(130.88,66.41) ; v2(161.26,67.43) 161.34,67.43 v1(161.61,67.71) ; v2(126.54,65.02) 126.58,65.06 v1(126.58,65.35) ; v1(149.63,67.71) v2(149.89,67.98) ; v2(126.42,68.09) 126.5,68.09 v1(126.88,67.71) ; v2(130.4,67.71) 130.4,67.71 v1(130.88,67.71) ; v2(119.6,66.33) 119.3,66.33 v1(119.22,66.41) ; v2(157.2,67.98) 157.34,67.98 v1(157.61,67.71) ; v2(145.96,68.03) 145.63,67.71 v1(145.63,67.71) ; v1(148.98,70.71) v2(148.98,69.89) ; v1(113.62,56.66) 113.78,56.66 v2(114.02,56.42) ; v1(151.23,66.41) 151.3,66.49 v2(151.67,66.49) ; v1(156.01,66.41) v2(155.67,66.41) ; v1(162.69,70.71) v2(162.69,71.05) ; v2(143.65,58.04) 143.97,58.04 v1(144.02,57.98) ; v1(147.77,66.13) v2(147.34,66.13)
  IN3 w0.254: v2(148.98,69.89) 148.99,69.9 v4(149.36,69.9) ; v2(162.69,71.05) v4(162.69,71.4) ; v4(145.1,69.9) 144.63,69.9 v2(144.61,69.92) ; v4(151.15,69.82) 151.59,69.37 v2(151.59,68.87)
  vias: v5(105.7,63.28) v5(105.7,62.65) v5(106.27,63.28) v5(106.27,62.65) v5(109.19,67.28) v5(114.46,52.87) v5(127.86,71.03) v5(131.54,71.03) v5(132.24,71.03) v5(132.89,71.05) v5(134,71.05) v5(135.34,71.04) v5(155.53,55.68) v5(155.51,54.37) v5(158.86,54.09) v5(163.61,56.32) v5(164.29,69.85) v5(164.42,56.35) v5(165.96,70.59) v6(119.48,69.82)
+VIN_3V3_L_TBT: length 5.8
  TOP w0.203: CPD5.1 9.42,17.63 9.89,17.63 UPD1.5
  TOP w0.381: RPD84.2 8.57,16.06 8.19,16.06 RPD114.2 7.85,16.4 7.85,16.94 8.5,17.58 9.03,17.58 CPD5.1
+VIN_3V3_R_TBT: length 5.5
  TOP w0.203: CP10.1 276.46,14.55 UPD2.5
  TOP w0.254: CP10.1 276.28,14.7 275.76,15.22 275.06,15.22 274.44,14.6 RPD93.2
  TOP w0.356: RPD93.2 274.21,14.28 RPD115.2
AGND: length 17.8
  TOP w0.203: UA1.22 v8(33.81,17.63) ; UA1.37 26.53,18.43 26.45,18.52 26.45,19.28 v5(26.58,19.4)
  TOP w0.254: v5(25.65,21.27) 25.83,21.09 CA17.1
  TOP w0.508: v5(24.44,55.45) 23.93,55.45 22.91,56.48 CA78.2 ; CA82.2 20.89,30.9 v5(21.73,31.74) ; v5(21.78,53.67) 21.78,53.66 21.31,53.19 CA79.2 ; CA20.1 25.56,20.18 25.65,20.27 v5(25.65,20.48) ; CA80.2 24.1,19.79 24.29,19.98 v5(24.48,19.98) ; CA83.2 16.42,67.8 v5(18.46,67.8)
  IN1 w0.254: v8(35.15,17.66) 35.49,17.66 v2(35.53,17.63) 35.58,17.58 v8(35.91,17.58) ; v8(36.11,18.52) v2(36.61,18.52) 36.66,18.46 v8(37.05,18.46) ; v2(24.1,18.2) 24.1,18.59 v8(24.04,18.65) ; v2(24.35,19.34) 24.45,19.44 v8(24.8,19.44)
  IN3 w0.254: v2(35.28,16.99) v9(35.28,16.62) ; v9(23.92,18.58) 24.1,18.4 v2(24.1,18.2)
  BOTTOM w0.081: v6(23.78,19.98) v5(24.48,19.98) ; v6(23.93,54.94) v5(24.44,55.45) ; v6(21.35,31.36) v5(21.73,31.74)
  vias: v8(10.41,70.38) v8(10.41,69.87) v8(10.98,70.38) v8(10.98,69.87) v8(24.8,18.24) v8(34.61,20.43) v8(37.5,16.69) v9(7.23,75.12) v9(7.23,73.95) v9(7.8,75.72) v10(12.77,72.62) v10(14.79,70.08) v10(28.86,22.08) v10(31.85,21.47) v10(32.42,21.47) v11(9.29,74.63) v11(9.39,73.95) v11(10.96,74.47) v11(21.12,63.16)
DV12S: length 3.8
  TOP w0.508: 280.49,21.46 278.06,21.46 277.77,21.75 277.77,22.73
GND: length 4505.9
  TOP w0.081: v10(173.79,31.33) 174.16,30.96 175.29,30.96 175.37,30.88 175.93,30.88
  TOP w0.089: 175.15,31.81 175.05,31.71 174.17,31.71 v10(173.79,31.33)
  TOP w0.102: PC509.2 v6(201.14,18.38) ; v6(93.5,38.91) 93.64,39.06 PC1209.2 ; v6(131.72,7.37) 132.01,7.09 v5(133.07,7.09) ; PC1013.2 v6(172.41,10.65) ; v8(199.47,11.11) 199.45,11.14 v6(199.45,11.88)
  TOP w0.152: v5(12.44,42.57) URT1.H1 URT1.H2 ; URT2.F2 URT2.F1 v5(279.39,34.64) ; URT1.D2 URT1.D1 v5(10.6,42.57) ; URT2.A11 v5(276.6,39.76) ; v5(282.4,41.22) 282.12,41.22 281.79,40.88 281.79,40.49 281.69,40.4 URT2.L12 ; URT2.D2 URT2.D1 v5(278.47,34.64) ; v5(13.56,57.44) 13.3,57.7 D82.1 v5(13.77,57.97) ; URT1.F2 URT1.F1 v8(11.52,42.57) ; v5(9.61,48.75) 9.68,48.68 URT1.B12 ; v5(281.23,34.62) 281.23,34.63 URT2.K1 URT2.K2 ; URT2.D11 URT2.D12 v5(278.47,40.73) ; v5(11.52,48.66) URT1.F12 URT1.F11 ; URT1.D11 URT1.D12 v5(10.6,48.68) ; URT2.H2 URT2.H1 v5(280.31,34.64) ; v5(279.39,40.74) URT2.F12 URT2.F11 ; URT1.K11 URT1.K12 v5(13.36,48.66) ; URT1.L12 13.82,48.32 14.15,48.64 v5(14.3,48.64) 14.3,48.61 14.28,48.59 URT1.M12 ; URT2.K11 URT2.K12 v5(281.23,40.72) ; v5(8.82,47.95) 9.08,47.69 URT1.A11 ; v5(11.4,57.97) D80.1 11.9,57.68 v5(11.65,57.44) ; URT1.H11 URT1.H12 v5(12.44,48.66) ; v5(13.36,42.55) 13.36,42.55 URT1.K1 URT1.K2 ; URT2.H11 URT2.H12 v5(280.31,40.74) ; v5(282.17,40.72) 282.17,40.68 282.15,40.67 URT2.M12 ; URT2.B12 277.55,40.65 v5(277.48,40.73)
  TOP w0.165: UC1.A36 v10(126.36,41.49) UC1.A36 ; UC1.A36 v5(124.99,41.49) ; UC1.A42 v10(126.36,44.11) UC1.A42 ; UC1.A42 125.42,44.11 125.39,44.14 124.96,44.14 v5(124.84,44.02) ; UC1.A39 v10(126.36,42.8) ; UC1.A39 v10(126.36,42.8) ; UC1.A39 124.57,42.8 v5(123.36,44.01) ; v10(126.36,42.8) v10(127.04,42.8)
  TOP w0.2: v8(131.01,41.39) v8(130.36,41.39) v8(129.71,41.39) v8(129.06,41.39) 128.41,41.39 v10(128.31,41.49)
  TOP w0.203: UC1.BA45 146.15,46.02 v10(146.15,46.02) ; v10(174.44,27.4) UC1.DU7 UC1.DT7 172.81,27.73 v10(172.81,28.05) 172.81,28.13 173.08,28.4 v8(173.41,28.4) 173.72,28.71 v10(173.79,28.71) v10(174.44,28.71) ; v8(14.77,19.31) 15.81,18.27 15.81,18.02 UPD1.20 16.71,17.12 v8(16.82,17.12) ; v5(137.4,82.65) 137.4,82.71 136.9,83.21 JEDP1.11 ; v8(279.62,36.39) 279.96,36.72 ; 279.96,36.72 279.64,37.04 v8(279.62,37.04) ; 279.96,36.72 URT2.G5 ; JEDP1.5 139.3,83.43 140.15,82.57 v5(140.15,82.38) ; U34.11 v8(174.98,69.6) ; JUFC1.28 156.7,83.53 v5(155.56,82.38) ; U31.11 v10(203.99,14.42) ; v8(195.57,64.36) 195.57,64.03 194.12,62.58 194.12,54.3 194.53,53.88 194.53,53.71 194.74,53.5 195.19,53.5 195.38,53.69 195.38,54.33 194.61,55.11 194.61,62.38 196.58,64.35 196.58,66.06 v8(196.48,66.16) ; JEDP1.24 v10(131.7,83.3) ; JEDP1.17 134.5,82.81 v5(134.34,82.65) ; v8(12.98,21.09) 11.93,22.15 11.68,22.15 UPD1.51 10.87,22.96 v10(10.7,22.96) ; 170.16,51.36 169.73,51.79 169.03,51.79 168.88,51.94 CH13.2 ; PU1200.13 102.76,34.48 v8(102.55,34.26) ; v5(277.55,34.67) URT2.B1 URT2.B2 ; URT1.B2 URT1.B1 v5(9.68,42.59) ; PU1201.13 102.74,25.35 v8(102.43,25.04) ; v10(281.01,9.23) 281.23,9.46 UPD2.20 281.23,12.11 v8(281.41,12.29) ; v5(138.72,82.46) 138.72,82.7 138.1,83.32 JEDP1.8 ; v8(281.41,14.82) 281.23,14.99 UPD2.51 ; v5(135.99,82.65) 135.7,82.94 JEDP1.14 ; UD3.P3 126.65,60.11 v8(126.64,60.18) ; JEDP1.30 v8(129.3,83.42) ; JEDP1.31 v8(128.9,83.4) ; UC1.T45 133.65,45.61 v1(133.43,45.41) ; UD1.K4 v8(162.41,60.93)
  TOP w0.229: v10(221.11,47.24) 220.92,47.05 QC2.1 ; QC2.4 v10(220.22,45.56)
  TOP w0.254: USSD1.E2 v5(194.3,44.07) USSD1.E1 ; USSD1.N4 196,38.37 v5(195.93,38.37) 195.8,38.37 USSD1.N3 ; USSD1.E6 v5(198.29,44.86) ; USSD1.AA2 v5(195.1,31.27) USSD1.AA3 ; v5(133.25,29.39) 133.7,29.39 v8(133.8,29.48) ; v10(162.42,41.66) 162.74,41.34 v5(162.91,41.34) 163.01,41.34 v10(163.33,41.66) 163.41,41.66 v5(163.75,41.32) 163.93,41.32 v10(164.25,41.01) ; v8(87.21,16.98) 87.23,16.95 v8(87.23,16.1) ; v8(18.28,48.55) v8(18.28,49.19) v8(18.28,49.82) 18.28,50.33 v8(18.04,50.57) v8(16.1,50.57) ; v8(18.28,48.55) 17.94,48.55 17.78,48.71 YT1.2 17.52,48.14 17.72,47.94 CT43.2 17.85,47.66 v10(18.28,47.66) ; v8(18.28,48.55) v10(18.28,47.66) ; UC1.BF45 v10(148.66,46) ; v5(158.05,27.74) 157.6,28.18 v10(157.59,28.18) ; v5(159.09,41.24) 159.25,41.24 v10(159.67,41.66) ; v10(164,28.18) 163.65,27.84 v8(163.53,27.84) 163.43,27.84 v10(163.08,28.18) ; USSD1.W1 v5(193.9,32.79) ; CE429.2 268.23,9.11 269.12,8.22 v8(269.17,8.22) ; USSD1.C2 194.7,45.78 v5(194.47,45.54) 193.94,46.07 USSD1.C1 ; v10(85.48,58.83) 85.49,58.81 v10(85.49,57.86) 85.49,57.01 v8(85.47,56.99) ; v5(289.48,31.34) 289.26,31.13 UT2.5 ; USSD1.C4 v5(196.7,45.67) USSD1.C5 ; UC1.DL13 170.68,30.49 v10(170.34,30.83) ; v10(159.67,41.66) 159.78,41.66 v5(160.12,41.32) 160.45,41.66 v10(160.59,41.66) ; v10(159.67,41.66) 159.54,41.79 v5(159.07,41.79) ; 287.56,41.63 287.54,41.61 YT2.4 288.26,40.93 288.26,40.93 ; 287.56,41.63 v8(286.99,41.63) v8(285.72,41.63) 285.47,41.38 CT45.2 284.93,41.16 284.82,41.27 v8(284.41,41.27) 284.39,41.25 284.15,41.25 v8(283.35,40.44) v8(282.77,39.87) ; 287.56,41.63 288.04,41.63 288.26,41.41 288.26,40.93 ; v8(129.28,38.75) 129.67,38.36 v5(129.67,38.29) 129.93,38.55 v8(129.93,38.75) ; v8(129.93,34.17) 129.93,34.05 v5(129.61,33.73) 129.28,34.06 v8(129.28,34.17) ; v5(136.94,28.56) 136.95,28.56 137.19,28.56 v10(137.46,28.83) 137.4,28.83 v5(137.03,29.21) ; v8(87,20.23) 87.05,20.27 v8(87.9,20.27) ; v10(18.28,47.66) 18.28,47.05 18.02,46.8 v10(17.96,46.8) 17.75,46.8 17.57,46.62 v8(16.86,46.62) 15.37,46.62 v8(15.32,46.57) 14.69,46.57 v10(14.64,46.52) ; v10(132.6,29.53) 132.6,29.38 v5(132.32,29.09) 131.95,28.73 v10(131.95,28.62) ; USSD1.R3 195.8,36.77 v5(195.93,36.77) 196,36.77 USSD1.R4 ; v5(144.8,29.74) 144.78,29.72 v10(144.78,29.11) 144.9,29.11 145.15,29.36 v5(145.27,29.36) ; 170.16,51.36 170.16,48.46 v5(169.9,48.19) 169.92,48.17 UC1.DK49 ; 286.42,38.83 v8(286.86,38.83) 288.11,38.83 v8(288.37,39.09) 288.37,39.9 288.26,40 v8(288.26,40.49) 288.26,40.93 ; 286.42,38.83 286.44,38.86 YT2.2 285.84,39.53 285.62,39.3 CT44.2 ; 286.42,38.83 285.72,38.83 285.47,39.09 CT44.2 ; v8(94.46,63.03) 94.39,63.07 PR704.2 ; USSD1.G1 v5(194.3,42.47) USSD1.G2 ; USSD1.J1 v5(194.3,40.87) USSD1.J2 ; v10(134.71,28.18) v10(135.63,28.18) 135.95,28.5 v5(136.13,28.5) ; v8(176.57,30.88) 176.93,30.88 177.13,31.09 178.85,31.09 179.08,31.32 v10(179.48,31.32) 179.48,31.53 179.93,31.98 182.21,31.98 182.47,31.72 ; v8(176.57,30.88) 175.93,30.88 ; v8(176.57,30.88) 176.48,30.8 v8(176.48,29.73) v8(175.85,29.1) v8(175.17,28.42) 174.78,28.42 174.49,28.71 v10(174.44,28.71) ; UD3.AB5 128.79,54.71 v8(128.84,54.76) ; v5(147.99,25.82) 147.57,26.23 v8(147.52,26.23) 147.4,26.23 v5(147.13,25.96) 146.75,25.58 v10(146.61,25.58) ; v5(147.99,25.82) 148.2,25.82 v10(148.44,25.58) 148.68,25.58 148.86,25.77 v5(148.91,25.77) 149.17,25.77 v10(149.36,25.58) ; v5(147.99,25.82) 147.75,25.58 v8(147.52,25.58) ; v8(15.34,47.79) v10(14.98,47.43) ; v8(15.34,47.79) CT42.2 ; v8(15.34,47.79) v8(15.34,48.55) v8(15.34,49.19) v8(15.34,49.82) ; UD1.T1 v8(165.17,64.46) ; v8(196.92,6.17) 196.92,6.58 196.66,6.84 PU1500.9 ; v5(146.53,29.77) 146.61,29.68 v10(146.61,29.11) ; PR1133.2 v8(102.92,45.72) 103.62,45.72 PR1134.2 ; v10(174.44,27.4) 175.11,27.4 v8(175.18,27.32) 175.48,27.32 v8(175.98,27.82) v8(176.63,28.48) v8(177.26,29.1) 177.66,29.5 v8(178.13,29.5) 179.45,29.5 CH10.1 180.14,28.8 v10(181.07,28.8) 182.09,28.8 182.47,29.18 v10(182.47,30.64) 182.47,31.72 ; UD3.N11 v8(133.66,60.56) ; PC1106.2 104.01,47.02 v8(102.94,47.02) ; USSD1.AA4 v5(196.74,31.23) 197.1,31.58 USSD1.AA5 ; UD3.V5 v10(128.85,57.31) ; v5(129.04,30) 129.04,29.87 v8(128.7,29.53) 128.7,29.4 v5(129,29.11) ; v8(127.34,34.17) 127.34,34.07 v5(126.99,33.73) 126.99,33.86 v8(126.69,34.17) 126.37,33.86 v5(126.37,33.72) ; v8(130,28.62) 130,28.78 v5(130.32,29.09) 130.32,29.2 v10(130.65,29.53) 130.98,29.2 v5(130.98,29.07) ; PR409.2 24.56,4.26 25.31,3.51 v8(25.31,3.45) 26.13,3.45 CE413.2 26.21,3.38 v8(26.21,2.64) ; v8(139.08,13.44) 139.66,12.86 140.02,12.86 140.18,12.7 140.56,12.7 140.81,12.44 PU900.19 ; v5(155.29,29.51) 155.28,29.5 154.44,29.5 154.04,29.11 v8(153.93,29.11) ; v5(137.03,29.21) 136.82,29.21 v10(136.55,29.48) ; v5(137.03,29.21) 137.19,29.21 v10(137.46,29.48) ; PR908.2 142.81,13.93 v8(142.81,13.93) ; v10(72.84,18.31) 72.82,18.29 v10(71.93,18.29) ; CH13.2 168.83,52.17 v8(168.36,52.63) 168.35,52.65 168.35,53.83 v8(168.36,53.85) 168.36,54.58 168.39,54.61 168.39,54.62 168.52,54.76 168.54,54.76 168.62,54.84 v8(168.82,54.84) v8(170.76,54.84) v10(172.31,54.84) 172.53,54.61 v10(172.53,53.5) 172.53,52.65 v10(171.93,52.04) 171.85,51.97 v8(171.85,49.83) ; v8(124.82,63.16) UD3.J1 ; USSD1.L1 v5(194.3,39.27) USSD1.L2 ; v5(158.06,41.32) 157.93,41.32 v8(157.59,41.66) ; v8(283.8,39.47) v8(284.81,39.47) 285.3,39.47 CT44.2 ; v8(15.34,49.82) v8(15.34,50.46) 15.45,50.57 v8(16.1,50.57) ; v8(15.34,49.82) 15.34,49.81 YT1.4 16.12,50.54 v8(16.1,50.57) ; UD3.K11 v8(133.28,62.15) ; 182.47,31.72 182.57,31.82 v10(182.57,33.64) 182.57,35.17 182.4,35.34 181.64,35.34 v10(181.39,35.59) v10(181.39,37.37) 181.3,37.46 181.3,37.47 181.17,37.6 181.16,37.6 181.13,37.63 v10(179.25,37.63) 178.8,37.63 177.9,36.72 v10(177.9,36.47) v10(177.9,34.58) 177.9,32.77 177.46,32.33 v10(177.45,32.33) 176.44,32.33 175.92,31.81 175.15,31.81 ; v10(166.44,26.17) 166.44,26.58 v10(166.74,26.88) 167.11,27.25 v5(167.13,27.25) 167.28,27.25 v10(167.66,26.88) ; v8(87.23,15.28) 87.23,15.28 v8(87.23,16.1) ; v8(153.93,29.11) 153.93,29.7 v5(153.91,29.73) ; v8(153.93,29.11) 153.67,29.11 v5(153.46,29.31) ; v8(153.93,27.53) 153.65,27.25 v5(153.5,27.25) 153.29,27.25 v8(153.02,27.53) ; PU500.9 210.13,19.05 210.05,18.98 v10(210.05,18.87) ; UD3.P1 124.95,59.91 v10(124.9,59.9) ; v8(155.3,41.85) 155.34,41.81 v5(155.34,41.15) ; PU800.9 81.25,66.34 v8(81.55,66.04) ; v8(129.93,36) 129.93,35.9 129.64,35.6 v5(129.64,35.55) 129.28,35.9 v8(129.28,36) 128.99,35.71 v5(128.99,35.55) ; USSD1.G3 v5(195.9,42.47) ; UD1.D9 v10(158.7,56.43) ; UC1.L45 v10(130.72,45.63) ; v8(94.23,17.05) 94.12,16.94 PC231.2 v8(92.8,16.92) v8(91.55,16.92) ; v10(155.76,27.53) 155.81,27.53 v5(156.23,27.11) 156.65,27.53 v8(156.68,27.53) ; v10(140.99,24.85) 141.06,24.85 v8(141.33,24.59) 141.6,24.85 v10(141.64,24.85) ; v8(87.23,16.1) PC241.2 ; v5(127.65,35.57) 127.34,35.89 v8(127.34,36) ; USSD1.W2 v5(195.1,32.87) USSD1.W3 ; v10(168.92,24.53) v8(168.92,25.18) 168.92,25.75 v10(168.91,25.75) 168.92,25.76 v10(168.92,26.17) ; USSD1.U5 USSD1.U4 v5(195.9,34.47) USSD1.U3 v5(195.1,34.47) USSD1.U2 v5(194.33,34.5) 193.96,34.87 USSD1.U1 ; v5(279.43,31.66) 279.27,31.5 QR1.3 ; USSD1.J4 v5(195.9,40.87) USSD1.J3 ; v10(142.94,24.85) 142.94,24.81 142.69,24.56 v8(142.63,24.56) ; USSD1.N1 v5(194.3,37.67) USSD1.N2 ; USSD1.R1 v5(194.3,36.07) USSD1.R2 ; v10(128.31,42.8) 127.7,42.8 v5(127.64,42.85) 127.59,42.8 v10(127.04,42.8) ; v5(129,38.29) 129,38.38 v8(128.63,38.75) 128.35,38.47 v5(128.35,38.29) 127.99,38.66 v8(127.99,38.75) 127.69,38.46 v5(127.69,38.29) 127.34,38.65 v8(127.34,38.75) 127.03,38.45 v5(127.03,38.29) 126.69,38.64 v8(126.69,38.75) 126.37,38.44 v5(126.37,38.29) 126.04,38.63 v8(126.04,38.75) 125.69,38.4 v5(125.69,38.3) ; RH5.2 v10(178.98,24.36) ; UD4.T12 119.2,58.62 118.89,58.52 v8(118.88,58.49) ; v9(280.89,69.53) v8(281.22,69.2) ; v8(110.07,64.43) 110.1,64.46 UD4.G1 ; UE1.A13 v5(217.7,65.96) ; USSD1.C3 v5(195.9,45.67) ; U60.5 v5(266.13,20.71) ; UE6.4 v5(210.94,49.9) ; v5(151.65,29.32) 151.43,29.11 v8(151.19,29.11) 151.19,29.7 v5(151.2,29.72) ; v8(159.68,58.61) UD1.G8
  TOP w0.305: JDEBUG1.5 v8(228.51,5.82) ; UWL1.96 181.27,71.67 v5(181.53,71.41) 181.77,71.65 UWL1.95 ; UWL1.75 191.22,70.87 v5(191.05,71.04) 191.38,71.37 UWL1.76 ; UWL1.88 185.27,71.61 v5(185.47,71.41) 185.77,71.72 UWL1.87 ; PU700.12 94.92,62.74 v8(94.46,63.03) ; v5(58.86,16.35) JFP1.4 ; UWL1.91 183.77,71.67 v5(183.51,71.41) 183.27,71.65 UWL1.92 ; UWL1.85 186.77,71.7 v5(186.48,71.41) 186.27,71.62 UWL1.86 ; UWL1.20 180.88,61.87 v5(181.01,61.74) ; UWL1.94 182.27,71.68 v5(182.55,71.41) 182.77,71.64 UWL1.93 ; UWL1.84 187.27,71.64 v5(187.5,71.41) 187.77,71.68 UWL1.83 ; UWL1.90 184.27,71.67 v5(184.53,71.41) 184.77,71.66 UWL1.89 ; JDEBUG1.8 228.75,4.32 228.44,4.63 v8(228.44,4.74) ; UWL1.82 188.27,71.65 v5(188.52,71.41) 188.77,71.67 UWL1.81 ; UWL1.80 189.27,71.67 v5(189.53,71.41) 189.77,71.65 UWL1.79 ; UWL1.78 190.27,71.67 v5(190.53,71.41) 190.77,71.65 UWL1.77
  TOP w0.356: v5(267.14,25.18) 266.74,25.59 R667.1 ; C37.2 105.79,68.9 105.79,68.9 v8(105.78,68.9) ; CH55.1 175.94,50.58 175.6,50.23 v5(175.6,49.88) ; RD26.2 168.39,57.76 v5(168.51,57.89) ; C801.2 264.64,18.2 264.36,17.92 264.35,17.92 264.32,17.89 v8(264.26,17.89) ; v5(285.93,37.06) RT4.1 RT3.1 ; v5(199.69,63.88) 199.72,63.85 CE68.1 ; R6152.1 v5(205.53,50.27) ; RC612.1 136.96,3.5 136.68,3.78 v8(136.68,4.1) ; CA13.2 CA48.2 ; CA13.2 RA30.2 ; CA13.2 v10(22.49,21.82) ; CT212.1 v5(289.69,33.5) ; RW34.1 v8(195.57,64.36) ; v8(285.5,23.98) CR13.2 285.5,25.08 285.21,25.37 v10(284.23,25.37) ; RE480.2 v5(215.06,49) ; RT34.2 RT33.2 274.16,39.34 v5(273.98,39.17) ; v5(200.45,61.17) 200.47,61.19 RE157.1 ; CD68.2 v5(168.51,57.12) ; PC911.2 v8(141.73,4.99) ; CT317.1 280.8,71.5 v5(280.39,71.09) ; CC721.2 v5(108.59,45.69) ; v8(139.6,4.05) 139.6,3.86 139.24,3.5 RC611.1 ; v5(194.64,24.29) 194.98,24.64 R680.2 ; CPD13.2 v5(283.99,7.27)
  TOP w0.381: C1131.2 176.91,15.89 v5(176.46,15.89) ; v8(66.18,4.18) 66.17,4.19 JFAN1.5 ; CA80.1 v10(22.88,19.21)
  TOP w0.406: UH1.3 176.98,55.23 v5(177.27,54.94)
  TOP w0.508: RE520.2 216.36,72.43 v5(216.33,72.47) ; PC244.2 v5(218.97,71.8) ; CA83.1 v5(15.14,67.79) ; JSPK1.9 14.31,2.69 v5(13.81,2.2) ; RR1.1 274.99,23.79 v5(274.73,24.04) ; CT210.2 v5(289.48,31.34) ; v5(189.32,43.24) 189.07,42.99 C750.2 ; v5(91.43,60.62) 91.43,60.05 PC713.2 ; 288.51,29.31 v5(289.59,29.31) ; UWL1.G1 v5(180.52,72.8) ; C41.2 v8(108.11,70.97) ; CA78.1 v5(21.99,56.01) ; PC715.2 v5(100.81,64.87) ; SW1.4 v5(68.61,26.52) ; SW1.2 v5(68.61,25.63) ; UWL1.G4 v5(191.52,72.8) ; QE23.3 v8(216.52,70.2) ; v10(288.94,42.01) CR24.2 ; Q348.3 183.16,16.34 v5(183.61,15.89) ; JSPK1.10 v5(6.11,2.37)
  GND1 w0.203: H20.1 201.56,70.84 ; H20.1 201.91,71.85 ; H20.1 199.54,72.86 ; H20.1 199.54,70.84 ; H20.1 200.55,73.21 ; H20.1 199.19,71.85 ; H20.1 200.55,70.49 ; H20.1 201.56,72.86 ; H8.1 4.75,53.35 ; H8.1 1.05,53.35 ; H8.1 1.54,51.99 ; H8.1 1.54,54.71 ; H8.1 4.26,54.71 ; H8.1 2.9,55.2 ; H8.1 2.9,51.5 ; H8.1 4.26,51.99 ; H15.1 111.8,80.2 ; H15.1 110.55,80.65 ; H15.1 112.25,78.95 ; H15.1 109.3,80.2 ; H15.1 109.3,77.7 ; H15.1 111.8,77.7 ; H15.1 108.85,78.95 ; H15.1 110.55,77.25 ; H17.1 20.06,70.24 ; H17.1 17.69,71.25 ; H17.1 20.06,72.26 ; H17.1 18.04,70.24 ; H17.1 19.05,69.89 ; H17.1 18.04,72.26 ; H17.1 20.41,71.25 ; 116.85,25.17 H11.1 ; H11.1 117.21,26.22 ; H11.1 118.26,26.58 ; H11.1 119.31,24.12 ; H11.1 119.31,26.22 ; H11.1 117.21,24.12 ; H11.1 118.26,23.76 ; H11.1 119.67,25.17 ; H12.1 183.59,24.12 ; H12.1 181.49,26.22 ; H12.1 181.49,24.12 ; H12.1 181.13,25.17 ; H12.1 183.95,25.17 ; H12.1 182.54,26.58 ; H12.1 182.54,23.76 ; H12.1 183.59,26.22 ; 230.94,21.58 H5.1 ; H5.1 232.12,22 ; H5.1 233.72,20.4 ; H5.1 230.94,19.22 ; H5.1 233.3,19.22 ; H5.1 233.3,21.58 ; H5.1 232.12,18.8 ; H5.1 230.52,20.4 ; 90.91,71.85 H18.1 ; H18.1 93.63,71.85 ; H18.1 91.26,70.84 ; H18.1 92.27,73.21 ; H18.1 92.27,70.49 ; H18.1 93.28,70.84 ; H18.1 91.26,72.86 ; H18.1 93.28,72.86 ; H4.1 65.43,22.96 ; H4.1 64.38,20.5 ; H4.1 63.33,20.86 ; H4.1 65.43,20.86 ; H4.1 65.79,21.91 ; H4.1 63.33,22.96 ; H4.1 64.38,23.32 ; H4.1 62.97,21.91 ; H1.1 3.95,70.7 ; H1.1 1.85,72.8 ; H1.1 2.9,70.34 ; H1.1 3.95,72.8 ; H1.1 2.9,73.16 ; H1.1 1.49,71.75 ; H1.1 4.31,71.75 ; H1.1 1.85,70.7 ; H16.1 195.05,73.55 ; H16.1 193.35,71.85 ; H16.1 196.3,73.1 ; H16.1 193.8,70.6 ; H16.1 195.05,70.15 ; H16.1 196.75,71.85 ; H16.1 196.3,70.6 ; H16.1 193.8,73.1 ; 221.42,3.53 H22.1 ; H22.1 224.2,2.35 ; H22.1 221,2.35 ; H22.1 221.42,1.17 ; H22.1 222.6,0.75 ; H22.1 222.6,3.95 ; H22.1 223.78,3.53 ; H22.1 223.78,1.17 ; H13.1 119.01,19.22 ; H13.1 117.83,18.8 ; H13.1 119.01,21.58 ; H13.1 116.65,19.22 ; H13.1 116.23,20.4 ; H13.1 117.83,22 ; H13.1 116.65,21.58 ; H13.1 119.43,20.4 ; 23.08,30.32 H3.1 ; H3.1 24.13,27.86 ; H3.1 25.18,28.22 ; H3.1 25.54,29.27 ; H3.1 25.18,30.32 ; H3.1 24.13,30.68 ; H3.1 23.08,28.22 ; H3.1 22.72,29.27 ; H25.1 292.22,3.11 ; H25.1 290.62,4.71 ; H25.1 291.8,1.93 ; H25.1 289.44,4.29 ; H25.1 289.02,3.11 ; H25.1 289.44,1.93 ; H25.1 290.62,1.51 ; H25.1 291.8,4.29 ; H9.1 119.67,46.9 ; H9.1 119.31,45.85 ; H9.1 117.21,45.85 ; H9.1 118.26,48.31 ; H9.1 118.26,45.49 ; H9.1 117.21,47.95 ; H9.1 119.31,47.95 ; H9.1 116.85,46.9 ; 26.8,56.34 H2.1 ; H2.1 26.8,59.16 ; H2.1 25.75,58.8 ; H2.1 27.85,56.7 ; H2.1 25.39,57.75 ; H2.1 25.75,56.7 ; H2.1 27.85,58.8 ; H2.1 28.21,57.75 ; H14.1 177.65,80.2 ; H14.1 174.7,78.95 ; H14.1 176.4,77.25 ; H14.1 175.15,77.7 ; H14.1 178.1,78.95 ; H14.1 177.65,77.7 ; H14.1 175.15,80.2 ; H14.1 176.4,80.65 ; 69.02,1.17 H23.1 ; H23.1 71.38,1.17 ; H23.1 71.8,2.35 ; H23.1 70.2,0.75 ; H23.1 69.02,3.53 ; H23.1 68.6,2.35 ; H23.1 70.2,3.95 ; H23.1 71.38,3.53 ; 1,4.29 H24.1 ; H24.1 3.78,3.11 ; H24.1 3.36,1.93 ; H24.1 0.58,3.11 ; H24.1 2.18,4.71 ; H24.1 1,1.93 ; H24.1 3.36,4.29 ; H24.1 2.18,1.51 ; H19.1 149.51,81.01 ; H19.1 147.14,80 ; H19.1 149.86,80 ; H19.1 147.49,81.01 ; H19.1 148.5,78.64 ; H19.1 148.5,81.36 ; H19.1 149.51,78.99 ; H19.1 147.49,78.99 ; H21.1 289.26,83.35 ; H21.1 288.91,84.36 ; H21.1 287.9,81.99 ; H21.1 286.54,83.35 ; H21.1 288.91,82.34 ; H21.1 286.89,84.36 ; H21.1 286.89,82.34 ; H21.1 287.9,84.71 ; v12(127.06,64.93) 126.88,64.76 v10(126.88,64.46) ; JCR1.22 288.29,62.1 ; JCR1.22 287.24,62.1 ; JCR1.22 286.18,61.35 ; JCR1.22 288.29,61.35 ; JCR1.22 286.18,62.1 ; H7.1 267.41,57.75 ; H7.1 264.95,56.7 ; H7.1 267.05,56.7 ; H7.1 266,59.16 ; H7.1 264.59,57.75 ; H7.1 264.95,58.8 ; H7.1 266,56.34 ; H7.1 267.05,58.8 ; 267.62,28.22 H6.1 ; H6.1 269.72,28.22 ; H6.1 267.26,29.27 ; H6.1 268.67,27.86 ; H6.1 270.08,29.27 ; H6.1 269.72,30.31 ; H6.1 268.67,30.68 ; H6.1 267.62,30.31 ; 286.18,44.7 JCR1.19 ; JCR1.19 288.29,44.7 ; JCR1.19 286.18,45.45 ; JCR1.19 287.24,44.7 ; JCR1.19 288.29,45.45 ; 181.49,45.85 H10.1 ; H10.1 183.59,45.85 ; H10.1 182.54,45.49 ; H10.1 182.54,48.31 ; H10.1 181.49,47.95 ; H10.1 183.95,46.9 ; H10.1 183.59,47.95 ; H10.1 181.13,46.9 ; v12(128.79,64.72) 128.53,64.46 v10(128.48,64.46)
  GND1 w0.254: v10(127.68,62.51) 127.68,62.28 127.4,62 v12(127.4,61.99) ; v12(126.26,62.78) 126.08,62.6 v10(126.08,62.51) ; v10(133.28,66.41) 133.06,66.64 v12(132.9,66.64)
  IN1 w0.081: v1(188.94,69.57) v2(188.61,69.57) ; v1(186.4,69.57) v2(186.73,69.57) ; v1(187.67,69.57) v2(188,69.57) ; v2(185.31,69.57) v1(185.64,69.57) ; v1(183.1,69.57) v2(183.43,69.57) ; v1(184.37,69.57) v2(184.7,69.57)
  IN1 w0.102: v12(133.32,23.98) 133.32,23.42 v12(133.16,23.26) v12(132.27,22.37) v12(131.37,21.47) 130.75,20.85 v12(130.26,20.85) v12(128.99,20.85) 128.45,20.85 128.19,20.85 v12(127.78,20.45) 127.61,20.28 v12(126.52,20.28) v12(125.25,20.28) 124.95,20.28 v12(124.23,19.56) v12(123.34,18.66) v12(122.44,17.76) v12(121.54,16.86) v12(120.64,15.96) 119.98,15.3 v12(119.56,15.3) v12(118.29,15.3) v12(117.02,15.3) v12(115.75,15.3) v12(114.48,15.3) v12(113.21,15.3) v12(111.94,15.3) v12(110.67,15.3) v12(109.4,15.3) v12(108.13,15.3) v12(106.86,15.3) 105.81,15.3 v12(105.6,15.1) v12(104.71,14.2) 104.26,13.75 v12(103.52,13.75) v12(102.25,13.75) v12(100.98,13.75) v12(99.71,13.75) v12(98.44,13.75) v12(97.17,13.75) v12(95.9,13.75) v12(94.63,13.75) 93.99,13.75 v12(93.47,14.27) 92.85,14.9 92.6,14.9 v12(92.36,14.9) v12(91.09,14.9) v12(89.82,14.9) v12(88.55,14.9) v12(87.28,14.9) v12(86.01,14.9) v12(84.74,14.9) 84.7,14.9 84.27,14.47 v12(83.55,14.47) v12(82.28,14.47) 82.2,14.47 81.94,14.21 v12(81.03,14.21) 81.02,14.21 v12(80.13,15.1) 79.67,15.56 79.63,15.56 79.6,15.59 v12(78.96,15.59) v12(77.69,15.59) v12(76.42,15.59) 76.41,15.59 v12(75.52,16.49) v12(74.62,17.39) v12(73.72,18.28) 73.23,18.77 v12(73.23,19.46) v12(73.23,20.73) v12(73.23,22) v12(73.23,23.27) v12(73.23,24.54) v12(73.23,25.81) v12(73.23,27.08) v12(73.23,28.35) v12(73.23,29.62) v12(73.23,30.89) v12(73.23,32.16) v12(73.23,33.43) v12(73.23,34.7) v12(73.23,35.97) v12(73.23,37.24) v12(73.23,38.51) v12(73.23,39.78) v12(73.23,41.05) v12(73.23,42.32) v12(73.23,43.59) v12(73.23,44.86) v12(73.23,46.13) v12(73.23,47.4) v12(73.23,48.67) v12(73.23,49.94) v12(73.23,51.21) v12(73.23,52.48) v12(73.23,53.75) v12(73.23,55.02) v12(73.23,56.29) v12(73.23,57.56) v12(73.23,58.83) v12(73.23,60.1) v12(73.23,61.37) v12(73.23,62.64) v12(73.23,63.91) v12(73.23,65.18) v12(73.23,66.45) v12(73.23,67.72) v12(73.23,68.99) v12(73.23,70.26) 73.23,70.66 v12(73.91,71.33) v12(74.8,72.23) 75.57,73 v8(75.82,73) v8(77.09,73) v8(78.36,73) v8(79.63,73) 80.74,73 v8(80.8,73.06) 81.76,74.01 v8(81.82,74.01) v2(82.39,74.01) v8(83.09,74.01) v2(83.66,74.01) v8(84.36,74.01) v2(84.93,74.01) v8(85.63,74.01) v2(86.2,74.01) v8(86.9,74.01) v2(87.47,74.01) v8(88.17,74.01) v2(88.74,74.01) v8(89.44,74.01) v2(90.01,74.01) v8(90.71,74.01) v2(91.28,74.01) v8(91.94,74.01) v2(92.55,74.01) v8(93.25,74.01) v2(93.82,74.01) v8(94.52,74.01) v2(95.09,74.01) v8(95.79,74.01) v2(96.36,74.01) v8(97.06,74.01) v2(97.63,74.01) v8(98.33,74.01) v2(98.9,74.01) v8(99.6,74.01) v8(100.05,74.01) v8(100.87,74.01) v8(102.14,74.01) v8(103.41,74.01) v8(104.68,74.01) v8(105.95,74.01) 107.13,74.01 v8(107.21,73.93) 108.04,73.11 v8(108.18,73.11) v8(109.45,73.11) v8(110.72,73.11) v8(111.99,73.11) 112.87,73.11 v8(113.21,73.45) 113.23,73.46 v8(114.48,73.46) v8(115.75,73.46) v8(117.02,73.46) v8(118.29,73.46) v8(119.56,73.46) v8(120.83,73.46) v8(122.1,73.46) v8(123.37,73.46) v8(124.64,73.46) v8(125.91,73.46) v8(127.18,73.46) 127.77,73.46 128.18,73.06 v8(128.39,73.06) 128.42,73.06 v8(129.66,73.06) v8(130.93,73.06) v8(132.2,73.06) v8(133.47,73.06) v8(134.74,73.06) 135.1,73.06 135.12,73.09 v8(135.8,73.76) 135.86,73.82 v8(137.07,73.82) v8(138.34,73.82) v8(139.36,73.82) 140.09,74.55 140.91,74.55 141.16,74.81 141.16,75.51 v5(141.13,75.54) v8(141.13,76.55) v8(140.23,77.45) 140.18,77.51 v8(138.96,77.51) v8(137.69,77.51) v8(136.42,77.51) v8(135.15,77.51) v8(133.88,77.51) 133.64,77.51 v8(132.87,76.74) 132.75,76.62 v8(132.24,76.62) v8(131.61,76.62) v8(130.72,76.62) v8(129.64,76.62) v8(128.56,76.62) v8(127.29,76.62) v8(126.02,76.62) v8(124.47,76.62) v8(123.48,76.62) v8(122.21,76.62) v8(120.94,76.62) v8(119.67,76.62) v8(118.4,76.62) v8(113.1,76.62) v8(112.05,76.62) 111.96,76.62 111.57,76.23 v8(110.84,76.23) v8(109.57,76.23) 109.42,76.23 v8(108.6,77.05) 108.37,77.29 108.33,77.29 108.29,77.33 v8(107.36,77.33) v8(106.4,77.33) v8(105.67,77.33) v8(105.14,77.33) v8(104.62,77.33) v8(104.1,77.33) v8(103.58,77.33) v8(103.06,77.33) v8(102.57,77.33) v8(102.05,77.33) v8(101.01,77.33) v8(99.74,77.33) v8(98.47,77.33) v8(97.2,77.33) v8(95.93,77.33) v8(94.66,77.33) v8(93.39,77.33) v8(92.12,77.33) v8(90.85,77.33) v8(89.58,77.33) v8(88.31,77.33) v8(87.04,77.33) v8(86.22,77.33) v8(85.5,77.33) v8(84.98,77.33) v8(84.46,77.33) v8(83.97,77.33) v8(83.45,77.33) v8(83,77.33) v8(82.48,77.33) v8(81.96,77.33) v8(80.69,77.33) v8(79.42,77.33) v8(78.15,77.33) v8(76.64,77.33) 76.13,77.33 v8(75.97,77.49) ; v5(211.32,16.38) 211.27,16.38 v12(210.85,16.79) 210.52,16.79 209.9,16.17 v12(209.62,16.17) v12(208.72,17.07) 208.24,17.55 v12(207.54,17.55) v12(206.27,17.55) v12(205,17.55) v12(203.73,17.55) 203.09,17.55 v12(202.57,17.03) v12(201.68,16.13) 201.39,15.85 v12(200.44,15.85) v12(199.17,15.85) v12(197.9,15.85) v12(196.63,15.85) v12(195.36,15.85) v12(194.09,15.85) v12(192.82,15.85) v12(191.55,15.85) v12(190.28,15.85) v12(189.01,15.85) v12(187.74,15.85) v12(186.47,15.85) v12(185.2,15.85) 183.65,15.85 v5(183.61,15.89) v12(182.66,15.89) v12(181.39,15.89) v12(180.12,15.89) v12(178.85,15.89) v12(177.58,15.89) v5(176.46,15.89) 175.81,15.89 175.42,16.28 v12(175.42,16.79) 175.42,17.6 175.66,17.84 v12(176.14,17.84) 176.32,17.84 176.88,17.28 v12(177.28,17.28) v12(178.55,17.28) v12(179.82,17.28) v12(181.09,17.28) v12(182.36,17.28) v12(183.63,17.28) v12(184.9,17.28) 185.81,17.28 v12(185.97,17.44) v12(186.9,18.37) v12(187.72,19.19) v12(188.69,20.16) v12(189.51,20.98) 189.57,21 v12(190.04,22.15) v12(190.53,23.33) v12(191.02,24.51) 191.38,25.38 v12(191.38,25.71) v12(191.38,26.98) v12(191.38,28.25) v12(191.38,29.52) 191.38,30.74 v12(191.43,30.79) 191.43,31.76 191.7,32.03 v12(191.7,32.03) 191.7,32.7 v8(191.66,32.74) 191.55,32.85 v12(191.55,33.29) v12(191.55,34.56) v12(191.55,35.83) v12(191.55,37.1) v12(191.55,38.37) v12(191.55,39.64) 192.08,40.17 192.08,40.98 v12(191.55,41.51) v12(191.55,42.18) 191.55,43.22 v12(191.33,43.43) v12(190.44,44.33) 190.44,44.63 189.95,45.12 189.5,45.12 v12(189.5,45.12) 188.56,45.12 v12(188.28,44.83) 188.18,44.74 v12(188.18,43.53) v12(188.18,42.33) 188.18,41.53 v12(187.76,41.1) v12(186.86,40.2) v12(185.96,39.3) 185.61,38.96 v12(185.61,38.08) v12(185.61,36.81) v12(185.61,35.54) v12(185.61,34.27) v12(185.61,33) v12(185.61,31.73) v12(185.61,30.46) v12(185.61,29.19) v12(185.61,27.92) v2(185.61,27.34) v12(185.61,26.65) 185.61,26.38 v12(185.23,25.46) v12(184.74,24.27) 184.6,23.95 v12(183.95,23.29) 183.5,22.85 v12(182.76,22.85) v12(181.49,22.85) v12(180.22,22.85) 179.23,22.85 v12(178.98,23.1) 178.42,23.66 v12(177.84,23.66) v12(176.57,23.66) v12(175.3,23.66) v12(174.03,23.66) v12(172.76,23.66) v2(171.36,23.66) 171.25,23.77 170.34,23.77 v2(170.34,23.77) 170.15,23.77 169.86,24.07 169.86,24.24 v12(169.38,24.72) v8(168.92,25.18) ; v5(211.76,15.05) 211.76,14.75 v12(211.35,14.34) 210.95,13.94 v12(210.41,13.94) v12(209.14,13.94) v12(207.87,13.94) v12(206.6,13.94) v12(205.33,13.94) 204.63,13.94 v12(204.47,13.78) v12(203.55,12.86) 203.17,12.48 v12(202.72,12.48) v12(201.45,12.48) v12(200.18,12.48) v12(198.91,12.48) v12(197.64,12.48) v12(196.37,12.48) v12(195.1,12.48) v12(193.83,12.48) v12(192.56,12.48) v12(191.29,12.48) v12(190.02,12.48) v12(188.75,12.48) v12(187.48,12.48) v12(186.21,12.48) v12(184.94,12.48) v12(183.67,12.48) v12(182.4,12.48) v12(181.13,12.48) v12(179.86,12.48) v12(178.59,12.48) v12(177.32,12.48) v12(176.05,12.48) v12(174.78,12.48) v12(173.86,12.48) v12(173.05,13.29) v12(172.36,13.98) v12(171.17,13.98) v12(169.96,13.98) v12(168.75,13.98) v12(167.29,13.98) v12(166.48,13.98) 166.45,14.01 166.42,14.01 v12(165.65,14.78) v12(164.5,15.92) v12(163.58,16.84) 163.2,17.22 v12(162.59,17.22) 162.09,17.22 v12(161.53,17.77) v12(160.79,18.52) v12(159.36,18.52) v12(158.85,19.03) v2(158.18,19.69) ; v8(74.81,76.75) 74.81,76.72 v12(73.73,75.64) v12(72.83,74.74) v12(71.93,73.84) v12(71.03,72.94) v12(70.14,72.04) 70.11,72.02 v12(70.11,70.69) v12(70.11,69.42) v12(70.11,68.15) v12(70.11,66.88) v12(70.11,65.61) v12(70.11,64.34) v12(70.11,63.07) v12(70.11,61.8) v12(70.11,60.53) v12(70.11,59.26) v12(70.11,57.99) v12(70.11,56.72) v12(70.11,55.45) v12(70.11,54.18) v12(70.11,52.91) v12(70.11,51.64) v12(70.11,50.37) v12(70.11,49.1) v12(70.11,47.83) v12(70.11,46.56) v12(70.11,45.29) v12(70.11,44.02) v12(70.11,42.75) v12(70.11,41.48) v12(70.11,40.21) v12(70.11,38.94) v12(70.11,37.67) v12(70.11,36.4) v12(70.11,35.13) v12(70.11,33.86) v12(70.11,32.59) v12(70.11,31.32) v12(70.11,30.05) v12(70.11,28.78) v12(70.11,27.51) v12(70.11,26.24) v12(70.11,24.97) v12(70.11,23.7) v12(70.11,22.43) v12(70.11,21.16) v12(70.11,19.89) v12(70.11,18.62) 70.11,17.36 v12(70.12,17.35) v12(71.02,16.45) v12(71.91,15.55) v12(72.81,14.65) v12(73.71,13.76) v12(74.61,12.86) 75.03,12.44 v12(75.81,12.44) v12(77.08,12.44) v12(78.35,12.44) 78.37,12.44 v12(79.26,11.55) 79.73,11.08 v12(80.44,11.08) v12(81.71,11.08) v12(82.98,11.08) 83.24,11.08 83.5,11.34 v12(84.22,11.34) v12(85.49,11.34) 85.57,11.34 85.99,11.77 v12(86.69,11.77) v12(89.23,11.77) v12(90.5,11.77) 91.55,11.77 v12(91.75,11.57) v12(92.65,10.67) 92.7,10.63 v12(93.92,10.63) v12(95.19,10.63) v12(96.46,10.63) v12(97.73,10.63) v12(99,10.63) v12(100.27,10.63) v12(101.54,10.63) v12(102.81,10.63) v12(104.08,10.63) v12(105.35,10.63) v12(106.62,10.63) v12(107.89,10.63) v12(109.16,10.63) v12(110.43,10.63) v12(111.7,10.63) v12(112.97,10.63) v12(114.24,10.63) 115.25,10.63 v12(115.49,10.87) v12(116.38,11.76) 116.74,12.12 v12(117.6,12.12) v12(118.87,12.12) v12(120.14,12.12) 121.22,12.12 v12(121.4,12.3) v12(122.3,13.2) v12(123.2,14.1) v12(124.09,15) v12(124.99,15.89) v12(125.89,16.79) 126.25,17.15 v12(127.1,17.15) v12(128.37,17.15) 128.92,17.15 129.5,17.73 v12(129.52,17.73) v12(130.79,17.73) 132.05,17.73 v12(132.06,17.74) v12(132.96,18.64) v12(133.85,19.53) v12(134.75,20.43) v12(135.65,21.33) v12(136.55,22.23) 137.32,23 v12(137.32,23.24) v12(137.32,24.51) 137.32,25.32 v12(136.93,25.71) v8(136.48,26.17)
  IN1 w0.127: 77.97,74.1 78.14,74.27 80.86,74.27 v2(81.12,74.01) ; 177.56,31 177.9,30.66 v12(177.9,30.57) 178.13,30.34 v8(178.13,29.5) 177.66,29.5 v8(177.26,29.1) v8(176.63,28.48) v8(175.98,27.82) 175.48,27.32 v8(175.18,27.32) 174.39,27.32 v8(173.98,27.73) 173.86,27.86 173.81,27.86 173.41,28.26 v8(173.41,28.4) 173.58,28.57 173.97,28.57 174.29,28.25 v8(174.42,28.25) 174.49,28.25 174.66,28.42 v8(175.17,28.42) v8(175.85,29.1) v8(176.48,29.73) 176.54,29.79 176.54,30.86 v8(176.57,30.88) 176.68,31 177.56,31 ; v14(77.44,62.52) 77.44,62.84 v14(77.19,63.09) 77.19,63.14 76.73,63.6 v12(76.68,63.6) v12(75.79,63.6) v14(74.96,63.6) 74.91,63.6 74.45,63.14 v14(74.45,63.09) 74.45,63.03 v14(74.96,62.52) v12(75.79,62.52) v12(76.68,62.52) v14(77.44,62.52) ; v9(98.71,69.95) v12(99.22,70.46) v9(98.71,70.97) v12(98.14,70.97) v12(97.57,70.97) v9(97.44,70.97) 97,70.52 v9(97,70.46) 97,70.41 97.46,69.95 v12(97.57,69.95) v12(98.14,69.95) v9(98.71,69.95)
  IN1 w0.254: v1(155.94,16.1) v12(156.36,16.1) v12(157.26,15.2) 157.27,15.19 v12(157.27,13.93) 157.27,13.12 v1(157.04,12.89) ; v8(170.03,26.82) 169.79,27.06 v2(169.79,27.32) ; v16(158.06,41.95) 157.88,41.95 v8(157.59,41.66) ; v1(168.73,35.57) 168.98,35.81 v2(168.98,35.81) ; v5(158.06,41.32) 158.39,41.66 v8(158.51,41.66) ; v8(281.41,14.82) 281.51,14.82 v2(281.72,15.02) ; v8(158.51,42.96) 158.32,42.96 v16(158.06,43.22) ; v2(168.63,46.58) 168.69,46.65 v8(168.69,46.93) ; v8(174.14,24.83) v2(173.87,24.57)
  GND2 w0.203: H4.1 65.43,22.96 ; H4.1 63.33,20.86 ; H4.1 64.38,23.32 ; H4.1 62.97,21.91 ; H4.1 65.43,20.86 ; H4.1 65.79,21.91 ; H4.1 64.38,20.5 ; H4.1 63.33,22.96 ; H24.1 3.36,4.29 ; H24.1 1,1.93 ; H24.1 2.18,4.71 ; H24.1 0.58,3.11 ; H24.1 3.36,1.93 ; H24.1 1,4.29 ; H24.1 2.18,1.51 ; H24.1 3.78,3.11 ; 17.69,71.25 H17.1 ; H17.1 20.06,70.24 ; H17.1 20.06,72.26 ; H17.1 18.04,70.24 ; H17.1 18.04,72.26 ; H17.1 19.05,69.89 ; H17.1 20.41,71.25 ; H8.1 4.26,54.71 ; H8.1 1.54,51.99 ; H8.1 2.9,51.5 ; H8.1 4.26,51.99 ; H8.1 1.54,54.71 ; H8.1 2.9,55.2 ; H8.1 4.75,53.35 ; H8.1 1.05,53.35 ; 193.35,71.85 H16.1 ; H16.1 193.8,70.6 ; H16.1 196.3,70.6 ; H16.1 196.3,73.1 ; H16.1 195.05,73.55 ; H16.1 195.05,70.15 ; H16.1 193.8,73.1 ; H16.1 196.75,71.85 ; 23.08,30.32 H3.1 ; H3.1 24.13,27.86 ; H3.1 25.54,29.27 ; H3.1 25.18,28.22 ; H3.1 22.72,29.27 ; H3.1 24.13,30.68 ; H3.1 23.08,28.22 ; H3.1 25.18,30.32 ; 116.23,20.4 H13.1 ; H13.1 119.01,19.22 ; H13.1 117.83,22 ; H13.1 116.65,21.58 ; H13.1 119.43,20.4 ; H13.1 119.01,21.58 ; H13.1 117.83,18.8 ; H13.1 116.65,19.22 ; H20.1 200.55,73.21 ; H20.1 199.54,70.84 ; H20.1 201.56,70.84 ; H20.1 201.56,72.86 ; H20.1 199.54,72.86 ; H20.1 200.55,70.49 ; H20.1 199.19,71.85 ; H20.1 201.91,71.85 ; H22.1 223.78,1.17 ; H22.1 221,2.35 ; H22.1 222.6,3.95 ; H22.1 224.2,2.35 ; H22.1 223.78,3.53 ; H22.1 221.42,1.17 ; H22.1 222.6,0.75 ; H22.1 221.42,3.53 ; H11.1 119.31,24.12 ; H11.1 116.85,25.17 ; H11.1 117.21,24.12 ; H11.1 119.31,26.22 ; H11.1 118.26,26.58 ; H11.1 118.26,23.76 ; H11.1 117.21,26.22 ; H11.1 119.67,25.17 ; 91.26,72.86 H18.1 ; H18.1 93.28,72.86 ; H18.1 91.26,70.84 ; H18.1 92.27,70.49 ; H18.1 92.27,73.21 ; H18.1 93.63,71.85 ; H18.1 90.91,71.85 ; H18.1 93.28,70.84 ; H15.1 112.25,78.95 ; H15.1 109.3,77.7 ; H15.1 110.55,80.65 ; H15.1 110.55,77.25 ; H15.1 111.8,77.7 ; H15.1 111.8,80.2 ; H15.1 109.3,80.2 ; H15.1 108.85,78.95 ; H14.1 177.65,80.2 ; H14.1 175.15,77.7 ; H14.1 176.4,80.65 ; H14.1 176.4,77.25 ; H14.1 174.7,78.95 ; H14.1 175.15,80.2 ; H14.1 178.1,78.95 ; H14.1 177.65,77.7 ; 147.49,81.01 H19.1 ; H19.1 148.5,78.64 ; H19.1 147.14,80 ; H19.1 149.51,78.99 ; H19.1 149.86,80 ; H19.1 147.49,78.99 ; H19.1 149.51,81.01 ; H19.1 148.5,81.36 ; 286.89,82.34 H21.1 ; H21.1 288.91,84.36 ; H21.1 289.26,83.35 ; H21.1 287.9,81.99 ; H21.1 288.91,82.34 ; H21.1 286.89,84.36 ; H21.1 286.54,83.35 ; H21.1 287.9,84.71 ; 181.49,24.12 H12.1 ; H12.1 181.13,25.17 ; H12.1 183.95,25.17 ; H12.1 183.59,26.22 ; H12.1 182.54,23.76 ; H12.1 182.54,26.58 ; H12.1 181.49,26.22 ; H12.1 183.59,24.12 ; H9.1 118.26,48.31 ; H9.1 117.21,45.85 ; H9.1 118.26,45.49 ; H9.1 116.85,46.9 ; H9.1 119.67,46.9 ; H9.1 117.21,47.95 ; H9.1 119.31,45.85 ; H9.1 119.31,47.95 ; 286.18,44.7 JCR1.19 ; JCR1.19 288.29,44.7 ; JCR1.19 286.18,45.45 ; JCR1.19 288.29,45.45 ; JCR1.19 287.24,44.7 ; H1.1 4.31,71.75 ; H1.1 3.95,72.8 ; H1.1 3.95,70.7 ; H1.1 2.9,73.16 ; H1.1 1.85,70.7 ; H1.1 1.85,72.8 ; H1.1 1.49,71.75 ; H1.1 2.9,70.34 ; JCR1.22 287.24,62.1 ; JCR1.22 288.29,62.1 ; JCR1.22 288.29,61.35 ; JCR1.22 286.18,62.1 ; JCR1.22 286.18,61.35 ; H5.1 233.3,19.22 ; H5.1 230.52,20.4 ; H5.1 232.12,18.8 ; H5.1 232.12,22 ; H5.1 233.72,20.4 ; H5.1 233.3,21.58 ; H5.1 230.94,21.58 ; H5.1 230.94,19.22 ; H25.1 291.8,1.93 ; H25.1 292.22,3.11 ; H25.1 291.8,4.29 ; H25.1 289.02,3.11 ; H25.1 290.62,4.71 ; H25.1 289.44,4.29 ; H25.1 289.44,1.93 ; H25.1 290.62,1.51 ; 267.26,29.27 H6.1 ; H6.1 267.62,28.22 ; H6.1 268.67,27.86 ; H6.1 269.72,28.22 ; H6.1 269.72,30.31 ; H6.1 267.62,30.31 ; H6.1 270.08,29.27 ; H6.1 268.67,30.68 ; v2(279.95,39.28) 279.66,38.99 v8(279.62,38.99) ; 68.6,2.35 H23.1 ; H23.1 69.02,1.17 ; H23.1 70.2,0.75 ; H23.1 71.8,2.35 ; H23.1 69.02,3.53 ; H23.1 71.38,3.53 ; H23.1 70.2,3.95 ; H23.1 71.38,1.17 ; H2.1 27.85,58.8 ; H2.1 26.8,56.34 ; H2.1 25.75,56.7 ; H2.1 25.75,58.8 ; H2.1 28.21,57.75 ; H2.1 26.8,59.16 ; H2.1 27.85,56.7 ; H2.1 25.39,57.75 ; 264.95,58.8 H7.1 ; H7.1 264.95,56.7 ; H7.1 266,56.34 ; H7.1 267.05,58.8 ; H7.1 267.41,57.75 ; H7.1 267.05,56.7 ; H7.1 266,59.16 ; H7.1 264.59,57.75 ; 279.58,36.39 v8(279.62,36.39) ; 181.49,45.85 H10.1 ; H10.1 181.13,46.9 ; H10.1 183.95,46.9 ; H10.1 182.54,48.31 ; H10.1 183.59,45.85 ; H10.1 181.49,47.95 ; H10.1 182.54,45.49 ; H10.1 183.59,47.95 ; v2(280.58,39.33) 280.92,38.99 v8(280.92,38.99)
  GND2 w0.254: v8(187.55,45.93) v2(187.55,46.26) ; v2(169.37,41.12) 169.38,41.12 v8(169.38,41.46) ; v8(168.69,46.93) 168.69,46.65 v2(168.63,46.58) ; v8(158.51,42.96) 158.32,42.96 v16(158.06,43.22) ; v8(173.79,39.19) v2(174.12,39.19) ; v8(171.33,38.72) v2(171.33,38.39) ; v8(166.08,41.01) 166.02,41.01 v2(165.65,41.38)
  VCC w0.203: 147.49,78.99 H19.1 ; H19.1 147.49,81.01 ; H19.1 149.51,78.99 ; H19.1 148.5,81.36 ; H19.1 147.14,80 ; H19.1 148.5,78.64 ; H19.1 149.51,81.01 ; H19.1 149.86,80 ; H2.1 26.8,59.16 ; H2.1 25.39,57.75 ; H2.1 25.75,56.7 ; H2.1 25.75,58.8 ; H2.1 26.8,56.34 ; H2.1 27.85,58.8 ; H2.1 27.85,56.7 ; H2.1 28.21,57.75 ; H8.1 4.26,54.71 ; H8.1 2.9,55.2 ; H8.1 1.05,53.35 ; H8.1 2.9,51.5 ; H8.1 1.54,54.71 ; H8.1 4.26,51.99 ; H8.1 4.75,53.35 ; H8.1 1.54,51.99 ; 176.4,77.25 H14.1 ; H14.1 174.7,78.95 ; H14.1 176.4,80.65 ; H14.1 178.1,78.95 ; H14.1 175.15,77.7 ; H14.1 177.65,80.2 ; H14.1 175.15,80.2 ; H14.1 177.65,77.7 ; H15.1 111.8,77.7 ; H15.1 109.3,77.7 ; H15.1 110.55,80.65 ; H15.1 112.25,78.95 ; H15.1 110.55,77.25 ; H15.1 111.8,80.2 ; H15.1 108.85,78.95 ; H15.1 109.3,80.2 ; H25.1 291.8,4.29 ; H25.1 289.44,1.93 ; H25.1 289.02,3.11 ; H25.1 290.62,4.71 ; H25.1 291.8,1.93 ; H25.1 290.62,1.51 ; H25.1 289.44,4.29 ; H25.1 292.22,3.11 ; H1.1 3.95,72.8 ; H1.1 3.95,70.7 ; H1.1 2.9,70.34 ; H1.1 4.31,71.75 ; H1.1 1.85,70.7 ; H1.1 2.9,73.16 ; H1.1 1.85,72.8 ; H1.1 1.49,71.75 ; 19.05,69.89 H17.1 ; H17.1 20.41,71.25 ; H17.1 18.04,72.26 ; H17.1 17.69,71.25 ; H17.1 20.06,70.24 ; H17.1 20.06,72.26 ; H17.1 18.04,70.24 ; JCR1.22 288.29,61.35 ; JCR1.22 286.18,61.35 ; JCR1.22 287.24,62.1 ; JCR1.22 288.29,62.1 ; JCR1.22 286.18,62.1
  VCC w0.254: H21.1 289.26,83.35 ; H21.1 288.91,82.34 ; H21.1 286.89,82.34 ; H21.1 287.9,84.71 ; H21.1 286.54,83.35 ; H21.1 287.9,81.99 ; H21.1 288.91,84.36 ; H21.1 286.89,84.36
  IN2 w0.127: v16(150.78,55.66) 149.25,55.66 v16(149.22,55.68) 146.96,55.68 146.55,56.09 145.07,56.09 144.66,55.69 v16(144.53,55.69) 144.5,55.69 143.8,56.39 v16(143.54,56.39) 143.53,56.39 143.25,56.11 140.93,56.11 140.74,56.3 139.41,56.3 138.97,55.85 v16(136.68,55.85) 136.3,55.47 131.16,55.47 130.91,55.73 129.89,55.73 129.56,56.06 128.8,56.06 128.61,56.24 127.64,56.24 v16(127.37,56.51) 126.48,56.51 v16(126.46,56.49) 126.08,56.11 124.81,56.11 124.04,55.34 118.31,55.34 117.92,55.73 117.28,55.73 v16(117.27,55.74) 117.25,55.73 113.89,55.73 113.46,55.29 111.87,55.29 110.56,53.99 108.55,53.99 108.51,53.95 108.49,53.95 107.89,53.35 105.28,53.35 104.43,54.2 104.43,63.54 v2(105.09,64.2) v16(106.65,65.76) 106.69,65.76 109.64,68.71 112.22,68.71 112.58,69.06 125.25,69.06 125.64,68.68 127.15,68.68 127.27,68.8 128.82,68.8 129.19,68.43 133.62,68.43 133.95,68.1 143.56,68.1 143.9,67.77 144.2,67.77 v16(144.3,67.66) 144.61,67.36 147.78,67.36 v16(147.81,67.33) 147.92,67.33 148.28,67.69 149.45,67.69 150.36,66.78 v16(150.78,66.78) 151.38,66.78 152.59,67.99 154.71,67.99 155.21,68.49 v16(157.3,68.49) 158.45,68.49 158.53,68.41 159.24,68.41 159.54,68.11 161.2,68.11 161.54,67.76 163.78,67.76 165.52,66.02 v16(165.52,65.6) 165.51,65.59 165.51,65.06 166.4,64.17 166.4,60.2 165.04,58.85 165.04,57.59 v16(164.4,56.95) 163.39,56.95 162.81,56.37 v16(162.81,56.36) 162.5,56.04 159.03,56.04 158.78,56.3 156.15,56.3 155.94,56.08 155.14,56.08 154.78,55.72 v16(153.3,55.72) 153.26,55.68 v16(151.59,55.68) 151.56,55.66 v16(150.78,55.66)
  IN2 w0.254: v2(95.98,66.69) 98.12,66.69 v5(98.15,66.66) 98.78,66.66 v2(101.82,69.7) 101.82,70.88 101.29,71.41 100.3,71.41 v2(99.66,70.78) 97.95,69.06 v2(95.88,69.06) v2(92.68,69.06) v2(91.28,69.06) v2(88.74,69.06) v2(86.93,67.25) 85.19,65.51 v2(85.19,65.38) v2(85.19,62.84) v2(85.19,60.3) 85.82,59.66 v2(87.73,59.66) 88.11,60.04 v2(88.11,62.39) v2(88.11,64.81) 89.99,66.69 v2(90.7,66.69) v2(92.32,66.69) v2(95.98,66.69) ; v2(95.98,66.69) 95.98,66.32 95.79,66.13 v2(95.79,60.49) v2(95.79,57.38) v2(95.79,55.73) 95.03,54.96 v2(93.76,54.96) 93.19,55.54 v2(93.19,57.31)
  IN2 w0.508: v16(160.88,70.46) v16(162.34,70.46)
  GND3 w0.203: H13.1 119.01,21.58 ; H13.1 116.65,21.58 ; H13.1 119.01,19.22 ; H13.1 116.65,19.22 ; H13.1 119.43,20.4 ; H13.1 116.23,20.4 ; H13.1 117.83,22 ; H13.1 117.83,18.8 ; H22.1 223.78,3.53 ; H22.1 221,2.35 ; H22.1 223.78,1.17 ; H22.1 224.2,2.35 ; H22.1 221.42,3.53 ; H22.1 222.6,3.95 ; H22.1 222.6,0.75 ; H22.1 221.42,1.17 ; H4.1 64.38,23.32 ; H4.1 63.33,22.96 ; H4.1 63.33,20.86 ; H4.1 62.97,21.91 ; H4.1 65.43,20.86 ; H4.1 65.79,21.91 ; H4.1 64.38,20.5 ; H4.1 65.43,22.96 ; 1.05,53.35 H8.1 ; H8.1 1.54,51.99 ; H8.1 2.9,51.5 ; H8.1 4.26,51.99 ; H8.1 2.9,55.2 ; H8.1 4.26,54.71 ; H8.1 4.75,53.35 ; H8.1 1.54,54.71 ; H21.1 288.91,82.34 ; H21.1 288.91,84.36 ; H21.1 289.26,83.35 ; H21.1 287.9,81.99 ; H21.1 286.89,82.34 ; H21.1 286.54,83.35 ; H21.1 286.89,84.36 ; H21.1 287.9,84.71 ; JCR1.22 287.24,62.1 ; JCR1.22 286.18,61.35 ; JCR1.22 286.18,62.1 ; JCR1.22 288.29,62.1 ; JCR1.22 288.29,61.35 ; 91.26,70.84 H18.1 ; H18.1 93.28,70.84 ; H18.1 93.63,71.85 ; H18.1 90.91,71.85 ; H18.1 92.27,70.49 ; H18.1 92.27,73.21 ; H18.1 93.28,72.86 ; H18.1 91.26,72.86 ; 286.18,45.45 JCR1.19 ; JCR1.19 288.29,45.45 ; JCR1.19 288.29,44.7 ; JCR1.19 287.24,44.7 ; JCR1.19 286.18,44.7 ; H15.1 112.25,78.95 ; H15.1 111.8,77.7 ; H15.1 110.55,77.25 ; H15.1 109.3,77.7 ; H15.1 108.85,78.95 ; H15.1 109.3,80.2 ; H15.1 111.8,80.2 ; H15.1 110.55,80.65 ; 22.72,29.27 H3.1 ; H3.1 24.13,30.68 ; H3.1 25.18,28.22 ; H3.1 24.13,27.86 ; H3.1 25.18,30.32 ; H3.1 25.54,29.27 ; H3.1 23.08,28.22 ; H3.1 23.08,30.32 ; H6.1 268.67,30.68 ; H6.1 267.62,30.31 ; H6.1 269.72,28.22 ; H6.1 268.67,27.86 ; H6.1 267.26,29.27 ; H6.1 269.72,30.31 ; H6.1 267.62,28.22 ; H6.1 270.08,29.27 ; 17.69,71.25 H17.1 ; H17.1 18.04,70.24 ; H17.1 20.06,70.24 ; H17.1 19.05,69.89 ; H17.1 20.06,72.26 ; H17.1 18.04,72.26 ; H17.1 20.41,71.25 ; 264.95,58.8 H7.1 ; H7.1 267.41,57.75 ; H7.1 267.05,56.7 ; H7.1 266,59.16 ; H7.1 264.59,57.75 ; H7.1 264.95,56.7 ; H7.1 267.05,58.8 ; H7.1 266,56.34 ; H5.1 233.72,20.4 ; H5.1 232.12,22 ; H5.1 230.52,20.4 ; H5.1 230.94,21.58 ; H5.1 233.3,21.58 ; H5.1 230.94,19.22 ; H5.1 232.12,18.8 ; H5.1 233.3,19.22 ; 289.02,3.11 H25.1 ; H25.1 289.44,4.29 ; H25.1 291.8,4.29 ; H25.1 290.62,4.71 ; H25.1 292.22,3.11 ; H25.1 289.44,1.93 ; H25.1 291.8,1.93 ; H25.1 290.62,1.51 ; 117.21,24.12 H11.1 ; H11.1 119.67,25.17 ; H11.1 118.26,26.58 ; H11.1 116.85,25.17 ; H11.1 117.21,26.22 ; H11.1 119.31,26.22 ; H11.1 119.31,24.12 ; H11.1 118.26,23.76 ; 147.14,80 H19.1 ; H19.1 147.49,81.01 ; H19.1 147.49,78.99 ; H19.1 149.51,81.01 ; H19.1 148.5,78.64 ; H19.1 148.5,81.36 ; H19.1 149.51,78.99 ; H19.1 149.86,80 ; 175.15,77.7 H14.1 ; H14.1 178.1,78.95 ; H14.1 177.65,80.2 ; H14.1 174.7,78.95 ; H14.1 177.65,77.7 ; H14.1 175.15,80.2 ; H14.1 176.4,80.65 ; H14.1 176.4,77.25 ; H2.1 28.21,57.75 ; H2.1 27.85,58.8 ; H2.1 25.39,57.75 ; H2.1 25.75,56.7 ; H2.1 27.85,56.7 ; H2.1 26.8,59.16 ; H2.1 25.75,58.8 ; H2.1 26.8,56.34 ; 181.13,46.9 H10.1 ; H10.1 181.49,45.85 ; H10.1 181.49,47.95 ; H10.1 183.59,45.85 ; H10.1 182.54,48.31 ; H10.1 182.54,45.49 ; H10.1 183.95,46.9 ; H10.1 183.59,47.95 ; 199.54,72.86 H20.1 ; H20.1 201.56,72.86 ; H20.1 199.54,70.84 ; H20.1 201.91,71.85 ; H20.1 199.19,71.85 ; H20.1 200.55,73.21 ; H20.1 200.55,70.49 ; H20.1 201.56,70.84 ; 195.05,70.15 H16.1 ; H16.1 195.05,73.55 ; H16.1 193.8,70.6 ; H16.1 196.3,73.1 ; H16.1 193.8,73.1 ; H16.1 196.3,70.6 ; H16.1 196.75,71.85 ; H16.1 193.35,71.85 ; H1.1 2.9,73.16 ; H1.1 3.95,72.8 ; H1.1 2.9,70.34 ; H1.1 1.85,70.7 ; H1.1 1.85,72.8 ; H1.1 4.31,71.75 ; H1.1 3.95,70.7 ; H1.1 1.49,71.75 ; H24.1 3.78,3.11 ; H24.1 3.36,1.93 ; H24.1 3.36,4.29 ; H24.1 2.18,4.71 ; H24.1 0.58,3.11 ; H24.1 1,4.29 ; H24.1 2.18,1.51 ; H24.1 1,1.93 ; 68.6,2.35 H23.1 ; H23.1 70.2,0.75 ; H23.1 69.02,3.53 ; H23.1 71.38,3.53 ; H23.1 71.8,2.35 ; H23.1 71.38,1.17 ; H23.1 69.02,1.17 ; H23.1 70.2,3.95 ; 117.21,47.95 H9.1 ; H9.1 119.67,46.9 ; H9.1 119.31,45.85 ; H9.1 119.31,47.95 ; H9.1 117.21,45.85 ; H9.1 116.85,46.9 ; H9.1 118.26,48.31 ; H9.1 118.26,45.49 ; H12.1 183.59,24.12 ; H12.1 181.49,26.22 ; H12.1 183.59,26.22 ; H12.1 183.95,25.17 ; H12.1 181.13,25.17 ; H12.1 181.49,24.12 ; H12.1 182.54,26.58 ; H12.1 182.54,23.76
  GND3 w0.254: v9(171.04,36.71) 171.29,36.97 v2(171.31,36.97)
  IN3 w0.102: v5(182.2,51.38) 182.08,51.38 v14(181.57,50.87) v14(180.67,49.97) 180.14,49.44 v14(180.14,48.81) v14(180.14,47.54) v14(180.14,46.27) 180.14,45.91 v14(180.83,45.21) v14(181.73,44.31) v14(182.63,43.41) 183.29,43.41 ; v5(182.2,51.38) 182.56,51.02 182.56,50.27 v14(182.83,50) v14(183.73,49.1) v14(184.63,48.21) 185.44,47.39 v14(185.44,47.23) v14(185.44,46.66) 185.44,46.51 v14(184.28,45.35) 183.29,44.36 v14(183.29,44.19) 183.29,43.41 ; v5(182.2,51.38) 182.2,51.57 182.62,51.99 v14(182.83,51.99) v14(184.1,51.99) v14(185.37,51.99) 186.21,51.99 v5(186.79,51.41) ; 178.91,57.19 178.91,58.2 v14(178.66,58.46) 178.53,58.58 v9(177.22,58.58) 177.21,58.57 176.23,58.57 v9(176.14,58.48) 176.03,58.48 v9(175.04,59.47) 174.18,60.33 v14(174.17,60.33) 173.02,61.48 v9(173.02,61.52) v9(173.02,62.48) 173.02,63.05 v9(172.92,63.15) v9(171.92,64.15) 171.66,64.4 v9(171.66,65.63) v9(171.66,66.95) 171.66,68.2 v9(171.6,68.26) v9(171.6,68.9) v9(170.35,70.15) v9(169.4,71.1) v9(168.39,72.11) 167.89,72.61 v9(167.89,73.35) v9(167.89,74.31) 167.89,74.5 v9(167.04,75.35) v9(166.14,76.25) 165.58,76.81 v5(165.37,76.81) 165.25,76.94 v2(164.43,76.94) 164.1,77.27 164.1,77.82 ; 178.91,57.19 178.48,56.75 v9(178.48,56.59) 178.48,56.33 178.07,55.92 v9(178.07,55.42) v14(178.07,54.12) v14(178.07,52.85) 178.07,52.51 v14(177.51,51.95) v14(176.58,51.01) 175.6,50.03 v5(175.6,49.88) v14(175.6,49.16) v14(174.98,48.54) 174.92,48.6 173.67,48.6 v14(173.61,48.54) 173.24,48.17 173.24,47.42 v14(173.29,47.37) 173.29,46.84 172.95,46.51 v14(172.86,46.51) 172.38,46.51 172.06,46.83 v14(171.63,46.83) 170.67,46.83 v14(170.39,46.55) 169.58,45.74 v14(169.58,45.69) v9(169.58,45.32) 169.57,45.31 168.85,45.31 168.56,45.02 168.56,44.29 168.87,43.99 v14(169.39,43.99) 169.44,44.04 170.4,44.04 v14(170.91,43.53) 171.03,43.42 v14(171.75,43.42) 172.56,43.42 v14(172.83,43.69) v14(173.73,44.59) v14(174.62,45.49) v14(175.52,46.39) v14(176.42,47.28) v14(177.32,48.18) v14(178.22,49.08) 178.53,49.39 178.53,50.31 178.67,50.44 v14(178.67,50.45) v14(179.54,51.32) 180.03,51.81 v14(180.03,52.35) v14(180.03,53.62) 180.03,54.3 180.3,54.58 180.56,54.58 180.58,54.6 180.58,54.6 v14(180.69,54.7) 180.84,54.85 180.84,54.86 180.99,55.01 180.99,55.11 181.17,55.28 v14(181.9,55.28) 182.27,55.28 182.8,54.76 v14(183.15,54.76) v14(184.37,54.76) 184.38,54.76 v14(185.57,54.76) v14(186.71,54.76) v14(187.98,54.76) v14(189.35,54.76) 190.3,54.76 v14(190.92,55.39) v14(191.33,55.8) v14(192.39,56.85) 192.74,57.21 v14(192.74,57.88) v14(192.74,59.15) 192.74,59.93 v14(192.32,60.35) v14(191.42,61.25) 190.74,61.25 v9(190.61,61.39) 190.22,61.39 v14(190.09,61.25) 190.09,60.71 190.09,60.7 v9(190.09,60.68) 190.09,60.55 189.93,60.39 v2(189.93,60.26) 189.93,58.79 v2(189.92,58.79) 189.92,58.3 190.32,57.91 v9(190.32,57.86) 190.32,57.81 190.22,57.71 v9(189.1,57.71) v9(187.7,57.71) v9(186.68,57.71) v9(185.67,57.71) v9(184.65,57.71) v9(183.64,57.71) v9(182.62,57.71) 182.6,57.68 181.66,57.68 v14(181.63,57.71) 181.43,57.71 181.3,57.83 v2(180.48,57.83) ; 178.91,57.19 179.04,57.06 v9(179.22,57.06) 180.12,57.06 v9(180.44,57.38) 180.44,57.79 v2(180.48,57.83) ; 164.1,77.82 164.41,78.13 v14(164.95,78.13) 165.34,78.13 165.59,78.38 ; 164.1,77.82 v14(163.64,77.36) v14(162.37,77.36) v14(159.83,77.36) 159.79,77.36 159.33,76.9 v14(158.34,76.9) 157.75,76.9 v14(157.43,76.57) 157.4,76.55 ; v2(180.48,57.83) v9(180.48,58.49) 180.48,58.5 v9(179.57,59.41) 178.94,60.04 v9(178.66,60.04) v9(177.29,60.04) v9(175.89,60.04) 175.47,60.04 v9(174.97,60.55) v14(173.96,61.56) v14(173.96,62.83) 173.96,63.54 v9(173.62,63.87) v9(172.59,64.9) 172.3,65.2 172.3,69.68 v9(172.21,69.77) v9(171.5,70.48) v9(170.8,71.18) v9(170.21,71.77) v9(169.48,72.51) 169.01,72.98 v9(169.01,73.86) 169.01,74.9 v9(168.83,75.08) v9(167.95,75.96) v9(167.05,76.86) v9(166.17,77.74) 165.59,78.32 165.59,78.38 ; v9(87.85,67.12) 87.61,67.12 v9(86.91,67.81) v9(85.92,68.8) v9(84.81,69.91) v9(84.15,70.58) 83.63,71.1 v9(82.87,71.1) v9(81.6,71.1) v9(80.33,71.1) v9(79.06,71.1) v9(77.79,71.1) v9(76.52,71.1) v9(75.25,71.1) v9(73.98,71.1) v9(72.95,70.07) v9(72.04,69.15) v9(72.04,68.1) v9(72.04,66.83) v9(72.04,65.56) v9(72.04,64.29) v9(72.04,63.02) v9(72.04,61.75) v9(72.04,60.48) v9(72.04,59.21) v9(72.04,57.81) v9(72.04,56.67) v9(72.04,55.4) v9(72.04,54.13) v9(72.04,52.86) v9(72.04,51.59) v9(72.04,50.32) v9(72.04,49.05) v9(72.04,47.78) v9(72.04,46.51) v9(72.04,45.24) v9(72.04,43.97) v9(72.04,42.7) v9(72.04,41.43) v9(72.04,40.16) v9(72.04,38.89) v9(72.04,37.62) v9(72.04,36.35) v9(72.04,35.08) v9(72.04,33.81) v9(72.04,32.54) v9(72.04,31.27) v9(72.04,30) v14(72.04,28.71) v14(72.04,27.44) v14(72.04,26.17) v14(72.04,24.9) v14(72.04,23.63) v14(72.04,22.36) v14(72.04,21.09) v9(72.04,19.84) v9(72.04,18.57) 72.04,18.49 72.55,17.98 v14(73.04,17.98) v14(74.31,17.98) v14(75.58,17.98) v14(76.85,17.98) v14(78.12,17.98) v14(79.39,17.98) v14(80.66,17.98) v14(81.93,17.98) v14(83.2,17.98) v14(84.47,17.98) v14(85.74,17.98) v14(87.01,17.98) v14(88.28,17.98) v14(89.55,17.98) v14(90.82,17.98) v14(92.09,17.98) v14(93.36,17.98) v14(94.63,17.98) v14(95.9,17.98) v14(97.17,17.98) v14(98.44,17.98) v14(99.71,17.98) v14(100.98,17.98) v14(102.25,17.98) v14(103.52,17.98) v14(104.79,17.98) v14(106.06,17.98) 106.21,17.98 106.87,17.32 v14(107.14,17.32) 107.47,17.32 107.6,17.19 v14(108.41,17.19) 108.78,17.19 109.03,16.94 v14(109.65,16.94) 109.89,16.94 110.63,17.68 v14(110.68,17.68) v14(111.95,17.68) v14(113.22,17.68) v14(114.49,17.68) v14(115.76,17.68) v14(117.03,17.68) v14(118.3,17.68) 118.96,17.68 v14(119.47,18.19) v14(120.36,19.09) v14(121.26,19.99) 121.66,20.39 v14(121.66,21.19) v14(121.66,22.46) 121.66,23.47 v14(121.9,23.71) v14(122.8,24.61) v14(123.7,25.51) v14(124.6,26.41) 125.06,26.87 v14(125.06,27.56) v14(125.06,28.74) 125.06,29.35 v14(125.7,29.98) 126.75,29.98 126.94,30.17 v14(126.94,30.2) 126.94,30.66 127.25,30.97 v2(127.69,30.97) 128.23,30.97 v2(128.35,30.85) 128.35,29.98 v14(128.29,29.92) 128.38,29.83 128.38,29.17 127.79,28.59 v2(127.2,28.59) 126.88,28.26 v14(126.88,28.06) 126.78,27.96 v2(126.78,27.02) 126.78,25.82 v14(126.72,25.75) v14(125.82,24.86) v14(124.92,23.96) v14(124.02,23.06) 123.35,22.39 v14(123.35,21.98) v14(123.35,20.71) 123.35,20.17 123.26,20.08 123.26,20.05 v14(122.79,19.57) v14(121.89,18.68) v14(120.99,17.78) v14(120.09,16.88) 119.53,16.31 119.28,16.31 119.28,16.31 v14(118.96,16.31) v14(117.69,16.31) v14(116.42,16.31) v14(115.15,16.31) v14(113.88,16.31) v14(112.61,16.31) v14(111.34,16.31) 111.2,16.31 110.46,15.57 v14(110.31,15.57) v14(109.04,15.57) 108.47,15.57 108.21,15.82 v14(107.79,15.82) 107.03,15.82 106.9,15.95 v14(106.53,15.95) 106.3,15.95 105.68,16.57 v14(105.42,16.57) v14(104.15,16.57) v14(102.88,16.57) v14(101.61,16.57) v14(100.34,16.57) v14(99.07,16.57) v14(97.8,16.57) v14(96.53,16.57) v14(95.26,16.57) v14(93.99,16.57) v14(92.72,16.57) v14(91.45,16.57) v14(90.18,16.57) v14(88.91,16.57) v14(87.64,16.57) v14(86.37,16.57) v14(85.1,16.57) v14(83.83,16.57) v14(82.56,16.57) v14(81.29,16.57) v14(80.02,16.57) v14(78.75,16.57) v14(77.48,16.57) v14(76.21,16.57) v14(74.94,16.57) v14(73.67,16.57) v14(72.4,16.57) 72.02,16.57 v14(71.33,17.26) 70.67,17.92 70.67,18.16 v9(70.67,18.52) v9(70.67,19.79) v9(70.67,21.06) v9(70.67,22.33) v9(70.67,23.6) v9(70.67,24.87) v9(70.67,26.14) v9(70.67,27.41) v9(70.67,28.68) v9(70.67,29.95) v9(70.67,31.42) v9(70.67,32.49) v9(70.67,33.76) v9(70.67,35.03) v9(70.67,36.3) v9(70.67,37.57) v9(70.67,38.84) v9(70.67,40.11) v9(70.67,41.38) v9(70.67,42.65) v9(70.67,43.92) v9(70.67,45.19) v9(70.67,46.46) v9(70.67,47.73) v9(70.67,49) v9(70.67,50.27) v9(70.67,51.54) v9(70.67,52.81) v9(70.67,54.08) v9(70.67,55.35) v9(70.67,56.62) v9(70.67,57.89) v9(70.67,59.16) v9(70.67,60.43) v9(70.67,61.7) v9(70.67,62.97) v9(70.67,64.24) v9(70.67,65.51) v9(70.67,66.78) v9(70.67,68.05) v9(70.67,69.32) 70.67,69.72 v9(71.26,70.31) v9(72.37,71.42) v9(73.42,72.47) 73.66,72.47 v9(74.7,72.47) v9(75.97,72.47) v9(77.24,72.47) v9(78.51,72.47) v9(79.78,72.47) v9(81.05,72.47) v9(82.32,72.47) v9(83.59,72.47) 84.2,72.47 v9(84.76,71.91) v9(85.57,71.1) v9(86.85,69.81) v9(88.02,68.64) 88.17,68.49 v9(89.05,68.49) v9(90.32,68.49) v9(91.59,68.49) v9(92.86,68.49) v9(94.13,68.49) v9(95.4,68.49) v9(96.67,68.49) v9(97.94,68.49) 99.08,68.49 v9(99.25,68.32) 99.7,67.87 100.46,67.87 v9(100.57,67.98) v9(101.39,67.98) v9(102.66,67.98) v9(103.93,67.98) 104.66,67.98 v14(105.43,68.75) v14(106.33,69.64) v14(107.23,70.54) 107.93,71.25 v14(108.36,71.25) v14(109.63,71.25) v14(110.89,71.25) v14(112.11,71.25) v14(113.33,71.25) v14(114.6,71.25) v14(115.87,71.25) v14(117.14,71.25) v14(118.41,71.25) v14(119.68,71.25) v14(120.95,71.25) 122.07,71.25 v14(122.39,71.56) v9(123.26,72.44) v9(124.03,73.21) v9(125.3,73.21) v9(126.57,73.21) v9(127.84,73.21) v9(129.11,73.21) v9(130.38,73.21) v9(131.65,73.21) v9(132.92,73.21) v9(134.19,73.21) v9(135.46,73.21) v9(136.73,73.21) 137.99,73.21 v9(138.22,72.97) 139.43,71.77 v9(139.44,71.77) v9(140.71,71.77) v9(141.98,71.77) v9(143.25,71.77) v9(144.52,71.77) v9(145.79,71.77) v9(147.06,71.77) v9(148.33,71.77) v9(149.6,71.77) v9(150.87,71.77) v9(152.14,71.77) 153.16,71.77 154.31,72.91 v9(154.31,72.98) v9(154.31,74.23) v5(154.31,74.99) v9(154.31,75.45) 154.31,75.82 v14(154.83,76.33) v14(155.72,77.23) v14(156.62,78.13) 156.76,78.27 v14(157.88,78.27) 158.74,78.27 v14(159.1,78.63) 159.1,78.82 159.89,79.61 v14(161.32,79.61) v14(162.59,79.61) v14(163.86,79.61) v14(165.13,79.61) 165.34,79.61 165.59,79.36 v14(165.59,78.88) 165.59,78.38 ; 182.79,41.38 182.79,42.52 v14(182.74,42.57) v14(181.84,43.47) v14(180.94,44.37) v14(180.04,45.27) 179.62,45.69 v14(179.62,46.46) v14(179.62,47.73) v14(179.62,49) 179.62,49.81 v14(180.09,50.28) v14(180.97,51.16) v14(181.89,52.09) 182.51,52.7 v14(182.96,52.7) v14(184.23,52.7) v14(185.5,52.7) v14(186.77,52.7) v14(188.04,52.7) v14(189.31,52.7) v14(190.58,52.7) 191.19,52.7 v14(191.73,53.24) v14(192.63,54.14) 192.74,54.25 v14(194.14,54.25) 194.35,54.47 195.16,54.47 195.35,54.28 195.35,53.74 195.08,53.48 v14(194.75,53.48) v14(193.48,53.48) 192.7,53.48 v14(192.28,53.06) 191.41,52.18 v14(191.37,52.18) v14(190.1,52.18) v14(188.83,52.18) v14(187.56,52.18) 186.85,51.47 186.79,51.47 v5(186.79,51.41) ; 182.79,41.38 182.79,40.11 v14(182.72,40.04) 182.79,39.98 182.79,38.71 ; 182.79,41.38 v14(182.74,41.38) ; v9(276.69,50.4) 276.69,49.89 v14(275.95,49.16) v14(275.95,48.23) v14(275.95,46.96) 275.95,45.86 v14(276.11,45.7) 276.65,45.16 v14(277.01,45.16) v14(278.27,45.16) v14(279.54,45.16) v14(280.81,45.16) v14(282.08,45.16) 282.75,45.16 v14(283.57,44.35) 283.98,43.93 v14(284.51,43.93) v14(285.78,43.93) v14(287.05,43.93) v14(288.32,43.93) v14(289.46,43.93) 291.16,43.93 291.55,43.55 v14(291.55,42.07) 291.56,42.05 v14(291.56,40.81) v14(291.56,39.54) v14(291.56,38.27) v14(291.56,37) v14(291.56,35.73) 290.67,34.83 v14(290.05,34.83) v14(289.16,33.94) 289.07,33.85 v14(289.07,32.93) v14(289.07,31.91) v14(289.07,30.66) 289.07,29.26 289.34,28.99 v14(289.34,28.74) 289.34,27.86 v14(289.07,27.6) 289.06,27.59 286.82,27.59 v14(286.52,27.28) 286.52,26.88 v14(285.97,26.34) 285.97,24.83 285.45,24.31 v14(285.13,24.31) v14(284.24,25.2) 284,25.44 v14(284,26.45) 284,27.43 v14(284.27,27.69) v2(284.64,28.06) 284.64,28.61 v14(284.85,28.82) 284.97,28.94 v14(284.97,29.7) v14(284.97,30.97) v14(284.97,32.24) 284.97,33.13 285.46,33.63 v14(285.97,33.63) v14(286.87,34.52) v14(287.77,35.42) 288.41,36.06 v14(288.41,36.52) v14(288.41,37.79) v14(288.41,39.06) v14(288.41,40.33) 288.41,41.42 v14(288.24,41.59) 287.93,41.9 v14(287.01,41.9) v14(285.74,41.9) v14(284.47,41.9) v14(283.2,41.9) 283.14,41.9 v14(282.38,42.66) 281.94,43.1 v14(280.93,43.1) v14(279.66,43.1) v14(278.39,43.1) v14(277.12,43.1) v14(275.85,43.1) 275.84,43.1 v14(274.98,43.96) v14(274.08,44.86) 273.92,45.02 v14(273.92,46.12) v14(273.92,47.39) v14(273.92,48.66) v14(273.92,49.93) 273.92,50.19 ; v9(276.6,54.75) 276.41,54.75 275.68,54.02 274.68,54.02 274.48,53.82 274.48,52.11 274.8,51.79 v14(274.8,51.28) 274.8,51.07 273.92,50.19 ; 157.4,76.55 v14(156.96,76.1) ; 157.4,76.55 157.59,76.36 157.74,76.36 v2(157.85,76.26) 157.88,76.23 v14(158.23,76.23) 158.85,76.23 159.28,75.79 159.67,75.79 ; v14(155.36,21.07) 155.98,21.69 v14(156.28,21.69) v14(157.55,21.69) v14(158.82,21.69) v2(160.09,21.69) v14(161.36,21.69) v14(162.63,21.69) 162.94,21.69 v2(163.06,21.56) v14(163.89,21.56) v14(165.16,21.56) v14(166.43,21.56) v14(167.7,21.56) v14(168.97,21.56) v14(170.24,21.56) v14(171.51,21.56) v14(172.78,21.56) v14(174.05,21.56) 174.55,21.56 v14(175.17,20.95) v14(176.06,20.05) 176.9,19.21 v14(177.02,19.21) v14(178.29,19.21) v14(179.56,19.21) v14(180.83,19.21) v14(182.1,19.21) v14(183.37,19.21) v14(184.64,19.21) v14(185.91,19.21) v14(187.18,19.21) v14(188.45,19.21) v14(189.72,19.21) v14(190.99,19.21) v14(192.26,19.21) v14(193.53,19.21) v14(194.8,19.21) v14(196.07,19.21) v14(197.34,19.21) v14(198.61,19.21) v14(199.88,19.21) v14(201.15,19.21) v14(202.42,19.21) v14(203.69,19.21) v14(204.96,19.21) v14(206.23,19.21) v14(207.5,19.21) v14(208.77,19.21) v14(210.04,19.21) v14(211.31,19.21) v14(212.58,19.21) v14(213.85,19.21) v14(215.12,19.21) v14(216.39,19.21) v14(217.66,19.21) v14(218.93,19.21) v14(220.2,19.21) v14(221.47,19.21) v14(222.74,19.21) v14(224.01,19.21) 225,19.21 225.05,19.26 v14(225.28,19.26) 225.44,19.26 v14(226.25,18.45) 226.7,18.01 v14(227.44,18.01) v14(228.71,18.01) v14(229.98,18.01) v14(231.25,18.01) v14(232.52,18.01) v14(233.79,18.01) v14(235.06,18.01) v14(236.33,18.01) v14(237.6,18.01) v14(238.87,18.01) v14(240.14,18.01) v14(241.41,18.01) v14(242.68,18.01) v14(243.95,18.01) v14(245.22,18.01) v14(246.49,18.01) v14(247.76,18.01) v14(249.03,18.01) v14(250.3,18.01) v14(251.57,18.01) v14(252.84,18.01) v14(254.11,18.01) v14(255.38,18.01) v14(256.65,18.01) v14(257.92,18.01) v14(259.19,18.01) v14(260.46,18.01) v14(261.73,18.01) v14(262.8,18.01) v14(263.56,18.77) 263.94,19.15 v14(264.64,19.15) v14(265.97,19.15) v14(267.18,19.15) 267.18,19.16 v14(268.44,20.43) v14(269.34,21.33) v14(270.24,22.22) v14(271.14,23.12) v14(272.04,24.02) 272.41,24.39 v14(272.41,25.24) v14(272.41,26.51) 272.41,26.61 v14(273.25,27.45) 274.14,28.34 v14(274.16,28.34) 274.18,28.34 274.18,28.34 274.75,28.34 v5(275,28.59) 275.39,28.59 v14(275.74,28.24) v14(275.74,26.97) 275.74,25.81 v14(275.84,25.7) 275.84,25.41 276.38,24.86 v14(276.38,24.55) 276.38,24.36 276.09,24.06 v14(276.09,23.36) v14(275.19,22.46) 275.18,22.45 v14(273.92,22.45) 273.55,22.45 v14(272.86,21.76) v14(271.96,20.86) v14(271.06,19.96) v14(270.16,19.06) v14(269.26,18.16) v14(268.37,17.26) 268.03,16.93 v14(267.37,16.93) v14(266.16,16.93) 265.34,16.93 v14(264.26,15.85) 264.24,15.84 v14(263.77,15.84) v14(262.5,15.84) v14(261.23,15.84) v14(259.96,15.84) v14(258.69,15.84) v14(257.42,15.84) v14(256.15,15.84) v14(254.88,15.84) v14(253.61,15.84) v14(252.34,15.84) v14(251.07,15.84) v14(249.8,15.84) v14(248.53,15.84) v14(247.26,15.84) v14(245.99,15.84) v14(244.72,15.84) v14(243.45,15.84) v14(242.18,15.84) v14(240.91,15.84) v14(239.64,15.84) v14(238.37,15.84) v14(237.1,15.84) v14(235.83,15.84) v14(234.56,15.84) v14(233.29,15.84) v14(232.02,15.84) v14(230.75,15.84) v14(229.48,15.84) v14(228.21,15.84) v14(226.94,15.84) 225.72,15.84 v14(225.67,15.88) v14(224.78,16.78) 224.51,17.05 v14(223.54,17.05) v14(222.27,17.05) v14(221,17.05) v14(219.73,17.05) v14(218.46,17.05) v14(217.19,17.05) v14(215.92,17.05) v14(214.65,17.05) v14(213.38,17.05) v14(212.11,17.05) v14(210.84,17.05) v14(209.39,17.05) v14(208.3,17.05) v14(207.03,17.05) v14(205.76,17.05) v14(204.49,17.05) v14(203.22,17.05) v14(201.95,17.05) v14(200.88,17.05) v14(199.41,17.05) v14(198.14,17.05) v14(196.87,17.05) v14(195.6,17.05) v14(194.33,17.05) v14(193.06,17.05) v14(191.79,17.05) v14(190.52,17.05) v14(189.25,17.05) v14(187.98,17.05) v14(186.71,17.05) v14(185.44,17.05) v14(184.17,17.05) v14(182.9,17.05) v14(181.63,17.05) v14(180.36,17.05) v14(179.09,17.05) v14(178.02,17.05) v14(176.55,17.05) 175.82,17.05 v14(175.36,17.51) v14(174.46,18.41) 173.71,19.17 v14(173.44,19.17) v14(172.17,19.17) v14(170.9,19.17) 169.67,19.17 v14(169.63,19.12) v14(168.84,18.33) ; 183.29,43.41 v14(183.29,42.33) v14(183.29,41.06) v14(183.29,39.79) 183.29,38.08 v14(182.64,37.43) v14(181.74,36.53) v14(180.85,35.63) v14(179.95,34.74) v14(179.05,33.84) v14(178.15,32.94) 177.94,32.73 v14(176.9,32.73) v14(175.63,32.73) v14(174.36,32.73) v14(173.09,32.73) v14(171.82,32.73) v14(170.55,32.73) 170.16,32.73 v14(169.48,32.05) v14(168.58,31.15) v14(167.68,30.25) v14(166.78,29.35) 166.13,28.7 v14(165.7,28.7) v14(164.43,28.7) v14(163.16,28.7) v14(161.89,28.7) 160.74,28.7 v14(160.62,28.58) v14(159.72,27.69) 159.09,27.05 159.09,26.65 v9(159.1,26.64) 158.97,26.52 158.97,26.09 v14(159.29,25.77) v14(160.56,25.77) 161.14,25.77 v14(161.7,26.33) v14(162.6,27.23) 162.72,27.35 v14(163.86,27.35) v14(165.13,27.35) 166.09,27.35 v14(166.37,27.08) v14(167.27,26.18) 167.34,26.11 168.03,26.11 v14(168.48,26.56) 168.94,27.02 v5(168.94,27.2) ; v2(169.68,28.46) 170.27,29.06 v14(170.92,29.06) v14(171.82,29.95) 172.46,30.59 v14(172.92,30.59) v14(174.19,30.59) v14(175.46,30.59) v14(176.73,30.59) v14(178,30.59) 178.79,30.59 v14(179.2,31.01) v14(180.1,31.9) v14(181.13,32.93) v14(181.89,33.7) v14(182.79,34.6) v14(183.96,35.76) v14(184.59,36.39) 185.43,37.23 v14(185.43,37.35) v14(185.43,38.62) v14(185.43,39.89) v14(185.43,41.16) v14(185.43,42.43) 185.43,43.34 v14(185.81,43.72) v14(186.76,44.68) 187.55,45.47 v14(187.55,45.55) v2(187.55,46.26) v14(187.55,46.82) v14(187.55,48.09) 187.55,48.29 v14(186.76,49.08) 186.72,49.12 v14(186.72,50.35) 186.72,50.52 186.92,50.72 186.92,51.27 v5(186.79,51.41) ; 159.67,75.79 v14(159.67,75.8) ; 159.67,75.79 159.79,75.91 160.03,75.91 160.27,76.16 160.35,76.16 160.4,76.21 v14(161.01,76.21) 161.87,76.21 v14(161.89,76.24) 162.28,76.62 v2(162.28,76.68) 162.29,76.69 v14(162.95,76.69) 163.83,76.69 v14(164.18,76.35) 164.19,76.34 164.55,76.34 v5(165.24,75.65) 165.13,75.54 v14(165.13,75.13) 165.13,75.02 v9(165.83,74.32) v9(166.41,73.75) v9(167.27,72.88) v9(167.27,72.24) v14(167.27,71.09) 167.27,70.46 v14(167.8,69.93) 167.85,69.88 v14(168.7,69.03) v14(169.59,68.14) v14(170.49,67.24) 171.08,66.65 v14(171.08,66.08) v14(171.08,64.68) 171.08,64.03 v9(171.6,63.5) 171.84,63.27 v9(171.84,62.56) v9(171.84,61.72) v9(171.84,60.17) 171.84,59.91 v9(172.55,59.2) v9(173.54,58.21) v14(174.57,57.17) v14(175.47,56.28) 175.8,55.95 v14(175.8,55.05) v14(175.8,53.78) 175.8,53.48 175.07,52.75 v14(175.07,52.74) 175.07,51.5 v14(175.04,51.47) v14(174.14,50.57) 173.92,50.57 173.36,50 v14(173.01,50) v14(171.74,50) v14(170.47,50) 169.59,50 v14(169.24,49.66) 168.99,49.41 168.99,49.05 168.97,49.02 168.97,48.84 v14(168.66,48.53) v14(167.76,47.64) v2(167.37,47.24) ; v9(276.38,55.47) 276.38,55.4 275.52,54.53 v14(275.37,54.53) v14(274.61,54.53) 274.41,54.53 273.92,54.04 v14(273.92,53.99) v14(273.92,52.47) 273.92,52.4 273.84,52.32 273.84,50.27 273.92,50.19 ; v5(164.31,26.52) v14(163.44,26.52) 163.18,26.52 v14(162.42,25.76) 161.86,25.2 v14(161.28,25.2) v14(160.01,25.2) 159.12,25.2 v14(158.79,25.54) 158.45,25.87 v14(158.45,26.76) 158.45,27.16 v14(159.13,27.84) v14(160.03,28.74) 160.51,29.22 v14(161.2,29.22) v14(162.47,29.22) v14(163.74,29.22) v14(165.01,29.22) 165.91,29.22 v14(166.24,29.55) v14(167.14,30.44) v14(168.04,31.34) v14(168.93,32.24) v14(169.83,33.14) 169.95,33.26 v14(171.1,33.26) v14(172.37,33.26) v14(173.64,33.26) v14(174.91,33.26) 175.48,33.26 v14(176.04,33.82) v14(176.94,34.72) 177.24,35.01 v14(178.18,35.01) v14(179.29,35.01) 179.53,35.01 180.37,35.85 v14(180.37,35.98) 180.56,35.98 180.68,36.1 180.68,36.1 181.26,36.68 v14(181.26,36.8) 181.33,36.8 182.09,37.57 v14(182.09,37.63) 182.15,37.63 182.79,38.26 182.79,38.71 ; 182.79,38.71 v14(182.74,38.71) ; v14(156.96,76.1) v2(155.94,75.08) v9(155.94,72.87) 155.94,72.56 v9(155.67,72.29) v14(154.95,71.56) v14(154.07,70.69) 153.73,70.34 v14(152.8,70.34) v14(151.8,70.34) v14(150.26,70.34) v14(149.26,70.34) v14(147.72,70.34) v14(146.45,70.34) v14(145.18,70.34) v14(143.91,70.34) v14(142.64,70.34) v14(141.37,70.34) v14(140.1,70.34) v14(138.83,70.34) 138.67,70.34 v14(137.86,71.15) 137.24,71.77 v9(136.47,71.77) v9(135.2,71.77) v9(133.93,71.77) v9(132.66,71.77) v9(131.39,71.77) v9(130.12,71.77) v9(128.85,71.77) v9(127.58,71.77) v9(126.31,71.77) v9(125.04,71.77) 125.03,71.75 125.01,71.75 v14(124.27,71.01) v14(123.38,70.12) 123.08,69.82 v14(122.12,69.82) v14(120.85,69.82) v14(119.58,69.82) v14(118.33,69.82) 118.31,69.82 118.3,69.83 v14(117.03,69.83) v14(115.73,69.83) 114.53,69.83 v14(114.52,69.82) v14(113.25,69.82) v14(112.24,69.82) 111.56,69.82 111.42,69.69 v14(110.7,69.69) v14(109.43,69.69) 108.37,69.69 v14(108.19,69.51) v14(107.29,68.61) v14(106.39,67.71) v14(105.49,66.81) 104.96,66.28 v9(103.05,66.28) v9(101.78,66.28) v9(100.51,66.28) v9(99.24,66.28) 98.41,67.12 v9(98.01,67.12) v9(96.74,67.12) v9(95.47,67.12) v9(94.2,67.12) v9(92.93,67.12) v9(91.66,67.12) v9(90.39,67.12) v9(89.12,67.12) ; v14(156.96,76.1) 157.36,75.71 v14(158.17,75.71) 158.85,75.71 159.27,75.28 v14(159.42,75.28) 159.92,75.28 160.3,75.67 v14(160.62,75.67) v14(161.89,75.67) 162.22,75.67 v14(162.44,75.88) 162.81,76.25 163.65,76.25 163.93,75.97 v2(163.93,75.67) 163.93,74.71 v14(163.97,74.67) v14(164.87,73.77) 165.77,72.87 166.15,72.87 v14(166.56,72.46) 166.75,72.27 v14(166.75,71.2) 166.75,70.24 v14(167.03,69.96) 167.33,69.66 v14(167.93,69.06) v14(168.83,68.16) v14(169.73,67.27) 170.56,66.43 v14(170.56,66.14) v14(170.56,64.87) 170.56,63.81 v14(170.75,63.62) 171.32,63.05 v9(171.32,62.53) v9(171.32,61.67) v9(171.32,60.45) 171.32,59.64 v9(171.99,58.96) 172.05,58.96 v9(172.82,58.19) v9(174.01,57) v9(174.97,56.05) 175.28,55.73 v14(175.28,54.86) 175.28,53.69 v14(175.18,53.6) 174.55,52.96 v14(174.55,52.49) 174.55,51.86 v14(174.03,51.34) 173.22,50.53 v14(173.05,50.53) v14(171.78,50.53) v14(170.85,50.53) 169.37,50.53 v14(169.25,50.4) 168.55,49.7 v14(168.55,49.34) 168.55,49.23 v14(167.71,48.39) v14(166.81,47.49) 166.81,46.92 v2(166.93,46.8)
  IN3 w0.127: v14(266.17,15.37) 266.24,15.44 v14(267.28,15.37) ; v5(211.76,15.05) v5(210.76,15.17) 210.47,15.25 v14(210.26,15.32)
  IN3 w0.254: v14(266.17,15.37) v14(265.21,15.21) v14(263.96,14.98) v14(262.71,14.76) v14(261.68,14.67) v14(260.43,14.89) v14(259.18,15.11) v14(257.93,15.34) 257.18,15.51 v14(256.9,15.43) v14(255.65,15.21) v14(254.4,14.98) v14(253.15,14.76) v14(252.12,14.67) v14(250.87,14.89) v14(249.62,15.11) v14(248.37,15.34) 247.63,15.49 v14(247.35,15.43) v14(246.1,15.21) v14(244.85,14.98) v14(243.59,14.76) v14(242.57,14.67) v14(241.32,14.89) v14(240.07,15.11) v14(238.82,15.34) 238.09,15.48 v14(237.79,15.43) v14(236.54,15.21) v14(235.29,14.98) v14(234.04,14.76) v14(233.01,14.67) v14(231.76,14.89) v14(230.51,15.11) v14(229.26,15.34) 228.59,15.49 v14(228.43,15.46) v14(226.99,15.21) v14(225.73,14.98) v14(224.48,14.76) v14(223.46,14.67) v14(222.21,14.89) v14(220.96,15.11) v14(219.71,15.34) 218.94,15.48 v14(218.68,15.43) v14(217.43,15.21) v14(216.18,14.98) v14(214.93,14.76) v14(214.01,14.65) v14(212.76,14.87) v5(211.76,15.05) ; v5(8.95,39.72) 8.61,39.38 ; 8.61,39.38 8.35,39.64 8.35,40.37 v14(8.91,40.93) 8.94,40.96 10.15,40.96 v14(10.18,40.93) v14(11.45,40.93) 11.47,40.95 12.7,40.95 v14(12.72,40.93) v14(13.99,40.93) 14.03,40.97 15.22,40.97 v14(15.26,40.93) 15.27,40.93 15.56,40.64 v14(15.56,40.03) v14(15.56,38.76) 15.56,38.08 14.74,37.26 v14(14.74,37.1) v14(14.74,35.83) v14(14.74,34.56) 15,33.08 14.96,32.85 v14(14.96,32.85) v14(14.74,31.6) v14(14.52,30.35) v14(14.3,29.1) v14(14.61,27.25) 14.61,27.25 14.71,26.66 v14(14.71,26.47) v14(14.71,25.2) 14.71,25.01 v14(15.32,24.4) v14(16.22,23.5) v14(17.11,22.61) v14(18.01,21.71) v14(18.91,20.81) v14(19.81,19.91) v14(20.71,19.01) v14(21.6,18.12) v14(22.5,17.22) v14(23.4,16.32) v14(24.3,15.42) 24.36,15.36 v14(25.96,15.36) v14(27.55,15.58) v14(28.85,15.77) v14(30.46,15.51) v14(31.71,15.29) v14(32.96,15.07) v14(33.87,15.18) v14(35.12,15.4) v14(36.37,15.62) v14(37.79,15.87) v14(38.65,15.75) v14(39.9,15.53) v14(41.15,15.31) v14(42.4,15.09) v14(43.43,15.18) v14(44.68,15.4) v14(45.93,15.62) v14(47.29,15.86) v14(48.2,15.75) v14(49.45,15.53) v14(50.7,15.31) v14(51.95,15.09) v14(52.98,15.18) v14(54.23,15.4) v14(55.48,15.62) v14(56.83,15.86) v14(57.76,15.75) v14(59.01,15.53) v14(60.26,15.31) v14(61.51,15.09) v14(62.54,15.18) v14(63.79,15.4) v14(65.04,15.62) v14(66.47,15.87) 66.64,15.85 66.9,15.81 v14(67.31,15.75) v14(68.56,15.53) v14(69.81,15.31) v14(71.07,15.09) 71.66,15.14 v14(72.09,15.18) v14(73.34,15.4) v14(74.59,15.62) v14(75.97,15.86) v14(76.87,15.75) v14(78.12,15.53) v14(79.37,15.31) v14(80.62,15.09) v14(81.65,15.18) v14(82.9,15.4) v14(84.15,15.62) v14(85.49,15.86) v14(86.42,15.75) v14(87.67,15.53) v14(88.93,15.31) v14(90.18,15.09) v14(91.2,15.18) v14(92.45,15.4) v14(93.7,15.62) v14(95.01,15.85) v14(95.98,15.75) v14(97.23,15.53) v14(98.48,15.31) v14(99.73,15.09) v14(100.76,15.18) v14(102.01,15.4) v14(103.26,15.62) v14(104.51,15.84) 104.55,15.88 105.04,15.87 v14(105.07,15.83) v14(106.32,15.61) v14(107.57,15.39) v14(108.82,15.17) v14(110.07,14.95) v14(110.77,15.05) v14(112.02,15.27) v14(113.27,15.49) 113.29,15.52 114.71,15.77 v14(114.74,15.75) v14(116.29,15.47) v14(117.54,15.25) v14(118.8,15.03) 118.8,15.03 v14(119.82,15.17) v14(121.07,15.39) v14(122.32,15.61) v14(123.57,15.83) 123.87,15.87 v14(124.65,15.75) v14(125.9,15.53) v14(127.15,15.31) v14(128.4,15.09) v14(129.22,15.15) v14(130.47,15.37) v14(131.32,15.47) v14(132.59,15.47) v14(133.86,15.47) 134,15.47 v14(134.97,16.44) v14(135.87,17.34) v14(136.77,18.23) v14(137.67,19.13) v14(138.56,20.03) v14(139.46,20.93) v14(140.36,21.83) v14(141.26,22.72) v14(142.16,23.62) v14(143.06,24.52) 143.06,24.53 v14(143.06,25.06) v14(143.06,26.33) 143.06,26.86 143.95,27.75 v14(144.62,27.75) v14(145.89,27.75) v14(147.16,27.75) v14(148.43,27.75) 148.65,27.75 148.83,27.93 v14(149.16,27.93) v14(150.43,27.93) v14(151.7,27.93) 151.87,27.93 v14(152.26,27.53) v14(153.16,26.63) v14(154.06,25.74) 154.26,25.54 v14(154.26,24.99) v14(154.26,23.72) v14(154.26,22.45) 154.26,22.18 v14(154.47,21.97) v14(155.36,21.07) v14(156.26,20.18) v14(157.16,19.28) v14(158.06,18.38) 158.87,18.38 v14(160.06,18.13) v14(161.3,18.38) v14(162.55,18.56) v14(163.77,18.78) v14(164.39,18.65) v14(165.64,18.43) v14(166.3,18.33) v14(167.57,18.33) v14(168.84,18.33) 168.88,18.33 v14(169.31,17.89) v14(170.21,16.99) v14(171.11,16.09) 172.15,15.05 v14(172.22,15.05) v14(173.49,15.05) 173.65,15.05 v14(175.37,14.73) v14(176.71,14.76) v14(177.96,14.98) v14(179.21,15.21) v14(180.46,15.43) 180.75,15.49 v14(181.48,15.34) v14(182.74,15.11) v14(183.99,14.89) v14(185.24,14.67) v14(186.26,14.76) v14(187.51,14.98) v14(188.76,15.21) v14(190.01,15.43) 190.28,15.48 v14(191.04,15.34) v14(192.29,15.11) v14(193.54,14.89) v14(194.79,14.67) v14(195.82,14.76) v14(197.07,14.98) v14(198.32,15.21) v14(199.57,15.43) 199.91,15.49 v14(201.26,15.22) v14(202.51,15) v14(203.76,14.78) v14(205.01,14.56) v14(205.82,14.68) v14(207.07,14.91) v14(208.33,15.13) v5(208.87,15.22) v14(209.58,15.35) 209.89,15.42 v14(210.26,15.32) ; 8.61,39.38 8.61,37.92 v14(8.78,37.74) 8.78,37.62 8.97,37.43 arc(9.05,37.32) 9.15,37.22 9.7,36.66 v14(9.7,36.63) 10.18,36.15 v14(10.18,35.92) 10.24,35.86 10.24,34.72 v14(10.18,34.65) v14(10.24,33.91) v14(10.45,32.66) v14(10.46,32.08) v14(10.24,30.82) 10.03,29.58 10.02,29.57 10.02,29.53 9.93,29.04 v14(9.95,28.95) v14(10.17,27.7) v14(10.42,26.11) v14(10.42,24.84) v14(10.42,23.57) 10.42,23.23 v14(10.46,23.19) v14(11.36,22.29) v14(12.25,21.39) v14(13.15,20.5) v14(14.05,19.6) v14(14.95,18.7) v14(15.85,17.8) v14(16.74,16.9) v14(17.64,16.01) v14(18.54,15.11) v14(19.44,14.21) v14(20.34,13.31) v14(21.23,12.41) v14(22.13,11.52) 22.6,11.05 v14(22.71,11.05) v14(23.98,11.05) v14(25.25,11.05) v14(26.52,11.05) 27.04,11.05 v14(28.47,11.3) 28.89,11.37 v14(30.35,11.12) v14(31.61,10.9) v14(32.86,10.68) 33.76,10.52 v14(34.02,10.56) v14(35.27,10.78) v14(36.52,11) v14(37.77,11.23) 38.53,11.36 v14(38.75,11.32) v14(40,11.1) v14(41.25,10.88) v14(42.5,10.66) 42.94,10.54 v14(43.27,10.57) v14(44.52,10.79) v14(45.77,11.01) v14(47.02,11.24) v14(47.69,11.26) v14(48.94,11.04) v14(50.19,10.82) v14(51.44,10.6) v14(52.47,10.51) v14(53.72,10.73) v14(54.97,10.95) v14(56.22,11.17) v14(57.25,11.26) v14(58.5,11.04) v14(59.75,10.82) v14(61,10.6) v14(62.02,10.51) v14(63.27,10.73) v14(64.52,10.95) v14(65.78,11.17) 66.64,11.25 v14(66.8,11.26) v14(68.05,11.04) v14(69.3,10.82) v14(70.55,10.6) v14(71.58,10.51) 72.8,10.73 v14(72.83,10.73) v14(74.08,10.95) v14(75.33,11.17) v14(76.36,11.26) v14(77.61,11.04) v14(78.86,10.82) v14(80.11,10.6) v14(81.13,10.51) v14(82.38,10.73) v14(83.64,10.95) v14(84.89,11.17) v14(85.91,11.26) v14(87.16,11.04) v14(88.41,10.82) v14(89.66,10.6) v14(90.69,10.51) v14(91.94,10.73) v14(93.19,10.95) v14(94.44,11.17) v14(95.47,11.26) v14(96.72,11.04) v14(97.97,10.82) v14(99.22,10.6) v14(100.24,10.51) v14(101.5,10.73) v14(102.75,10.95) v14(104,11.17) v14(105.02,11.26) v14(106.27,11.04) v14(107.52,10.82) v14(108.77,10.6) 109.74,10.45 v14(109.74,10.45) v14(110.83,10.64) v14(112.08,10.86) v14(113.4,11.09) v14(114.64,11.31) v14(116.11,11.11) v14(117.36,10.89) v14(118.61,10.67) 118.92,10.59 v14(119.31,10.67) v14(120.56,10.89) v14(121.81,11.11) v14(123.06,11.33) v14(123.93,11.47) v14(125.18,11.25) v14(126.43,11.03) v14(127.68,10.81) 128.57,10.59 v14(128.93,10.59) v14(130.63,10.81) v14(131.88,11.04) v14(132.65,11.12) v14(133.92,11.12) v14(135.19,11.12) 135.73,11.12 v14(135.79,11.18) v14(136.69,12.08) v14(137.58,12.98) v14(138.48,13.88) v14(139.38,14.77) v14(140.28,15.67) v14(141.18,16.57) v14(142.07,17.47) v14(142.97,18.37) v14(143.87,19.26) v14(144.77,20.16) v14(145.67,21.06) 146.3,21.69 v14(146.57,21.69) v14(147.84,21.69) 148.44,21.69 149.59,20.55 v14(149.59,20.22) v14(149.96,19.84) 150.29,19.84 151,19.14 v14(151,18.88) 151,18.81 v14(151.76,18.05) 152.11,18.05 152.66,17.5 v14(152.66,17.15) v14(153.56,16.25) v14(154.45,15.35) v14(155.35,14.45) 155.78,14.03 v14(156.39,14.03) v14(157.66,14.03) 157.81,14.03 158.86,13.88 v14(160.1,13.65) v14(161.7,13.93) v14(162.95,14.15) v14(164.05,14.22) 165.09,14.02 v14(165.79,14.03) v14(167.06,14.03) v14(168.1,12.99) v14(169.02,12.06) 169.07,12.06 v14(169.92,11.21) 170.37,10.76 v14(170.46,10.76) v14(171.73,10.76) v14(172.84,10.76) 173.02,10.73 173.03,10.71 v14(174.47,10.49) 174.47,10.48 175.72,10.26 v14(175.73,10.26) 175.97,10.21 v14(177.48,10.5) v14(178.7,10.71) v14(179.98,10.94) 180.41,10.98 180.43,11 v14(181.04,11.05) v14(182.22,10.84) v14(183.47,10.62) v14(184.72,10.4) 185.17,10.31 185.49,10.24 v14(185.82,10.31) 186.99,10.52 v14(187,10.53) v14(188.25,10.75) v14(189.5,10.97) v14(190.53,11.06) v14(191.78,10.84) v14(193.03,10.62) 193.04,10.61 194.27,10.4 v14(194.28,10.4) 195.02,10.26 v14(195.3,10.31) v14(196.56,10.53) v14(197.81,10.75) v14(199.06,10.97) v14(199.91,11.09) v14(201.16,10.87) v14(202.41,10.65) v14(203.66,10.43) v14(204.91,10.21) 205.24,10.15 v14(205.83,10.26) v14(207.08,10.48) v14(208.17,10.73) v14(209.42,10.96) v14(209.98,11) v14(211.23,10.78) v14(212.48,10.56) v14(213.73,10.34) 214.23,10.25 v14(214.35,10.27) v14(215.67,10.5) v14(216.92,10.72) 218.14,10.94 v14(218.18,10.94) v14(219.22,11.04) v14(220.46,10.82) v14(221.74,10.59) v14(222.92,10.38) 223.72,10.23 v14(223.97,10.31) v14(225.22,10.53) v14(226.47,10.75) 226.49,10.74 v14(227.86,10.99) v14(228.75,11.06) v14(230,10.84) v14(231.25,10.62) v14(232.5,10.4) 233.29,10.25 v14(233.53,10.31) v14(234.78,10.53) v14(236.03,10.75) v14(237.28,10.97) 238.25,11.06 v14(238.26,11.07) 238.31,11.06 v14(239.52,10.85) 239.56,10.84 240.57,10.66 v14(240.57,10.66) 240.81,10.62 240.81,10.62 242.05,10.4 v14(242.05,10.4) 242.84,10.25 v14(243.08,10.31) v14(244.33,10.53) v14(245.58,10.75) v14(246.83,10.97) v14(247.86,11.06) v14(249.11,10.84) v14(250.36,10.62) v14(251.61,10.4) 252.19,10.29 252.36,10.25 v14(252.64,10.31) v14(253.89,10.53) v14(255.14,10.75) 255.14,10.75 256.39,10.97 v14(256.39,10.97) v14(257.41,11.06) 257.42,11.06 v14(258.62,10.85) v14(259.91,10.62) 261.16,10.4 v14(261.18,10.4) 261.19,10.4 261.96,10.25 v14(262.16,10.31) 262.16,10.31 262.17,10.3 v14(263.43,10.53) 264.62,10.74 v14(264.62,10.73) 264.67,10.74 265.91,10.96 265.91,10.97 v14(265.92,10.97) 266.91,11.03 v14(266.91,11.03) 268.35,10.76 v14(268.53,10.76) v14(269.8,10.76) v14(271.07,10.76) 271.17,10.76 272.08,11.67 v14(272.08,11.67) 272.98,12.57 v14(272.98,12.57) 273.88,13.47 v14(273.88,13.47) 274.78,14.37 v14(274.78,14.37) 275.67,15.26 v14(275.67,15.27) 276.57,16.16 v14(276.57,16.16) 277.47,17.06 v14(277.47,17.06) 278.37,17.96 v14(278.37,17.96) 279.27,18.86 v14(279.27,18.86) 280.16,19.75 v14(280.16,19.76) 281.21,20.75 v14(281.28,20.96) v14(281.5,22.21) v14(281.72,23.46) v14(281.94,24.71) 281.94,24.72 281.99,25.03 281.93,25.39 v14(281.93,25.4) v14(281.71,26.65) v14(281.65,27.08) v14(281.65,28.35) v14(281.65,29.62) 282.63,30.6 v14(282.63,30.81) v14(282.63,31.86) 282.63,32.15 281.91,32.87 v14(281.82,32.87) v14(280.55,32.87) v14(279.28,32.87) v14(278.01,32.87) v14(276.74,32.87) 276.38,32.87 275.94,32.42 v14(275.94,32.27) v14(275.94,31) v14(275.94,29.73) 275.94,29.43 v14(276.13,29.25) v14(277.02,28.35) 277.21,28.16 277.21,27.42 v14(277.28,27.03) 277.42,26.24 v14(277.5,25.78) v14(277.56,25.35) v14(277.34,24.1) 277.1,22.77 v14(277.04,22.71) v14(276.14,21.81) v14(275.25,20.91) v14(274.35,20.01) v14(273.45,19.11) v14(272.55,18.22) v14(271.65,17.32) v14(270.76,16.42) v14(269.86,15.52) v14(268.53,15.15) v14(267.28,15.37)
  GND4 w0.203: 117.21,47.95 H9.1 ; H9.1 119.31,45.85 ; H9.1 117.21,45.85 ; H9.1 119.31,47.95 ; H9.1 118.26,48.31 ; H9.1 118.26,45.49 ; H9.1 116.85,46.9 ; H9.1 119.67,46.9 ; 110.55,77.25 H15.1 ; H15.1 109.3,80.2 ; H15.1 110.55,80.65 ; H15.1 109.3,77.7 ; H15.1 111.8,80.2 ; H15.1 112.25,78.95 ; H15.1 108.85,78.95 ; H15.1 111.8,77.7 ; H18.1 93.63,71.85 ; H18.1 91.26,70.84 ; H18.1 90.91,71.85 ; H18.1 91.26,72.86 ; H18.1 92.27,70.49 ; H18.1 93.28,72.86 ; H18.1 92.27,73.21 ; H18.1 93.28,70.84 ; 181.49,45.85 H10.1 ; H10.1 182.54,45.49 ; H10.1 181.13,46.9 ; H10.1 183.59,47.95 ; H10.1 182.54,48.31 ; H10.1 183.59,45.85 ; H10.1 183.95,46.9 ; H10.1 181.49,47.95 ; H23.1 70.2,3.95 ; H23.1 69.02,1.17 ; H23.1 68.6,2.35 ; H23.1 71.38,3.53 ; H23.1 70.2,0.75 ; H23.1 69.02,3.53 ; H23.1 71.38,1.17 ; H23.1 71.8,2.35 ; 195.05,70.15 H16.1 ; H16.1 193.8,73.1 ; H16.1 193.8,70.6 ; H16.1 196.3,70.6 ; H16.1 196.3,73.1 ; H16.1 193.35,71.85 ; H16.1 196.75,71.85 ; H16.1 195.05,73.55 ; JCR1.19 288.29,45.45 ; JCR1.19 287.24,44.7 ; JCR1.19 286.18,44.7 ; JCR1.19 286.18,45.45 ; JCR1.19 288.29,44.7 ; 117.21,24.12 H11.1 ; H11.1 116.85,25.17 ; H11.1 118.26,26.58 ; H11.1 119.31,26.22 ; H11.1 119.31,24.12 ; H11.1 117.21,26.22 ; H11.1 118.26,23.76 ; H11.1 119.67,25.17 ; 26.8,56.34 H2.1 ; H2.1 25.39,57.75 ; H2.1 26.8,59.16 ; H2.1 25.75,58.8 ; H2.1 25.75,56.7 ; H2.1 27.85,58.8 ; H2.1 28.21,57.75 ; H2.1 27.85,56.7 ; 2.9,70.34 H1.1 ; H1.1 2.9,73.16 ; H1.1 3.95,70.7 ; H1.1 1.85,72.8 ; H1.1 3.95,72.8 ; H1.1 1.49,71.75 ; H1.1 4.31,71.75 ; H1.1 1.85,70.7 ; H7.1 267.05,58.8 ; H7.1 267.41,57.75 ; H7.1 264.95,58.8 ; H7.1 264.59,57.75 ; H7.1 266,59.16 ; H7.1 266,56.34 ; H7.1 267.05,56.7 ; H7.1 264.95,56.7 ; H25.1 292.22,3.11 ; H25.1 291.8,4.29 ; H25.1 291.8,1.93 ; H25.1 290.62,1.51 ; H25.1 289.44,4.29 ; H25.1 289.44,1.93 ; H25.1 289.02,3.11 ; H25.1 290.62,4.71 ; H8.1 4.75,53.35 ; H8.1 1.54,54.71 ; H8.1 4.26,54.71 ; H8.1 2.9,51.5 ; H8.1 1.54,51.99 ; H8.1 1.05,53.35 ; H8.1 2.9,55.2 ; H8.1 4.26,51.99 ; 24.13,27.86 H3.1 ; H3.1 24.13,30.68 ; H3.1 25.18,30.32 ; H3.1 25.18,28.22 ; H3.1 22.72,29.27 ; H3.1 25.54,29.27 ; H3.1 23.08,28.22 ; H3.1 23.08,30.32 ; H17.1 20.06,70.24 ; H17.1 19.05,69.89 ; H17.1 17.69,71.25 ; H17.1 20.06,72.26 ; H17.1 18.04,70.24 ; H17.1 20.41,71.25 ; H17.1 18.04,72.26 ; H5.1 233.3,19.22 ; H5.1 233.3,21.58 ; H5.1 232.12,18.8 ; H5.1 230.94,21.58 ; H5.1 230.94,19.22 ; H5.1 233.72,20.4 ; H5.1 230.52,20.4 ; H5.1 232.12,22 ; 286.89,84.36 H21.1 ; H21.1 286.89,82.34 ; H21.1 287.9,84.71 ; H21.1 286.54,83.35 ; H21.1 287.9,81.99 ; H21.1 288.91,84.36 ; H21.1 288.91,82.34 ; H21.1 289.26,83.35 ; H12.1 183.59,26.22 ; H12.1 183.59,24.12 ; H12.1 181.49,26.22 ; H12.1 183.95,25.17 ; H12.1 181.49,24.12 ; H12.1 181.13,25.17 ; H12.1 182.54,26.58 ; H12.1 182.54,23.76 ; 199.19,71.85 H20.1 ; H20.1 201.56,70.84 ; H20.1 200.55,73.21 ; H20.1 199.54,72.86 ; H20.1 200.55,70.49 ; H20.1 201.56,72.86 ; H20.1 201.91,71.85 ; H20.1 199.54,70.84 ; H22.1 223.78,3.53 ; H22.1 222.6,0.75 ; H22.1 222.6,3.95 ; H22.1 221,2.35 ; H22.1 223.78,1.17 ; H22.1 224.2,2.35 ; H22.1 221.42,1.17 ; H22.1 221.42,3.53 ; JCR1.22 287.24,62.1 ; JCR1.22 286.18,62.1 ; JCR1.22 286.18,61.35 ; JCR1.22 288.29,62.1 ; JCR1.22 288.29,61.35 ; H4.1 65.43,20.86 ; H4.1 63.33,20.86 ; H4.1 63.33,22.96 ; H4.1 64.38,23.32 ; H4.1 65.79,21.91 ; H4.1 64.38,20.5 ; H4.1 62.97,21.91 ; H4.1 65.43,22.96 ; 116.65,19.22 H13.1 ; H13.1 119.01,21.58 ; H13.1 119.01,19.22 ; H13.1 117.83,22 ; H13.1 119.43,20.4 ; H13.1 116.23,20.4 ; H13.1 116.65,21.58 ; H13.1 117.83,18.8 ; 1,4.29 H24.1 ; H24.1 3.36,1.93 ; H24.1 2.18,4.71 ; H24.1 2.18,1.51 ; H24.1 3.78,3.11 ; H24.1 0.58,3.11 ; H24.1 3.36,4.29 ; H24.1 1,1.93 ; H19.1 149.51,78.99 ; H19.1 149.51,81.01 ; H19.1 147.14,80 ; H19.1 148.5,78.64 ; H19.1 147.49,78.99 ; H19.1 148.5,81.36 ; H19.1 149.86,80 ; H19.1 147.49,81.01 ; H14.1 177.65,80.2 ; H14.1 174.7,78.95 ; H14.1 175.15,77.7 ; H14.1 175.15,80.2 ; H14.1 178.1,78.95 ; H14.1 176.4,77.25 ; H14.1 176.4,80.65 ; H14.1 177.65,77.7 ; H6.1 269.72,28.22 ; H6.1 268.67,27.86 ; H6.1 268.67,30.68 ; H6.1 267.26,29.27 ; H6.1 269.72,30.31 ; H6.1 267.62,30.31 ; H6.1 270.08,29.27 ; H6.1 267.62,28.22
  BOTTOM w0.102: 154.13,82.26 154.77,82.26 154.89,82.38 v5(155.56,82.38) 155.56,81.28 155.12,80.85 155.12,79.73 155.49,79.37 155.49,78.54 157.84,76.19 157.84,75.83 157.58,75.58 157.22,75.58 154.67,78.14 v5(154.67,78.71) 154.67,79.32 153.7,80.29 153.7,81.83 154.13,82.26
  BOTTOM w0.254: CC191.2 134.58,41.03 134.69,41.15 v9(134.69,41.3) ; v5(158.06,41.32) 158.3,41.57 158.57,41.57 158.8,41.79 v5(159.07,41.79) 159.42,41.79 159.6,41.62 159.82,41.62 v5(160.12,41.32) 160.53,41.74 162.31,41.74 162.39,41.82 163.25,41.82 v5(163.75,41.32) ; UPD4.4 v9(243.05,8.36)
  BOTTOM w0.305: JDEBUG2.9 v9(212.03,69.87) ; 221.29,69.97 v5(221.29,70.93) ; JDB4.7 v5(289.83,28.44) ; JAPS1.8 v5(218.22,59.27)
  BOTTOM w0.356: v5(156.23,27.11) 156.65,27.11 156.81,27.28 156.81,27.62 153.87,27.62 v5(153.5,27.25) ; v11(176.94,33.88) RC691.1 RC692.1 ; C1686.2 v5(201.39,46.89) ; v5(200.76,46.89) C1687.2 C1689.2 ; R709.2 157.25,78.43 156.65,79.03 v9(156.65,79.92) ; v9(171.04,36.71) CC656.2
  BOTTOM w0.381: C635.2 164.92,76.35 v5(165.37,76.81)
  BOTTOM w0.406: JDEBUG2.11 v11(207.03,72.55) ; 215.79,72.47 v5(216.33,72.47) ; v5(212.95,72.36) 213.53,71.78 JDEBUG2.12 ; 222.29,72.47 v5(221.65,72.47)
  BOTTOM w0.508: v5(165.24,75.65) 165.18,75.59 C625.2 ; PC236.2 88.12,30.72 v5(87.73,30.33) ; v5(68.61,26.52) SW1.4 ; v5(113.94,7.88) 113.94,8.98 JMIPI60.62 ; UPD3.4 15.38,18.6 16.16,17.82 v11(16.35,17.82) ; SW1.2 v5(68.61,25.63)
  vias: v1(126.22,43.78) v1(130.14,77.32) v1(132.24,77.25) v1(136.15,46.18) v1(142.02,77.32) v1(144.11,77.32) v1(183.1,70.84) v1(183.1,68.3) v1(183.1,67.54) v1(183.1,66.27) v1(183.1,65) v1(183.1,64.24) v1(183.1,62.97) v1(183.1,61.7) v1(183.1,60.94) v1(183.1,59.67) v1(183.1,58.4) v1(184.37,70.84) v1(184.37,68.3) v1(184.37,67.54) v1(184.37,66.27) v1(184.37,65) v1(184.37,64.24) v1(184.37,62.97) v1(184.37,61.7) v1(184.37,60.94) v1(184.37,59.67) v1(184.37,58.4) v1(185.64,70.84) v1(185.64,68.3) v1(185.64,67.54) v1(185.64,66.27) v1(185.64,65) v1(185.64,64.24) v1(185.64,62.97) v1(185.64,61.7) v1(185.64,60.94) v1(185.64,59.67) v1(185.64,58.4) v1(186.4,70.84) v1(186.4,68.3) v1(186.4,67.54) v1(186.4,66.27) v1(186.4,65) v1(186.4,64.24) v1(186.4,62.97) v1(186.4,61.7) v1(186.4,60.94) v1(186.4,59.67) v1(186.4,58.4) v1(187.67,70.84) v1(187.67,68.3) v1(187.67,67.54) v1(187.67,66.27) v1(187.67,65) v1(187.67,64.24) v1(187.67,62.97) v1(187.67,61.7) v1(187.67,60.94) v1(187.67,59.67) v1(187.67,58.4) v1(188.56,77.25) v1(188.56,76.81) v1(188.94,70.84) v1(188.94,68.3) v1(188.94,67.54) v1(188.94,66.27) v1(188.94,65) v1(188.94,64.24) v1(188.94,62.97) v1(188.94,61.7) v1(188.94,60.94) v1(188.94,59.67) v1(188.94,58.4) v1(189,77.9) v1(189.33,77.25) v1(189.33,76.81) v1(190.09,77.25) v1(190.09,76.81) v1(190.9,60.62) v1(190.91,58.65) v1(275.18,55.45) v1(275.37,56.97) v1(276.27,41.86) v1(277.31,41.86) v1(277.57,42.68) v1(279.09,42.68) v1(282.86,27.11) v1(283.24,27.98) v2(0.43,2.68) v2(0.62,4.06) v2(1.23,1.55) v2(1.75,4.89) v2(2.61,1.33) v2(3.13,4.67) v2(3.74,2.16) v2(3.96,3.54) v2(15.06,60.63) v2(15.06,59.08) v2(16.29,66.37) v2(16.28,64.82) v2(18.36,56.07) v2(18.81,55.29) v2(20.75,0.91) v2(21.19,23.56) v2(22.02,0.91) v2(22.17,23.37) v2(23.29,0.91) v2(24.56,0.91) v2(25.83,0.91) v2(27.1,0.91) v2(28.37,0.91) v2(29.64,0.91) v2(30.91,0.91) v2(32.18,0.91) v2(54.49,0.91) v2(55.76,0.91) v2(57.03,0.91) v2(58.3,0.91) v2(59.57,0.91) v2(60.84,0.91) v2(62.11,0.91) v2(62.61,16.28) v2(63.38,0.91) v2(64.19,16.09) v2(64.65,0.91) v2(65.92,0.79) v2(70.33,74.01) v2(71.6,74.01) v2(73.97,77.69) v2(76.42,73.63) v2(77.44,74.08) v2(83.11,77.86) v2(93.19,62.39) v2(93.19,59.85) v2(108.94,77.82) v2(108.87,65.76) v2(110.1,56.81) v2(110.52,61.12) v2(110.64,64.51) v2(110.76,67.38) v2(110.8,65.51) v2(111.52,68.03) v2(111.54,55.66) v2(111.61,65.56) v2(111.62,64.13) v2(111.62,63.48) v2(111.62,58.93) v2(112.02,67.4) v2(112.02,54.27) v2(112.06,61.36) v2(112.17,62.3) v2(112.23,51.59) v2(112.44,65.56) v2(112.43,64.08) v2(112.36,58.93) v2(112.49,66.65) v2(112.45,56.39) v2(112.72,68.13) v2(112.81,52.66) v2(113.05,77.09) v2(113.22,59.58) v2(113.22,57.63) v2(113.23,55.68) v2(113.26,67.39) v2(113.26,65.69) v2(113.61,61.35) v2(113.8,66.25) v2(114.17,58.44) v2(114.27,79.98) v2(114.27,79.32) v2(114.33,62.56) v2(115.35,79.97) v2(115.35,79.31) v2(115.32,60.98) v2(115.37,68.68) v2(115.37,65.58) v2(115.79,56.36) v2(116.2,61) v2(116.36,79.96) v2(116.36,79.29) v2(116.4,67.99) v2(116.42,67.38) v2(116.42,65.44) v2(116.36,64.17) v2(117.14,60.96) v2(117.22,66.17) v2(117.22,58.93) v2(117.95,77.19) v2(118.02,67.38) v2(117.97,65.51) v2(118.02,64.13) v2(118.03,63.5) v2(117.96,62.66) v2(118.02,59.58) v2(118.02,58.93) v2(118.6,60.84) v2(118.81,58.9) v2(118.78,57.63) v2(118.78,57) v2(118.84,55.73) v2(118.94,62.6) v2(119.22,77.19) v2(120.34,77.33) v2(124.02,84.5) v2(124.34,60.03) v2(125.09,64.83) v2(125.13,62.84) v2(125.11,61.12) v2(125.19,63.31) v2(125.27,55.65) v2(125.37,59.93) v2(125.62,67.49) v2(125.61,66.66) v2(125.62,65.59) v2(125.62,57.63) v2(125.64,56.48) v2(126.21,61.78) v2(126.46,66.65) v2(126.48,59.58) v2(126.51,55.36) v2(126.7,62.87) v2(126.83,16.27) v2(126.98,61.29) v2(127.25,64.04) v2(127.29,65.58) v2(127.29,60.55) v2(127.38,57.63) v2(127.38,55.05) v2(127.6,68.15) v2(128.04,63.52) v2(127.96,54.65) v2(128.11,65.63) v2(128.09,59.42) v2(128.07,55.83) v2(128.27,45.12) v2(128.26,43.79) v2(128.33,40.59) v2(128.42,46.31) v2(128.51,61.44) v2(128.47,57.19) v2(128.68,41.35) v2(128.82,66.95) v2(128.76,61.04) v2(128.78,43.14) v2(128.94,52.42) v2(129,63.56) v2(129.18,64.63) v2(129.38,52.42) v2(129.64,69.14) v2(129.63,65.48) v2(129.74,64.61) v2(129.69,43.14) v2(129.69,41.85) v2(129.76,61.04) v2(130.33,75.09) v2(130.45,63.84) v2(130.39,59.73) v2(130.45,57.15) v2(130.53,77.25) v2(130.61,44.45) v2(130.61,43.71) v2(130.61,43.14) v2(130.61,41.85) v2(130.99,54.31) v2(131.04,45.39) v2(131.16,78.14) v2(131.16,77.25) v2(131.28,67.38) v2(131.28,65.45) v2(131.28,63.39) v2(131.33,60.74) v2(131.6,43.85) v2(131.74,78.14) v2(131.73,75.09) v2(131.69,61.4) v2(131.86,77.25) v2(132.05,50.72) v2(132.08,66.08) v2(132.09,63.99) v2(132.06,62.9) v2(132.08,58.92) v2(132.42,44.42) v2(132.44,43.86) v2(132.44,43.24) v2(132.44,42.63) v2(132.49,69.14) v2(132.49,61.31) v2(132.65,60.21) v2(132.85,64.04) v2(132.87,67.4) v2(132.94,58.33) v2(132.96,58.95) v2(133.04,56.42) v2(133.32,60.58) v2(133.32,42.6) v2(133.36,45.01) v2(133.36,44.5) v2(133.35,43.86) v2(133.48,46.65) v2(133.61,62.36) v2(133.58,59.6) v2(133.58,57.62) v2(133.67,56.23) v2(133.84,64.15) v2(133.88,63.44) v2(134.08,84.3) v2(134.18,43.33) v2(134.39,44.86) v2(134.66,81.21) v2(134.94,61.9) v2(134.93,59.99) v2(135.21,42.58) v2(135.33,84.14) v2(135.33,44.87) v2(135.38,69.41) v2(135.73,80.49) v2(135.77,67.39) v2(135.77,57.43) v2(136.15,65.91) v2(136.1,44.43) v2(136.1,43.86) v2(136.11,43.22) v2(136.1,42.59) v2(136.51,64.6) v2(136.49,45.65) v2(136.62,84.3) v2(136.63,63.55) v2(136.63,62.11) v2(136.63,60.68) v2(136.68,56.3) v2(137.01,44.23) v2(137.01,43.14) v2(137,41.15) v2(137.16,48.24) v2(137.29,80.98) v2(137.38,67.73) v2(137.52,41.51) v2(137.89,83.54) v2(137.93,44.25) v2(137.93,43.14) v2(138.15,55.41) v2(138.27,80.49) v2(138.37,41.53) v2(138.84,44.45) v2(138.84,43.71) v2(138.84,43.14) v2(138.88,67.69) v2(139.16,84.3) v2(139.21,41.56) v2(139.3,65.45) v2(139.38,63.26) v2(139.38,61.7) v2(139.4,60.86) v2(139.43,59.17) v2(139.43,58.32) v2(139.69,81.04) v2(139.75,44.22) v2(139.76,43.14) v2(140.04,67.13) v2(139.99,55.66) v2(140.06,55.15) v2(140.22,41.55) v2(140.43,83.54) v2(140.67,44.22) v2(140.67,43.14) v2(140.81,80.49) v2(141.12,41.83) v2(141.59,44.45) v2(141.59,43.71) v2(141.59,43.14) v2(141.7,84.3) v2(141.9,41.56) v2(142.02,78.14) v2(142.03,65.76) v2(142.15,58.2) v2(142.16,60.93) v2(142.5,43.14) v2(142.76,67.37) v2(142.77,57.63) v2(142.83,55.68) v2(142.91,68.78) v2(142.9,60.38) v2(142.97,83.54) v2(143.03,78.14) v2(143.03,77.32) v2(143.42,43.14) v2(143.42,41.85) v2(143.48,62.14) v2(143.61,65.56) v2(143.62,63.48) v2(143.62,59.58) v2(143.62,58.93) v2(143.63,57.53) v2(143.73,77.32) v2(143.98,41.82) v2(144.05,83.54) v2(144.14,82.76) v2(144.05,81.38) v2(144.11,78.14) v2(144.24,84.3) v2(144.33,44.45) v2(144.33,43.71) v2(144.33,43.14) v2(144.43,66.27) v2(144.42,64.13) v2(144.42,58.93) v2(144.52,65.43) v2(144.46,57.54) v2(144.75,80.11) v2(144.66,41.79) v2(144.8,82.23) v2(144.94,61.05) v2(145.13,81.19) v2(145.25,43.14) v2(145.23,41.53) v2(145.32,66.72) v2(145.27,62.11) v2(145.26,57.39) v2(145.31,55.55) v2(145.56,65.42) v2(145.71,58.01) v2(145.89,80.24) v2(145.93,62.1) v2(145.94,58.75) v2(146.02,81.89) v2(146.15,81.13) v2(146.15,45.69) v2(146.16,43.14) v2(146.16,41.85) v2(146.27,78.71) v2(146.27,50.33) v2(146.29,49.83) v2(146.83,62.05) v2(147.08,44.32) v2(147.08,43.71) v2(147.08,43.16) v2(147.07,42.14) v2(147.21,64.06) v2(147.4,48.28) v2(147.5,60.59) v2(147.48,58.77) v2(147.94,66.66) v2(147.99,64.79) v2(147.98,44.26) v2(147.97,43.04) v2(147.99,41.82) v2(148.2,57.61) v2(148.42,63.48) v2(148.41,61.71) v2(148.46,66) v2(148.49,45.71) v2(148.57,41.74) v2(149,43.83) v2(148.97,43.23) v2(149.13,41.76) v2(149.23,58.94) v2(149.21,56.35) v2(149.28,67.24) v2(149.26,65.51) v2(149.28,64.1) v2(149.64,61.44) v2(149.81,45.06) v2(149.82,43.92) v2(149.83,43.25) v2(149.8,42.63) v2(149.79,41.53) v2(149.93,64.97) v2(149.93,56.35) v2(150.03,64.12) v2(150.02,59.58) v2(150.02,58.93) v2(149.97,54.89) v2(150.25,47.92) v2(150.27,41.87) v2(150.75,42.58) v2(150.85,78.46) v2(150.78,65.38) v2(150.78,57.63) v2(150.79,56.98) v2(151.04,80.81) v2(151,61.96) v2(151.23,82.14) v2(151.23,79.35) v2(151.16,67.65) v2(151.53,43.28) v2(151.53,42.66) v2(151.61,45.45) v2(151.61,44.59) v2(152,82.07) v2(151.99,80.94) v2(152.05,83.09) v2(152.5,78.46) v2(152.54,65.74) v2(152.62,82.14) v2(152.57,44.45) v2(152.57,43.71) v2(152.69,76.81) v2(153.39,84.56) v2(153.45,42.65) v2(153.5,41.63) v2(153.83,81.44) v2(153.83,80.36) v2(153.77,67.06) v2(153.89,79.09) v2(153.89,78.46) v2(153.89,64.43) v2(153.89,59.35) v2(153.96,62.14) v2(154.16,45.73) v2(154.4,43.14) v2(154.43,41.46) v2(154.72,67.07) v2(154.9,65.66) v2(155.03,82.25) v2(155.19,81) v2(155.25,47.67) v2(155.31,44.32) v2(155.31,43.71) v2(155.31,43.14) v2(155.61,79.85) v2(155.65,41.92) v2(155.91,84.59) v2(155.87,68.07) v2(156.01,55.42) v2(156.23,43.14) v2(156.31,81.19) v2(156.37,67.3) v2(156.37,66.71) v2(156.36,65.43) v2(156.42,59.05) v2(156.37,57.5) v2(156.52,55.69) v2(156.6,41.43) v2(156.78,61.24) v2(157.13,66.69) v2(157.1,63.48) v2(157.12,56.79) v2(157.11,45.08) v2(157.13,43.14) v2(157.18,59.6) v2(157.35,58.91) v2(157.43,62.26) v2(157.5,69.37) v2(157.57,84.7) v2(157.87,64.16) v2(158.03,65.53) v2(158.01,62.9) v2(158.02,60.15) v2(158.11,68.03) v2(158.09,55.06) v2(158.21,61.1) v2(158.33,56.68) v2(158.48,84.61) v2(158.71,67.37) v2(158.85,65.66) v2(158.81,63.6) v2(158.77,62.25) v2(158.81,59.65) v2(158.85,55.55) v2(158.88,57.39) v2(159.49,59.57) v2(159.66,54.47) v2(159.76,63.33) v2(159.93,61.35) v2(160.18,69.7) v2(160.29,65.76) v2(161.02,84.59) v2(160.95,63.98) v2(161.06,49.42) v2(161.23,60.78) v2(161.25,59.16) v2(161.61,61.69) v2(162.01,67.38) v2(161.96,65.8) v2(162.01,54.49) v2(162.08,84.89) v2(162.81,64.06) v2(162.81,59.01) v2(162.82,57.48) v2(162.77,55.69) v2(163.11,61.84) v2(163.35,84.67) v2(163.35,62.85) v2(163.4,60.2) v2(163.73,63.49) v2(163.72,59.59) v2(163.8,61.32) v2(163.93,58.6) v2(164.41,57.63) v2(164.66,69.44) v2(164.85,61.52) v2(164.96,62.85) v2(165,60.19) v2(165.45,82.14) v2(165.74,61.23) v2(166.09,84.61) v2(166.09,75.67) v2(166.21,78.84) v2(166.35,81.95) v2(166.42,58.66) v2(166.85,78.21) v2(167.23,78.84) v2(167.28,26.74) v2(167.59,67.41) v2(168.36,28.56) v2(168.5,63.13) v2(168.55,62.17) v2(168.54,58.46) v2(168.65,84.64) v2(169.92,82.79) v2(169.9,81.51) v2(169.9,80.36) v2(170.28,25.31) v2(171.04,83.41) v2(171.04,82.4) v2(171.04,81.25) v2(170.99,27.99) v2(171.17,84.56) v2(171.2,27.28) v2(171.19,26.35) v2(171.42,79.48) v2(171.5,25.82) v2(171.67,44.22) v2(171.86,24.93) v2(172.05,83.35) v2(172.05,82.33) v2(172.45,44.6) v2(172.41,26.77) v2(172.66,27.72) v2(175.61,74.78) v2(177.13,74.78) v2(178.28,74.78) v2(179.55,74.78) v2(179.74,73.89) v2(180.82,74.78) v2(181.01,73.89) v2(182.09,74.78) v2(182.28,73.89) v2(183.36,74.78) v2(183.43,66.26) v2(183.43,62.96) v2(183.53,59.66) v2(184.63,74.78) v2(184.63,73.89) v2(184.7,66.26) v2(184.7,62.96) v2(184.7,59.66) v2(185.24,77.85) v2(185.31,66.26) v2(185.31,62.96) v2(185.31,59.66) v2(185.82,74.78) v2(185.9,73.89) v2(186.74,66.26) v2(186.74,62.96) v2(186.74,59.66) v2(187.17,74.78) v2(187.17,73.89) v2(188.01,66.26) v2(188.01,62.96) v2(188.01,59.66) v2(188.18,77.25) v2(188.18,76.81) v2(188.44,74.78) v2(188.56,66.26) v2(188.56,62.96) v2(188.58,59.66) v2(188.95,77.25) v2(188.95,76.81) v2(189.31,73.91) v2(189.71,77.25) v2(189.71,76.81) v2(189.71,74.78) v2(190.22,73.89) v2(190.85,76.94) v2(190.85,75.79) v2(190.98,74.78) v2(191.49,73.89) v2(191.74,75.79) v2(192.12,76.94) v2(192.25,74.78) v2(192.25,72.36) v2(192.25,70.78) v2(192.76,73.57) v2(193.2,71.47) v2(193.52,69.32) v2(193.83,73.25) v2(194.09,70.14) v2(195.04,68.93) v2(195.68,73.63) v2(196.31,68.96) v2(196.5,70.52) v2(196.88,72.49) v2(197.5,69.15) v2(198.91,68.93) v2(200.12,68.93) v2(201.39,68.93) v2(202.6,68.95) v2(203.17,72.62) v2(203.17,71.35) v2(203.17,70.08) v2(203.77,73.63) v2(204.95,73.63) v2(206.22,73.63) v2(206.64,26.07) v2(207.34,75.06) v2(207.49,73.63) v2(208.15,75.06) v2(208.24,26.07) v2(208.76,73.63) v2(208.96,75.06) v2(209.78,75.06) v2(210.03,73.63) v2(210.59,75.06) v2(211.3,73.63) v2(212.57,73.63) v2(213.84,73.63) v2(215.11,73.63) v2(216.42,77.82) v2(216.38,73.63) v2(216.9,75.15) v2(217.65,73.63) v2(217.8,75.15) v2(218.92,73.63) v2(219.07,75.15) v2(219.65,22.41) v2(219.78,21.09) v2(219.92,75.14) v2(220.19,73.63) v2(221.19,22.56) v2(221.46,73.63) v2(222.75,73.3) v2(224.94,20.65) v2(228.16,0.91) v2(229.43,0.91) v2(230.7,0.91) v2(231.97,0.91) v2(232.51,4.99) v2(233.24,0.91) v2(234.51,0.91) v2(235.78,0.91) v2(237.05,0.91) v2(238.32,0.91) v2(239.24,20.67) v2(239.59,0.91) v2(240.04,20.39) v2(240.9,20.14) v2(240.86,0.91) v2(241.79,19.91) v2(242.01,0.91) v2(242.83,19.68) v2(242.79,1.79) v2(243.93,19.5) v2(244.04,1.91) v2(245.2,19.35) v2(245.31,1.91) v2(246.57,19.27) v2(246.58,1.91) v2(247.85,1.91) v2(247.85,19.27) v2(249.08,19.33) v2(249.12,1.91) v2(250.24,19.44) v2(250.39,1.91) v2(251.47,19.63) v2(251.66,1.91) v2(252.74,19.9) v2(252.93,1.91) v2(254.06,20.25) v2(254.2,1.91) v2(255.32,20.66) v2(255.47,1.91) v2(256.63,21.18) v2(256.74,1.91) v2(258.01,1.91) v2(258.1,21.87) v2(259.51,22.65) v2(259.74,1.59) v2(260.46,0.91) v2(260.86,23.53) v2(261.73,0.91) v2(262.21,24.55) v2(263,0.91) v2(263.3,25.48) v2(264.25,26.4) v2(264.27,0.91) v2(265.54,0.91) v2(266.81,0.91) v2(268.08,0.91) v2(269.35,0.91) v2(270.62,0.91) v2(271.89,0.91) v2(273.76,37.57) v2(275.18,55.45) v2(275.37,56.97) v2(275.59,60.15) v2(275.61,58.51) v2(276.27,41.86) v2(276.64,29.74) v2(277.13,63.47) v2(277.15,31.02) v2(277.31,41.86) v2(277.57,42.68) v2(278.61,63.47) v2(278.75,70.51) v2(278.75,70.01) v2(278.87,66.91) v2(279.09,42.68) v2(279.41,39.5) v2(279.92,66.91) v2(280.61,38.01) v2(281.31,38.81) v2(281.34,36) v2(281.72,15.72) v2(281.72,13.94) v2(281.72,12.67) v2(281.72,11.85) v2(282.42,15.72) v2(282.42,15.02) v2(282.42,13.94) v2(282.42,12.67) v2(282.42,11.85) v2(283.65,28.27) v2(283.62,26.68) v2(283.98,36) v2(285.05,34.35) v2(285.1,35.4) v2(288.89,2.64) v2(289.11,4.02) v2(289.72,1.51) v2(290.24,4.85) v2(291.1,1.29) v2(291.62,4.63) v2(292.05,62.33) v2(291.95,61.89) v2(292.04,61.16) v2(292.23,2.12) v2(292.39,3.53) v2(292.73,61.38) v4(7.29,48.09) v4(14.59,60.72) v4(14.61,58.97) v4(15.81,66.47) v4(16.59,64.46) v4(125.19,77.4) v4(127.1,84.25) v4(276.27,41.86) v4(277.31,41.86) v4(277.57,42.68) v4(278.87,66.91) v4(279.09,42.68) v4(279.92,66.91) v4(282.04,15.4) v4(282.04,14.45) v4(282.04,13.56) v4(282.04,12.99) v4(282.04,12.29) v4(282.8,15.4) v4(282.8,14.45) v4(282.8,13.56) v4(282.8,12.99) v4(282.8,12.29) v5(0.43,21.14) v5(0.43,19.87) v5(0.43,18.6) v5(0.43,17.33) v5(0.43,16.06) v5(0.43,8.82) v5(0.43,5.16) v5(0.45,6.08) v5(0.73,70.83) v5(0.73,69.56) v5(0.65,67.85) v5(0.74,56.49) v5(0.74,55.22) v5(0.74,53.95) v5(0.73,52.61) v5(0.67,10.07) v5(0.67,1.04) v5(0.84,53.35) v5(1.19,51.43) v5(1.28,72.4) v5(1.29,71.75) v5(1.47,21.87) v5(1.69,15.88) v5(1.87,55.13) v5(1.87,51.57) v5(1.93,10.21) v5(2.12,75.77) v5(2.09,73.15) v5(2.09,70.35) v5(2.19,74.27) v5(2.31,76.69) v5(2.44,48.96) v5(2.44,47.69) v5(2.44,46.42) v5(2.44,45.15) v5(2.45,43.94) v5(2.51,50.61) v5(2.63,15.03) v5(2.74,21.87) v5(2.73,13.76) v5(2.73,12.49) v5(2.71,11.22) v5(3.28,43.93) v5(3.58,76.77) v5(3.71,73.15) v5(3.71,70.35) v5(3.93,55.13) v5(3.93,51.57) v5(4.01,21.87) v5(4.3,0.93) v5(4.43,43.38) v5(4.51,71.75) v5(4.73,42.15) v5(4.73,40.88) v5(4.73,39.61) v5(4.85,76.77) v5(4.96,53.35) v5(5.28,21.88) v5(5.57,0.93) v5(5.71,38.8) v5(6.12,76.77) v5(6.34,22.58) v5(6.5,37.81) v5(6.53,36.54) v5(6.53,35.27) v5(6.53,34) v5(6.53,32.73) v5(6.53,31.46) v5(6.53,30.19) v5(6.53,28.92) v5(6.53,27.65) v5(6.53,26.38) v5(6.53,25.11) v5(6.53,23.84) v5(6.83,13.82) v5(6.83,13.24) v5(6.84,0.93) v5(7.08,12.67) v5(7.39,76.77) v5(7.4,13.82) v5(7.4,13.24) v5(8.04,13.81) v5(8.03,13.24) v5(8.11,0.93) v5(8.41,65.57) v5(8.41,59.58) v5(8.66,76.77) v5(9.38,0.93) v5(9.75,76.77) v5(9.94,39.72) v5(10.17,38.16) v5(10.65,0.93) v5(10.76,54.2) v5(11.16,38.16) v5(11.44,39.72) v5(11.53,66.71) v5(11.71,52.72) v5(11.92,0.93) v5(12.43,39.72) v5(12.54,67.92) v5(12.64,38.41) v5(12.8,66.39) v5(12.93,75.27) v5(13.24,68.11) v5(13.19,0.93) v5(13.37,66.14) v5(13.66,38.41) v5(13.82,74.36) v5(13.79,60.88) v5(13.88,68.11) v5(13.94,66.06) v5(13.98,39.72) v5(14.46,0.93) v5(14.72,73.46) v5(14.78,43.67) v5(14.97,39.72) v5(15.71,72.66) v5(15.73,0.93) v5(16.48,71.35) v5(16.95,72.42) v5(17,0.93) v5(17.49,71.25) v5(17.73,30.9) v5(18.27,69.9) v5(18.27,0.93) v5(18.82,53.76) v5(19.4,68.55) v5(19.54,0.93) v5(19.83,69.9) v5(20.38,72.42) v5(20.61,71.25) v5(20.67,67.66) v5(21.81,71.69) v5(21.81,70.42) v5(21.81,69.15) v5(21.81,67.88) v5(21.81,66.61) v5(21.81,49.03) v5(21.81,47.76) v5(21.81,46.49) v5(21.81,45.22) v5(21.81,43.95) v5(21.81,42.68) v5(21.89,65.34) v5(21.94,50.29) v5(21.86,41.41) v5(21.97,40.15) v5(22.16,38.89) v5(22.41,37.65) v5(22.54,64.25) v5(22.52,29.27) v5(22.64,51.35) v5(22.73,36.42) v5(22.83,9.63) v5(23.11,35.21) v5(23.32,30.67) v5(23.32,27.87) v5(23.55,52.24) v5(23.46,9.63) v5(23.56,34.02) v5(24.07,32.85) v5(24.1,9.63) v5(24.25,62.58) v5(24.46,53.13) v5(24.64,31.72) v5(24.94,30.67) v5(24.94,27.87) v5(24.99,8.19) v5(25.15,61.69) v5(25.19,57.75) v5(25.36,54.01) v5(25.56,8.36) v5(25.74,29.27) v5(25.99,59.15) v5(25.99,56.35) v5(26.06,60.8) v5(26.27,54.9) v5(26.71,28.52) v5(26.78,60.09) v5(26.98,55.95) v5(27.51,27.54) v5(27.61,59.15) v5(27.61,56.35) v5(28.41,57.75) v5(28.36,26.59) v5(29.26,25.7) v5(30.21,24.85) v5(31.2,24.06) v5(32.23,23.32) v5(32.88,0.93) v5(33.15,1.45) v5(33.3,22.64) v5(33.62,1.87) v5(34.2,1.93) v5(34.41,22.01) v5(34.73,6.14) v5(34.84,1.93) v5(35.14,6.57) v5(35.54,21.44) v5(35.47,1.93) v5(35.71,6.74) v5(36.11,1.93) v5(36.29,6.58) v5(36.71,20.94) v5(36.67,6.16) v5(36.66,5.26) v5(36.74,1.93) v5(37.08,5.72) v5(37.38,1.93) v5(37.9,20.5) v5(38.01,1.93) v5(38.65,1.93) v5(39.11,20.12) v5(39.28,1.93) v5(39.92,1.93) v5(40.34,19.81) v5(40.55,1.93) v5(41.19,1.93) v5(41.59,19.57) v5(41.82,1.93) v5(42.85,19.39) v5(43.09,1.93) v5(44.11,19.28) v5(44.36,1.93) v5(45.38,19.24) v5(45.63,1.93) v5(46.9,1.93) v5(47.34,19.3) v5(48.17,1.93) v5(48.6,19.43) v5(49.44,1.93) v5(49.86,19.63) v5(50.71,1.93) v5(51.1,19.9) v5(51.98,1.93) v5(52.32,20.23) v5(52.92,0.95) v5(53.53,20.62) v5(54.72,21.08) v5(55.87,21.6) v5(57,22.19) v5(58.1,22.83) v5(59.21,23.44) v5(60.47,23.57) v5(61.74,23.71) v5(62.72,24.51) v5(63.62,25.4) v5(64.48,26.33) v5(65.3,27.31) v5(66.06,28.33) v5(66.57,0.44) v5(66.77,29.38) v5(67.43,30.47) v5(67.84,0.43) v5(67.97,35.22) v5(68.03,31.58) v5(68.12,33.96) v5(68.36,36.43) v5(68.52,32.76) v5(68.67,37.66) v5(68.92,38.91) v5(69.11,40.17) v5(69.22,41.43) v5(69.27,76.99) v5(69.27,75.72) v5(69.27,74.45) v5(69.27,73.18) v5(69.27,71.91) v5(69.27,70.64) v5(69.27,69.37) v5(69.27,68.1) v5(69.27,66.83) v5(69.27,65.56) v5(69.27,64.29) v5(69.27,63.02) v5(69.27,61.75) v5(69.27,60.48) v5(69.27,59.21) v5(69.27,57.94) v5(69.27,56.67) v5(69.27,55.4) v5(69.27,54.13) v5(69.27,52.86) v5(69.27,51.59) v5(69.27,50.32) v5(69.27,49.05) v5(69.27,47.78) v5(69.27,46.51) v5(69.27,45.24) v5(69.27,43.97) v5(69.27,42.7) v5(69.26,0.52) v5(70,77.82) v5(70.26,76.04) v5(70.64,76.8) v5(70.63,0.43) v5(70.84,75.03) v5(71.27,77.82) v5(71.53,76.04) v5(71.91,76.8) v5(72.11,75.03) v5(72.22,77.83) v5(72.22,76.04) v5(72.92,0.43) v5(74.17,0.62) v5(74.49,47.55) v5(74.49,46.94) v5(74.49,46.28) v5(74.49,45.62) v5(74.49,44.93) v5(74.52,44.22) v5(75.09,47.92) v5(75.1,47.24) v5(75.1,46.61) v5(75.1,46) v5(75.1,45.34) v5(75.1,44.68) v5(75.1,43.99) v5(75.41,0.93) v5(75.86,47.27) v5(76.68,0.93) v5(77.62,77.82) v5(77.95,0.93) v5(78.2,48.11) v5(78.2,47.47) v5(78.89,77.82) v5(78.99,60.12) v5(79.22,0.93) v5(79.5,60.48) v5(79.5,59.84) v5(79.5,59.21) v5(80.16,77.82) v5(80.21,59.18) v5(80.49,0.93) v5(81.24,77.82) v5(81.25,48.11) v5(81.25,47.47) v5(81.76,0.93) v5(81.88,48.11) v5(81.88,47.47) v5(83.03,0.93) v5(84.3,0.93) v5(85.08,48.36) v5(85.08,47.75) v5(85.57,0.93) v5(86.25,24.51) v5(86.38,49.4) v5(86.41,48.79) v5(86.51,77.82) v5(86.48,48.13) v5(86.84,0.93) v5(86.94,47.75) v5(86.94,25.63) v5(86.91,25.02) v5(86.91,24.38) v5(86.96,28.07) v5(86.96,27.46) v5(86.96,26.85) v5(86.96,26.24) v5(87.55,25.02) v5(87.55,24.38) v5(87.6,28.07) v5(87.6,27.46) v5(87.6,26.85) v5(87.6,26.24) v5(87.57,25.63) v5(87.78,77.82) v5(88.11,0.93) v5(89.05,77.82) v5(89.38,0.93) v5(89.85,77.81) v5(90.65,0.93) v5(90.71,71.85) v5(91.49,73.2) v5(91.49,70.5) v5(91.92,0.93) v5(92.92,77.83) v5(93.05,73.2) v5(93.05,70.5) v5(93.19,0.93) v5(93.83,71.85) v5(94.13,77.82) v5(94.46,0.93) v5(94.69,40.65) v5(94.69,40.07) v5(95.24,40.65) v5(95.24,40.07) v5(95.4,77.82) v5(95.73,0.93) v5(96.98,77.82) v5(97.02,40.77) v5(97.02,40.16) v5(97,0.93) v5(97.34,48.43) v5(97.34,46.29) v5(97.58,40.74) v5(97.58,40.13) v5(98.01,39.55) v5(98.04,38.99) v5(98.15,65.66) v5(98.14,40.74) v5(98.14,40.11) v5(98.14,30.45) v5(98.14,29.88) v5(98.15,64.67) v5(98.27,0.93) v5(98.44,77.82) v5(98.37,57.97) v5(98.37,56.97) v5(98.37,55.98) v5(98.37,54.97) v5(98.41,47.36) v5(98.7,40.77) v5(98.7,40.16) v5(98.72,39.55) v5(98.72,38.96) v5(98.71,30.45) v5(98.71,29.88) v5(99.28,30.45) v5(99.28,29.88) v5(99.41,77.82) v5(99.36,40.74) v5(99.38,40.16) v5(99.38,39.57) v5(99.36,38.96) v5(99.48,48.43) v5(99.48,46.29) v5(99.54,0.93) v5(99.74,32.82) v5(99.74,32.21) v5(99.74,31.65) v5(99.79,30.88) v5(100,55.17) v5(100,54.6) v5(100,54.03) v5(100,53.46) v5(99.97,40.79) v5(99.97,40.16) v5(99.99,39.42) v5(100.25,32.51) v5(100.25,31.9) v5(100.25,31.34) v5(100.48,77.82) v5(100.5,40.33) v5(100.48,39.77) v5(100.81,40.84) v5(100.83,38.56) v5(100.81,0.93) v5(100.91,29.41) v5(101.39,38.56) v5(101.47,29.41) v5(101.65,32.38) v5(101.65,31.77) v5(101.65,31.22) v5(102.03,41.25) v5(102,40.54) v5(101.98,38.56) v5(102.05,29.41) v5(102.08,0.93) v5(102.23,32.37) v5(102.2,31.76) v5(102.23,31.2) v5(102.28,41.88) v5(102.59,41.25) v5(102.61,40.54) v5(102.76,31.76) v5(102.79,31.2) v5(102.94,41.88) v5(103.17,41.25) v5(103.22,40.54) v5(103.3,32.43) v5(103.32,31.86) v5(103.35,31.3) v5(103.35,0.93) v5(103.6,41.88) v5(103.75,41.25) v5(103.83,40.56) v5(103.88,32.59) v5(103.91,31.98) v5(103.91,31.42) v5(104.03,39.8) v5(104.08,30.63) v5(104.38,40.68) v5(104.49,40.11) v5(104.51,39.41) v5(104.49,32.56) v5(104.49,32) v5(104.46,31.42) v5(104.64,30.88) v5(104.62,0.93) v5(105.07,32.56) v5(105.07,31.98) v5(105.57,32.29) v5(105.89,0.93) v5(106.83,77.82) v5(107.16,0.93) v5(107.28,81.25) v5(107.73,80.61) v5(108.43,0.93) v5(108.55,81.25) v5(109.48,80.64) v5(109.7,0.93) v5(109.82,81.25) v5(110.97,0.93) v5(111.09,81.25) v5(111.22,80.71) v5(112.24,0.93) v5(112.36,81.25) v5(112.55,80.61) v5(113.52,33.31) v5(113.52,32.75) v5(113.51,0.93) v5(113.63,81.25) v5(114.08,33.31) v5(114.08,32.75) v5(114.43,80.77) v5(114.64,33.32) v5(114.64,32.76) v5(114.78,0.93) v5(114.9,81.25) v5(115.2,33.32) v5(115.2,32.76) v5(115.26,80.75) v5(115.7,38.39) v5(115.73,34.07) v5(115.67,29.65) v5(116.05,0.93) v5(116.1,81.25) v5(116.22,29.65) v5(116.26,38.37) v5(116.3,34.07) v5(116.46,80.75) v5(116.65,46.9) v5(116.65,25.17) v5(116.82,38.37) v5(116.8,33.34) v5(116.78,29.65) v5(117.34,29.64) v5(117.32,0.93) v5(117.37,81.25) v5(117.38,38.38) v5(117.36,33.34) v5(117.45,48.3) v5(117.45,45.5) v5(117.45,26.57) v5(117.45,23.77) v5(117.64,80.75) v5(117.94,38.38) v5(117.85,34.06) v5(117.9,29.64) v5(118.23,77.76) v5(118.42,34.06) v5(118.5,38.38) v5(118.46,29.64) v5(118.59,0.93) v5(118.71,81.25) v5(118.82,29.12) v5(118.82,28.56) v5(118.9,80.61) v5(118.9,79.67) v5(118.9,78.4) v5(118.92,33.31) v5(119.03,29.67) v5(119.07,48.3) v5(119.07,45.5) v5(119.07,38.4) v5(119.07,26.57) v5(119.07,23.77) v5(119.29,77.76) v5(119.48,33.31) v5(119.63,38.4) v5(119.59,29.67) v5(119.87,46.9) v5(119.87,25.17) v5(119.86,0.93) v5(119.98,81.25) v5(119.98,34.06) v5(120.15,29.67) v5(120.19,38.4) v5(120.56,34.06) v5(120.75,84.21) v5(120.75,82) v5(120.75,38.39) v5(120.71,29.68) v5(120.76,83.22) v5(120.8,79.09) v5(120.8,77.82) v5(121,85) v5(121.05,33.31) v5(121.13,0.93) v5(121.3,38.39) v5(121.27,29.68) v5(121.61,33.31) v5(121.57,26.3) v5(121.79,85.42) v5(121.83,29.65) v5(121.86,38.39) v5(122.12,34.05) v5(122.17,26.3) v5(122.31,38.82) v5(122.44,29.37) v5(122.4,0.93) v5(122.56,25.22) v5(122.69,34.05) v5(122.99,29.35) v5(123.03,25.59) v5(123.24,85.42) v5(123.32,34.06) v5(123.58,35.52) v5(123.55,28.56) v5(123.6,26.22) v5(123.67,0.93) v5(123.9,34.06) v5(124.15,35.52) v5(124.14,28.56) v5(124.07,26.59) v5(124.47,36.02) v5(124.51,33.95) v5(124.52,33.36) v5(124.62,48.13) v5(124.73,35.49) v5(124.94,0.93) v5(125.06,33.95) v5(125.09,33.36) v5(125.19,48.13) v5(125.19,4.93) v5(125.31,35.49) v5(125.38,85.42) v5(126.21,0.93) v5(126.49,85.42) v5(127.48,0.93) v5(127.64,85.42) v5(128.75,0.93) v5(128.91,85.42) v5(130.02,0.93) v5(130.18,85.42) v5(130.8,79.69) v5(131.19,85.42) v5(131.29,0.93) v5(132.46,85.42) v5(132.56,0.93) v5(133.04,75.09) v5(133.53,85.42) v5(133.7,7.09) v5(133.83,0.93) v5(134.34,7.09) v5(134.46,76.34) v5(134.6,81.81) v5(134.8,75.09) v5(134.88,85.42) v5(134.97,7.09) v5(135.1,0.93) v5(135.61,7.09) v5(135.83,81.96) v5(136.15,85.42) v5(136.18,6.45) v5(136.25,76.42) v5(136.37,0.93) v5(136.88,6.45) v5(137.23,81.62) v5(137.42,85.42) v5(137.57,6.45) v5(137.64,0.93) v5(137.95,76.43) v5(138.27,6.45) v5(138.49,81.63) v5(138.91,0.93) v5(138.97,6.45) v5(139.54,74.84) v5(139.57,85.42) v5(139.63,76.12) v5(140.03,81.59) v5(140.18,12.1) v5(140.24,8.29) v5(140.18,0.93) v5(140.84,85.42) v5(141.31,82.43) v5(141.45,0.93) v5(141.64,81.7) v5(141.94,74.75) v5(142.72,0.93) v5(143.38,85.42) v5(143.48,80.62) v5(143.99,0.93) v5(144.65,85.42) v5(144.8,84.3) v5(145.26,0.93) v5(145.47,84.44) v5(145.88,83.24) v5(146.15,27.11) v5(146.53,0.93) v5(146.94,80) v5(147.04,27.16) v5(147.08,82.82) v5(147.72,81.35) v5(147.72,78.65) v5(147.85,23.61) v5(147.85,23.05) v5(147.8,0.93) v5(148.35,82.82) v5(148.37,23.32) v5(149.07,0.93) v5(149.17,23.79) v5(149.28,81.35) v5(149.28,78.65) v5(149.62,82.82) v5(150.06,80) v5(150.34,0.93) v5(150.84,83.17) v5(151.33,84.34) v5(151.61,0.93) v5(151.74,25.21) v5(152.01,85.42) v5(152.47,84.16) v5(152.88,0.93) v5(153.28,85.42) v5(154.15,0.93) v5(154.62,4.35) v5(155.42,12.34) v5(155.42,0.93) v5(155.75,4.37) v5(155.82,85.42) v5(155.98,12.34) v5(156.34,40.17) v5(156.46,40.79) v5(156.69,0.93) v5(156.97,4.37) v5(157.4,85.42) v5(157.5,12.37) v5(157.51,5.37) v5(157.67,26.4) v5(157.96,0.93) v5(158.06,12.37) v5(158.21,5.37) v5(158.29,4.39) v5(158.67,85.42) v5(158.91,5.37) v5(159.23,0.93) v5(159.48,4.39) v5(159.61,12.37) v5(159.61,5.37) v5(159.74,82.93) v5(159.82,85.42) v5(160.17,12.37) v5(160.31,5.37) v5(160.5,0.93) v5(160.7,4.39) v5(161.09,85.42) v5(161.21,82.85) v5(161.72,12.39) v5(161.77,0.93) v5(161.86,79.15) v5(161.97,4.39) v5(162.25,82.03) v5(162.28,12.39) v5(162.36,85.42) v5(162.4,82.8) v5(163.04,0.93) v5(163.16,4.39) v5(163.34,79.21) v5(163.44,85.42) v5(163.4,78.49) v5(163.73,81.99) v5(163.86,82.81) v5(163.86,5.43) v5(164.31,0.93) v5(164.38,4.39) v5(164.5,5.43) v5(164.71,85.42) v5(164.97,82.83) v5(165,78.91) v5(165.13,5.43) v5(165.6,4.39) v5(165.58,0.93) v5(165.77,5.43) v5(165.98,85.42) v5(166.33,79.49) v5(166.4,5.43) v5(166.8,4.39) v5(166.85,0.93) v5(167.25,85.42) v5(168.02,4.39) v5(168.12,0.93) v5(168.31,22.82) v5(168.52,85.42) v5(168.61,23.89) v5(169.41,4.39) v5(169.39,0.93) v5(169.64,85.42) v5(170.07,10.41) v5(170.61,4.39) v5(170.66,0.93) v5(171.06,85.42) v5(171.3,80.31) v5(171.83,4.39) v5(171.93,0.93) v5(172.02,84.63) v5(171.98,79.11) v5(171.98,77.78) v5(172.07,83.91) v5(172.07,81.39) v5(172.07,80.58) v5(172.07,79.77) v5(172.18,76.68) v5(172.18,75.41) v5(172.85,80.78) v5(172.88,77.76) v5(173.2,0.93) v5(173.26,81.25) v5(173.39,74.52) v5(173.56,76.68) v5(173.74,80.66) v5(173.77,75.47) v5(174.53,81.25) v5(174.47,76.3) v5(174.47,0.93) v5(174.67,77.89) v5(174.66,74.52) v5(175.04,75.47) v5(175.29,80.63) v5(175.55,77.23) v5(175.74,0.93) v5(175.8,81.25) v5(176.37,76.3) v5(177.01,0.93) v5(177.07,81.25) v5(177.55,80.58) v5(177.64,77.48) v5(177.9,72.74) v5(177.91,71.69) v5(178.02,76.3) v5(178.34,81.25) v5(178.34,79.28) v5(178.33,75.56) v5(178.28,0.93) v5(178.82,80.58) v5(179.29,76.43) v5(179.55,0.93) v5(179.61,81.25) v5(179.6,80.38) v5(179.6,79.11) v5(179.6,77.84) v5(179.6,75.56) v5(180.37,76.7) v5(180.82,0.93) v5(180.87,77.84) v5(180.87,75.56) v5(180.93,46.9) v5(180.93,25.17) v5(181.64,76.7) v5(181.73,48.3) v5(181.73,45.5) v5(181.73,26.57) v5(181.73,23.77) v5(182.14,77.84) v5(182.14,75.56) v5(182.09,0.93) v5(182.91,76.7) v5(183.35,48.3) v5(183.35,45.5) v5(183.35,26.57) v5(183.35,23.77) v5(183.37,77.84) v5(183.36,75.57) v5(183.36,0.93) v5(183.95,51.39) v5(184.15,46.9) v5(184.15,25.17) v5(184.63,0.93) v5(185.39,51.4) v5(185.9,0.93) v5(187.17,0.93) v5(188.44,0.93) v5(189.71,0.93) v5(191.03,77.84) v5(190.98,0.93) v5(192.25,0.93) v5(192.3,77.84) v5(192.97,78.17) v5(193.26,74.78) v5(193.52,77.57) v5(193.52,0.93) v5(193.67,78.17) v5(194.37,78.17) v5(194.4,75.79) v5(194.4,74.78) v5(194.79,0.93) v5(194.95,78.17) v5(195.5,75.79) v5(195.5,74.78) v5(195.92,35.29) v5(196.06,0.93) v5(196.16,76.33) v5(196.34,78.5) v5(197.25,76.71) v5(197.33,0.93) v5(197.73,78.5) v5(198.47,76.71) v5(198.6,0.93) v5(198.99,71.85) v5(199.13,78.5) v5(199.63,73.1) v5(199.69,76.71) v5(199.77,70.5) v5(199.87,0.93) v5(200.69,36.1) v5(200.69,35.28) v5(200.76,42.47) v5(200.76,40.87) v5(201.14,0.93) v5(201.33,73.2) v5(201.33,70.5) v5(202.08,78.5) v5(202.08,77.28) v5(202.08,76.06) v5(202.11,71.85) v5(202.41,0.93) v5(203.35,78.5) v5(203.35,77.28) v5(203.35,76.06) v5(203.35,74.84) v5(203.68,0.93) v5(204.62,78.5) v5(204.62,77.28) v5(204.62,76.06) v5(204.62,74.84) v5(204.95,0.93) v5(205.89,78.5) v5(205.89,77.28) v5(205.89,76.06) v5(205.89,74.84) v5(206.12,15.91) v5(206.22,0.93) v5(207.36,16.54) v5(207.49,0.93) v5(208.16,16.34) v5(208.76,0.93) v5(209.71,42.39) v5(209.85,9.9) v5(209.85,6.75) v5(210.03,0.93) v5(210.92,42.7) v5(211.32,23.19) v5(211.3,0.93) v5(211.43,77.84) v5(211.43,76.32) v5(211.43,74.79) v5(211.42,8.33) v5(211.55,42.7) v5(211.55,42.06) v5(211.6,22.68) v5(211.88,23.2) v5(212.62,77.84) v5(212.62,76.32) v5(212.62,74.79) v5(212.57,0.93) v5(213,9.9) v5(213,6.75) v5(213.84,0.93) v5(213.89,77.84) v5(213.89,76.32) v5(213.89,74.79) v5(215.11,0.93) v5(215.16,77.84) v5(215.16,76.32) v5(215.16,74.79) v5(215.52,59.13) v5(216.38,0.93) v5(217.65,0.93) v5(218.83,0.48) v5(220.1,0.43) v5(221.51,77.84) v5(221.51,76.32) v5(221.51,74.79) v5(222.64,0.43) v5(222.78,77.84) v5(222.78,76.32) v5(222.78,74.79) v5(223.56,76.99) v5(223.56,75.72) v5(223.56,74.45) v5(223.56,73.18) v5(223.56,71.91) v5(223.56,70.64) v5(223.56,69.37) v5(223.56,68.1) v5(223.56,66.83) v5(223.56,65.56) v5(223.56,64.29) v5(223.56,63.02) v5(223.56,61.75) v5(223.56,60.48) v5(223.56,59.21) v5(223.56,57.94) v5(223.56,56.67) v5(223.56,55.4) v5(223.56,54.13) v5(223.56,52.86) v5(223.56,51.59) v5(223.56,50.32) v5(223.56,49.05) v5(223.56,47.78) v5(223.56,46.51) v5(223.56,45.24) v5(223.56,43.97) v5(223.56,42.7) v5(223.61,41.44) v5(223.72,40.17) v5(223.9,38.91) v5(224.16,37.67) v5(224.28,32.77) v5(224.47,36.44) v5(224.69,33.97) v5(224.77,31.59) v5(224.85,35.23) v5(225.18,0.43) v5(225.37,30.47) v5(226.02,29.39) v5(226.45,0.52) v5(226.73,28.33) v5(227.5,27.32) v5(228.31,26.34) v5(229.17,25.41) v5(230.08,24.52) v5(231.05,23.71) v5(232.32,23.57) v5(233.58,23.45) v5(234.7,22.85) v5(235.79,22.21) v5(236.92,21.62) v5(238.08,21.1) v5(264.39,57.75) v5(264.45,57.15) v5(264.47,58.42) v5(264.84,26.99) v5(265.19,59.15) v5(265.19,56.35) v5(265.67,27.95) v5(266.2,60.28) v5(266.15,55.27) v5(266.36,28.83) v5(266.81,59.15) v5(266.81,56.35) v5(267.11,61.16) v5(267.06,54.38) v5(267.06,29.27) v5(267.61,57.75) v5(267.86,30.66) v5(267.86,27.87) v5(268.02,62.05) v5(267.97,53.49) v5(268.44,32.2) v5(268.92,62.94) v5(268.88,52.61) v5(268.99,33.35) v5(269.47,34.52) v5(269.48,30.66) v5(269.48,27.87) v5(269.83,63.83) v5(269.78,51.72) v5(269.89,35.72) v5(270.25,36.94) v5(270.28,29.27) v5(270.53,38.18) v5(270.65,50.79) v5(270.68,64.77) v5(270.76,39.43) v5(270.91,40.69) v5(271.02,71.08) v5(271.02,69.81) v5(271.02,68.54) v5(271.02,67.27) v5(271.02,66) v5(271.02,49.57) v5(271.02,48.3) v5(271.02,47.03) v5(271.02,45.76) v5(271.02,44.49) v5(271.02,43.22) v5(271,41.95) v5(271.22,61.13) v5(271.22,59.42) v5(271.28,72.32) v5(272.54,72.42) v5(273.21,11.34) v5(273.37,0.93) v5(273.59,66.21) v5(273.81,72.42) v5(274.23,68.88) v5(274.29,26.99) v5(274.54,25.44) v5(274.64,0.93) v5(274.73,27.38) v5(274.81,66.21) v5(275.08,72.42) v5(275.91,0.93) v5(276.35,72.55) v5(277.08,31.6) v5(277.16,60.84) v5(277.22,45.83) v5(277.18,0.93) v5(277.4,73.26) v5(278.15,31.68) v5(278.3,74.16) v5(278.33,61.32) v5(278.45,0.93) v5(278.94,45.82) v5(279.19,75.06) v5(279.53,60.98) v5(279.72,0.93) v5(279.95,76.08) v5(280.13,78.61) v5(280.13,77.34) v5(280.21,45.82) v5(280.36,73.29) v5(280.53,79.81) v5(280.7,31.67) v5(280.8,60.98) v5(280.99,0.93) v5(281.28,80.83) v5(281.42,82.1) v5(281.48,45.82) v5(282.07,60.98) v5(282.23,68.74) v5(282.17,31.92) v5(282.26,0.93) v5(282.48,68.24) v5(282.66,82.37) v5(282.74,35.69) v5(282.75,45.82) v5(283.19,35.18) v5(283.34,60.98) v5(283.3,30.62) v5(283.35,29.24) v5(283.53,0.93) v5(283.76,35.15) v5(284.02,45.82) v5(284.2,82.33) v5(284.34,76.82) v5(284.32,2.42) v5(284.39,70.81) v5(284.61,60.98) v5(284.8,0.93) v5(284.91,2.42) v5(285.02,65.12) v5(285.02,64.49) v5(285.21,83.22) v5(285.29,45.82) v5(285.49,2.42) v5(285.59,84.62) v5(285.66,63.6) v5(285.66,62.97) v5(285.88,60.98) v5(286.1,2.42) v5(286.07,0.93) v5(286.34,83.35) v5(286.25,64.31) v5(286.84,64.29) v5(287.12,84.7) v5(287.12,82) v5(287.34,0.93) v5(287.46,64.27) v5(288.26,64.81) v5(288.45,44.42) v5(288.61,0.93) v5(288.68,82) v5(288.82,45.72) v5(288.97,84.66) v5(289.41,23.57) v5(289.46,83.35) v5(290.01,13.76) v5(289.97,12.49) v5(289.97,11.22) v5(290.04,9.95) v5(290.13,84.14) v5(290.77,66.09) v5(290.77,64.82) v5(290.77,63.55) v5(290.79,62.7) v5(290.84,14.72) v5(290.93,9.05) v5(291.11,83.33) v5(291.3,67.24) v5(291.47,62.49) v5(291.83,82.29) v5(292.1,14.83) v5(292.2,8.97) v5(292.26,81.09) v5(292.37,79.82) v5(292.37,67.93) v5(292.37,43.41) v5(292.37,42.75) v5(292.37,41.48) v5(292.37,40.21) v5(292.37,38.94) v5(292.37,37.67) v5(292.37,36.4) v5(292.37,35.13) v5(292.37,33.86) v5(292.37,32.59) v5(292.37,31.32) v5(292.37,30.05) v5(292.37,28.78) v5(292.37,27.51) v5(292.37,26.24) v5(292.37,24.97) v5(292.37,23.7) v5(292.37,22.43) v5(292.37,21.16) v5(292.37,19.89) v5(292.37,18.62) v5(292.37,17.35) v5(292.37,16.08) v5(292.37,7.9) v5(292.37,6.44) v5(292.37,5.17) v5(292.7,62.16) v5(292.77,43.95) v6(2.76,8.74) v6(4.16,8.99) v6(8.55,13.52) v6(9.85,50.43) v6(13.75,47.98) v6(15.53,42.71) v6(16.8,63.79) v6(16.86,30.2) v6(18,58.9) v6(20.92,55.22) v6(76.11,51.47) v6(85.95,26.26) v6(90.8,27.6) v6(96.36,40.61) v6(104.93,39.79) v6(122.97,20.93) v6(127.1,2.51) v6(137.57,13.56) v6(168.56,78.4) v6(188.44,69.25) v6(194.79,13.69) v6(205.96,19.09) v6(226.66,19.39) v6(260.5,15.73) v6(262.67,22.64) v6(265.46,2.09) v6(271.3,53.88) v6(274.37,48.73) v6(276.37,54.34) v6(276.7,63.16) v6(279.81,24.99) v6(281.08,76.55) v6(289.59,8.86) v6(289.78,64.3) v6(289.85,16.36) v8(0.4,3.11) v8(0.92,4.37) v8(0.92,1.85) v8(2.18,4.89) v8(2.18,1.33) v8(3.44,4.37) v8(3.44,1.85) v8(3.96,13.44) v8(3.96,3.11) v8(4.29,13.44) v8(5.23,13.87) v8(5.93,48.46) v8(5.93,46.12) v8(5.93,44.96) v8(5.96,44.33) v8(6.22,16.48) v8(7.18,16.5) v8(7.4,53.25) v8(7.4,52.87) v8(7.61,54.33) v8(7.65,20.06) v8(8.4,40.94) v8(8.56,16.77) v8(8.93,22.62) v8(9.01,5.6) v8(10.12,16.35) v8(10.47,50.56) v8(11.14,11.95) v8(11.1,7.86) v8(11.44,11.95) v8(11.41,7.86) v8(11.57,50.56) v8(11.72,11.95) v8(11.69,7.86) v8(11.91,50.91) v8(12.03,56.74) v8(12.14,64.3) v8(12.29,66.14) v8(12.38,11.95) v8(12.71,50.56) v8(12.73,30.83) v8(12.68,11.95) v8(12.8,65.85) v8(12.8,64.47) v8(12.96,11.95) v8(13.12,56.74) v8(13.1,53.7) v8(13.13,23.03) v8(13.13,13.24) v8(13.16,54.82) v8(13.62,12.1) v8(13.62,11.82) v8(13.6,7.87) v8(13.88,20.2) v8(13.94,12.1) v8(13.91,7.87) v8(14.03,22.14) v8(14.22,65.69) v8(14.22,64.73) v8(14.18,7.87) v8(14.92,21.24) v8(15.07,23.18) v8(15.15,2.13) v8(15.53,2.13) v8(15.65,43.75) v8(15.81,20.35) v8(15.96,22.28) v8(15.97,2.13) v8(16.23,43.75) v8(16.35,2.13) v8(16.71,19.46) v8(16.85,21.39) v8(17.32,27.5) v8(17.31,24.79) v8(18.51,44.8) v8(18.51,44.42) v8(18.88,25.8) v8(19.13,24.49) v8(20.11,0.83) v8(20.66,53.83) v8(21.36,23.2) v8(21.38,0.83) v8(22.32,3.87) v8(22.59,8.76) v8(22.73,8.09) v8(22.65,0.83) v8(23.09,8.76) v8(23.12,8.09) v8(23.17,7.71) v8(23.49,8.08) v8(23.59,8.76) v8(23.81,7.71) v8(23.86,8.09) v8(23.92,0.83) v8(24.09,8.76) v8(24.24,8.08) v8(24.57,7.71) v8(25.2,7.71) v8(25.19,0.83) v8(25.64,7.85) v8(26.03,7.85) v8(26.09,8.49) v8(26.19,5.23) v8(26.4,8.49) v8(26.41,7.85) v8(26.46,0.83) v8(26.67,8.49) v8(26.77,7.85) v8(27.15,7.84) v8(27.08,5.23) v8(27.37,8.47) v8(27.5,7.86) v8(27.67,8.47) v8(27.73,0.83) v8(27.88,7.85) v8(27.97,18.2) v8(27.95,8.47) v8(29,0.83) v8(29.73,11.34) v8(29.73,10.77) v8(29.94,18.2) v8(29.94,16.23) v8(29.94,14.26) v8(30.27,0.83) v8(31.25,11.66) v8(31.25,11.09) v8(31.42,4.55) v8(31.42,4.1) v8(31.42,3.66) v8(31.42,3.21) v8(31.42,2.77) v8(31.54,0.83) v8(31.91,18.2) v8(31.91,16.23) v8(31.91,14.26) v8(31.99,4.55) v8(31.99,4.1) v8(31.99,3.66) v8(31.99,3.21) v8(31.99,2.77) v8(36.18,15.72) v8(36.55,11.02) v8(37.39,7.59) v8(37.39,4.67) v8(37.39,4.03) v8(37.5,15.77) v8(38.03,7.59) v8(38.03,6.83) v8(38.03,6.06) v8(38.03,5.3) v8(38.03,4.67) v8(38.03,4.03) v8(38.66,7.59) v8(38.66,6.83) v8(38.66,6.06) v8(38.66,5.3) v8(38.66,4.67) v8(38.66,4.03) v8(39.3,7.59) v8(39.3,6.83) v8(39.3,6.06) v8(39.3,5.3) v8(39.3,4.67) v8(39.3,4.03) v8(39.93,7.59) v8(39.93,6.83) v8(39.93,6.06) v8(39.93,5.3) v8(39.93,4.67) v8(39.93,4.03) v8(40.57,7.59) v8(40.57,6.83) v8(40.57,6.06) v8(40.57,5.3) v8(40.57,4.67) v8(40.57,4.03) v8(41.32,16.67) v8(43.51,17.17) v8(44.61,16.42) v8(44.89,18.07) v8(47.89,18.2) v8(53.44,2.64) v8(53.75,6.77) v8(53.86,0.83) v8(54.71,2.64) v8(55.13,0.83) v8(55.98,2.64) v8(56.31,19.35) v8(56.4,0.83) v8(57.25,2.64) v8(57.67,0.83) v8(58.52,2.64) v8(58.94,0.83) v8(59.79,2.64) v8(60.21,0.83) v8(60.36,19) v8(60.68,6.77) v8(60.87,20.33) v8(60.93,19) v8(61.06,17.51) v8(61.06,15.97) v8(61.06,2.64) v8(61.48,0.83) v8(62.21,4.11) v8(62.25,14.51) v8(62.33,2.64) v8(62.75,0.83) v8(64.02,0.83) v8(64.95,2.64) v8(65.29,0.83) v8(67.1,14.75) v8(67.85,15.85) v8(68.17,18.93) v8(73.01,77.9) v8(73.01,77.47) v8(73.01,77.09) v8(73,76.74) v8(73.16,78.46) v8(73.64,77.9) v8(73.64,77.47) v8(73.64,77.09) v8(73.64,76.74) v8(73.74,78.46) v8(73.73,70.1) v8(73.73,69.7) v8(73.73,68.9) v8(73.73,68.49) v8(73.73,67.66) v8(73.73,67.26) v8(73.76,66.46) v8(73.76,66.05) v8(74.14,57.82) v8(74.14,57.44) v8(74.14,56.55) v8(74.14,56.17) v8(74.14,55.35) v8(74.14,54.96) v8(74.28,77.9) v8(74.28,77.47) v8(74.28,77.09) v8(74.27,76.74) v8(74.39,28.83) v8(74.39,28.55) v8(74.45,78.46) v8(74.58,43.3) v8(74.67,32.1) v8(74.67,31.8) v8(74.7,31.34) v8(74.7,31.04) v8(74.7,30.63) v8(74.7,30.33) v8(74.7,29.82) v8(74.7,29.51) v8(74.8,77.9) v8(74.8,77.47) v8(74.8,77.09) v8(74.98,78.46) v8(75.14,71.16) v8(75.08,32.1) v8(75.08,31.8) v8(75.1,31.34) v8(75.1,31.04) v8(75.1,30.63) v8(75.1,30.33) v8(75.1,29.82) v8(75.1,29.51) v8(75.15,28.7) v8(75.33,77.93) v8(75.33,77.49) v8(75.47,78.46) v8(75.51,32.13) v8(75.51,31.82) v8(75.51,31.34) v8(75.51,31.04) v8(75.51,30.61) v8(75.51,30.3) v8(75.51,29.82) v8(75.51,29.51) v8(75.61,77.33) v8(75.64,46.76) v8(75.61,45.54) v8(75.61,44.27) v8(75.56,28.7) v8(75.91,46.18) v8(75.91,44.91) v8(75.91,43.64) v8(75.92,32.13) v8(75.92,31.82) v8(75.92,31.34) v8(75.92,31.04) v8(75.92,30.61) v8(75.92,30.3) v8(75.92,29.82) v8(75.92,29.51) v8(75.99,78.46) v8(75.97,77.93) v8(76.04,46.76) v8(76.04,45.54) v8(76.02,44.27) v8(76.3,32.13) v8(76.3,31.82) v8(76.27,31.34) v8(76.27,31.04) v8(76.32,30.61) v8(76.32,30.3) v8(76.35,29.82) v8(76.35,29.51) v8(76.35,28.7) v8(76.58,78.46) v8(76.6,77.93) v8(76.7,32.13) v8(76.7,31.82) v8(76.68,31.34) v8(76.68,31.04) v8(76.73,30.61) v8(76.73,30.3) v8(76.75,29.82) v8(76.75,29.51) v8(76.75,28.7) v8(77.13,32.13) v8(77.13,31.82) v8(77.06,31.37) v8(77.06,31.06) v8(77.13,30.61) v8(77.13,30.3) v8(77.19,29.82) v8(77.19,29.51) v8(77.54,32.13) v8(77.54,31.82) v8(77.46,31.37) v8(77.46,31.06) v8(77.54,30.61) v8(77.54,30.3) v8(77.54,28.7) v8(77.59,29.82) v8(77.59,29.51) v8(77.87,31.37) v8(77.87,31.06) v8(77.9,30.61) v8(77.9,30.3) v8(77.95,28.7) v8(77.97,32.13) v8(77.97,31.82) v8(77.97,29.82) v8(77.97,29.51) v8(78.28,31.37) v8(78.28,31.06) v8(78.3,30.61) v8(78.3,30.3) v8(78.38,32.13) v8(78.38,31.82) v8(78.38,29.82) v8(78.38,29.51) v8(78.73,59.49) v8(78.66,57.81) v8(78.66,57.4) v8(78.66,56.56) v8(78.66,56.16) v8(78.66,55.37) v8(78.66,54.96) v8(78.68,31.34) v8(78.68,31.04) v8(78.73,30.63) v8(78.73,30.33) v8(78.73,28.7) v8(78.76,32.13) v8(78.76,31.82) v8(78.84,29.82) v8(78.84,29.51) v8(79.04,5.17) v8(79.09,31.34) v8(79.09,31.04) v8(79.14,30.63) v8(79.14,30.33) v8(79.14,28.7) v8(79.17,32.13) v8(79.17,31.82) v8(79.24,29.82) v8(79.24,29.51) v8(79.34,56.54) v8(79.34,56.16) v8(79.37,58.01) v8(79.37,57.68) v8(79.37,57.28) v8(79.37,56.89) v8(79.45,5.17) v8(79.55,31.39) v8(79.55,31.09) v8(79.62,33.04) v8(79.62,32.74) v8(79.6,32.18) v8(79.6,31.88) v8(79.73,34.57) v8(79.73,34.26) v8(79.67,33.86) v8(79.67,33.55) v8(79.83,40.28) v8(79.83,39.98) v8(79.83,39.55) v8(79.83,39.24) v8(79.83,35.3) v8(79.83,35) v8(79.85,40.82) v8(79.85,38.84) v8(79.85,38.53) v8(79.85,38.15) v8(79.85,37.84) v8(79.85,37.41) v8(79.85,37.11) v8(79.85,36.7) v8(79.85,36.4) v8(79.85,35.99) v8(79.85,35.69) v8(80.02,57.93) v8(80.02,57.43) v8(80.02,56.93) v8(80.02,56.43) v8(80.03,33.04) v8(80.03,32.74) v8(80,32.18) v8(80,31.88) v8(79.95,31.39) v8(79.95,31.09) v8(80.13,34.57) v8(80.13,34.26) v8(80.08,33.86) v8(80.08,33.55) v8(80.23,40.28) v8(80.23,39.98) v8(80.23,39.55) v8(80.23,39.24) v8(80.23,35.3) v8(80.23,35) v8(80.33,61.7) v8(80.33,61.29) v8(80.33,60.48) v8(80.33,60.07) v8(80.26,40.82) v8(80.26,38.84) v8(80.26,38.53) v8(80.26,38.15) v8(80.26,37.84) v8(80.26,37.41) v8(80.26,37.11) v8(80.26,36.7) v8(80.26,36.4) v8(80.26,35.99) v8(80.26,35.69) v8(80.46,34.57) v8(80.46,34.26) v8(80.51,33.88) v8(80.51,33.58) v8(80.51,33.04) v8(80.51,32.74) v8(80.54,32.21) v8(80.54,31.9) v8(80.49,31.42) v8(80.49,31.11) v8(80.64,40.28) v8(80.64,39.98) v8(80.64,39.57) v8(80.64,39.27) v8(80.64,38.86) v8(80.64,38.56) v8(80.61,35.3) v8(80.61,35) v8(80.74,58.11) v8(80.72,57.78) v8(80.72,57.45) v8(80.72,57.07) v8(80.72,56.69) v8(80.69,40.84) v8(80.66,38.17) v8(80.66,37.87) v8(80.66,37.44) v8(80.66,37.13) v8(80.72,36.73) v8(80.72,36.42) v8(80.66,36.02) v8(80.66,35.71) v8(80.86,62.57) v8(80.89,61.7) v8(80.89,61.29) v8(80.92,60.45) v8(80.92,60.04) v8(80.87,34.57) v8(80.87,34.26) v8(80.92,33.88) v8(80.92,33.58) v8(80.92,33.04) v8(80.92,32.74) v8(80.94,32.21) v8(80.94,31.9) v8(80.89,31.42) v8(80.89,31.11) v8(81.05,40.28) v8(81.05,39.98) v8(81.05,39.57) v8(81.05,39.27) v8(81.05,38.86) v8(81.05,38.56) v8(81.02,35.3) v8(81.02,35) v8(81.07,59.05) v8(81.07,58.03) v8(81.07,57.43) v8(81.07,57.02) v8(81.1,40.84) v8(81.07,38.17) v8(81.07,37.87) v8(81.07,37.44) v8(81.07,37.13) v8(81.12,36.73) v8(81.12,36.42) v8(81.07,36.02) v8(81.07,35.71) v8(81.24,18.38) v8(81.24,17.27) v8(81.24,16.15) v8(81.25,69.45) v8(81.35,70.38) v8(81.35,70.1) v8(81.43,35.28) v8(81.43,34.97) v8(81.4,34.59) v8(81.4,34.29) v8(81.35,33.83) v8(81.35,33.53) v8(81.4,33.09) v8(81.4,32.79) v8(81.38,32.18) v8(81.38,31.88) v8(81.38,31.42) v8(81.38,31.11) v8(81.53,40.84) v8(81.53,40.31) v8(81.53,40) v8(81.5,39.57) v8(81.5,39.27) v8(81.5,38.91) v8(81.5,38.61) v8(81.48,38.17) v8(81.48,37.87) v8(81.5,37.44) v8(81.5,37.13) v8(81.53,36.75) v8(81.53,36.45) v8(81.48,36.02) v8(81.48,35.71) v8(81.76,70.38) v8(81.78,70.13) v8(81.75,69.45) v8(81.83,35.28) v8(81.83,34.97) v8(81.81,34.59) v8(81.81,34.29) v8(81.76,33.83) v8(81.76,33.53) v8(81.81,33.09) v8(81.81,32.79) v8(81.78,32.18) v8(81.78,31.88) v8(81.78,31.42) v8(81.78,31.11) v8(81.93,40.84) v8(81.93,40.31) v8(81.93,40) v8(81.91,39.57) v8(81.91,39.27) v8(81.91,38.91) v8(81.91,38.61) v8(81.88,38.17) v8(81.88,37.87) v8(81.91,37.44) v8(81.91,37.13) v8(81.93,36.75) v8(81.93,36.45) v8(81.88,36.02) v8(81.88,35.71) v8(82.15,78.48) v8(82.15,77.89) v8(82.24,70.38) v8(82.19,70.13) v8(82.25,69.45) v8(82.39,40.84) v8(82.42,40.31) v8(82.42,40) v8(82.39,39.55) v8(82.39,39.24) v8(82.42,38.89) v8(82.42,38.58) v8(82.36,18.38) v8(82.36,17.27) v8(82.36,16.15) v8(82.65,70.38) v8(82.73,78.48) v8(82.73,77.89) v8(82.72,70.08) v8(82.72,69.7) v8(82.72,69.32) v8(82.8,41.15) v8(82.8,40.84) v8(82.82,40.31) v8(82.82,40) v8(82.8,39.55) v8(82.8,39.24) v8(82.82,38.89) v8(82.82,38.58) v8(83.05,70.36) v8(83.13,70.08) v8(83.13,69.7) v8(83.13,69.32) v8(83.28,40.31) v8(83.28,40) v8(83.26,39.6) v8(83.26,39.29) v8(83.26,38.91) v8(83.26,38.61) v8(83.45,78.48) v8(83.45,77.89) v8(83.46,70.36) v8(83.54,47.09) v8(83.54,46.79) v8(83.54,41.12) v8(83.54,40.82) v8(83.48,18.38) v8(83.48,17.27) v8(83.48,16.15) v8(83.67,60.16) v8(83.69,40.31) v8(83.69,40) v8(83.66,39.6) v8(83.66,39.29) v8(83.66,38.91) v8(83.66,38.61) v8(83.84,69.87) v8(83.84,69.29) v8(83.87,66.59) v8(83.94,47.09) v8(83.94,46.79) v8(83.94,41.12) v8(83.94,40.82) v8(83.97,78.48) v8(83.97,77.89) v8(84.12,40.31) v8(84.12,40) v8(84.09,39.6) v8(84.09,39.29) v8(84.09,38.91) v8(84.09,38.61) v8(84.25,69.87) v8(84.25,69.29) v8(84.34,64.93) v8(84.31,22.96) v8(84.46,78.48) v8(84.46,77.89) v8(84.53,40.31) v8(84.53,40) v8(84.5,39.6) v8(84.5,39.29) v8(84.5,38.91) v8(84.5,38.61) v8(84.66,65.7) v8(84.79,66.6) v8(84.75,41.12) v8(84.75,40.82) v8(84.91,47.12) v8(84.91,46.81) v8(84.93,40.31) v8(84.93,40) v8(84.91,39.6) v8(84.91,39.29) v8(84.91,38.91) v8(84.91,38.61) v8(84.98,78.48) v8(84.98,77.89) v8(85.03,69.29) v8(85.06,69.87) v8(85.16,41.12) v8(85.16,40.82) v8(85.25,22.99) v8(85.31,47.12) v8(85.31,46.81) v8(85.34,40.31) v8(85.34,40) v8(85.31,39.6) v8(85.31,39.29) v8(85.31,38.91) v8(85.31,38.61) v8(85.44,69.29) v8(85.47,69.87) v8(85.48,59.66) v8(85.57,78.48) v8(85.57,77.89) v8(85.74,48.49) v8(85.74,48.08) v8(85.74,39.6) v8(85.74,39.29) v8(85.74,38.91) v8(85.74,38.61) v8(85.77,40.31) v8(85.77,40) v8(86.02,41.15) v8(86.02,40.84) v8(86,27.25) v8(86,25.98) v8(86.18,40.31) v8(86.18,40) v8(86.15,39.6) v8(86.15,39.29) v8(86.15,38.91) v8(86.15,38.61) v8(86.25,47.17) v8(86.25,46.86) v8(86.26,27.86) v8(86.26,26.59) v8(86.26,25.32) v8(86.43,41.15) v8(86.43,40.84) v8(86.43,27.28) v8(86.48,25.98) v8(86.66,47.17) v8(86.66,46.86) v8(87.14,53.85) v8(87.14,53.39) v8(87.14,52.96) v8(87.14,52.5) v8(87.14,52.02) v8(87.19,50.65) v8(87.19,50.19) v8(87.17,49.73) v8(87.17,49.33) v8(87.19,48.89) v8(87.32,65.42) v8(87.55,53.85) v8(87.55,53.39) v8(87.55,52.96) v8(87.55,52.5) v8(87.55,52.02) v8(87.6,50.65) v8(87.6,50.19) v8(87.57,49.73) v8(87.57,49.33) v8(87.6,48.89) v8(87.63,47.74) v8(87.57,46.85) v8(87.74,18.6) v8(88.81,21.14) v8(89.22,64.12) v8(91.03,65.67) v8(93.09,46.56) v8(93.75,6.83) v8(93.9,47.04) v8(93.9,46.19) v8(93.9,45.3) v8(94.89,39.39) v8(94.89,38.73) v8(94.97,29.89) v8(94.97,29.23) v8(95.3,39.39) v8(95.3,38.73) v8(95.39,50.71) v8(95.37,29.89) v8(95.37,29.23) v8(95.73,39.39) v8(95.73,38.73) v8(95.8,29.89) v8(95.8,29.23) v8(95.99,7) v8(96.14,62.82) v8(96.14,62.26) v8(96.14,61.7) v8(96.14,59.92) v8(96.12,59.33) v8(96.14,58.82) v8(96.13,39.39) v8(96.13,38.73) v8(96.21,29.89) v8(96.21,29.23) v8(96.42,63.17) v8(96.47,58.45) v8(96.54,56.88) v8(96.53,56.5) v8(96.54,56.13) v8(96.54,39.39) v8(96.54,38.73) v8(96.61,67.25) v8(96.61,66.87) v8(96.61,66.5) v8(96.61,65.5) v8(96.61,65.12) v8(96.61,64.75) v8(96.6,63.83) v8(96.6,57.8) v8(96.57,55.22) v8(96.57,54.84) v8(96.57,54.47) v8(96.62,29.89) v8(96.62,29.23) v8(96.69,62.82) v8(96.69,62.26) v8(96.69,61.72) v8(96.69,59.92) v8(96.67,59.33) v8(96.69,58.82) v8(96.92,39.39) v8(96.92,38.73) v8(96.97,63.17) v8(97.02,58.45) v8(97,29.89) v8(97,29.23) v8(97.15,65.54) v8(97.14,65.16) v8(97.15,64.79) v8(97.15,56.86) v8(97.14,56.48) v8(97.15,56.12) v8(97.14,55.25) v8(97.14,54.87) v8(97.14,54.5) v8(97.09,6.25) v8(97.18,67.26) v8(97.17,66.88) v8(97.18,66.51) v8(97.24,62.82) v8(97.24,62.26) v8(97.24,61.7) v8(97.24,59.92) v8(97.22,59.33) v8(97.24,58.82) v8(97.25,57.6) v8(97.22,51.21) v8(97.27,64) v8(97.26,63.62) v8(97.26,57.98) v8(97.55,65.54) v8(97.54,65.15) v8(97.54,64.78) v8(97.52,63.17) v8(97.55,56.86) v8(97.54,56.48) v8(97.54,56.1) v8(97.54,55.25) v8(97.54,54.86) v8(97.54,54.49) v8(97.47,4.61) v8(97.58,67.26) v8(97.58,66.87) v8(97.58,66.5) v8(97.57,58.45) v8(97.67,64) v8(97.66,63.62) v8(97.66,57.98) v8(97.65,57.6) v8(97.91,38.4) v8(97.91,38.07) v8(97.94,29.28) v8(97.94,28.95) v8(98.04,63.17) v8(98.08,72.06) v8(98.08,58.45) v8(98.17,38.24) v8(98.19,29.12) v8(98.22,24) v8(98.22,23.6) v8(98.22,23.16) v8(98.22,22.76) v8(98.22,22.35) v8(98.22,21.97) v8(98.29,33.22) v8(98.29,32.89) v8(98.29,32.54) v8(98.29,32.13) v8(98.29,31.72) v8(98.29,31.34) v8(98.44,38.4) v8(98.42,35.03) v8(98.4,25.85) v8(98.44,24.99) v8(98.47,38.07) v8(98.47,34.18) v8(98.47,29.28) v8(98.5,28.95) v8(98.66,16.14) v8(98.88,24) v8(98.88,23.6) v8(98.88,23.16) v8(98.88,22.76) v8(98.88,22.35) v8(98.88,21.97) v8(98.95,33.22) v8(98.95,32.89) v8(98.95,32.54) v8(98.95,32.13) v8(98.95,31.72) v8(98.95,31.34) v8(99.16,38.43) v8(99.16,38.1) v8(99.18,35.05) v8(99.23,34.62) v8(99.23,34.29) v8(99.16,29.28) v8(99.16,28.95) v8(99.16,25.83) v8(99.21,25.47) v8(99.21,25.14) v8(99.41,38.26) v8(99.41,29.12) v8(99.49,35.05) v8(99.49,34.45) v8(99.49,25.83) v8(99.46,25.31) v8(99.69,38.43) v8(99.71,38.1) v8(99.71,30.22) v8(99.69,29.28) v8(99.71,28.95) v8(99.74,25.47) v8(99.79,35.05) v8(99.77,34.62) v8(99.79,34.29) v8(99.77,29.82) v8(99.79,25.83) v8(99.77,25.14) v8(99.92,77.82) v8(99.94,38.91) v8(100.1,38.4) v8(100.12,37.79) v8(100.12,30.22) v8(100.1,29.39) v8(100.17,29.82) v8(100.22,28.93) v8(100.25,28.5) v8(100.35,38.12) v8(100.4,39.06) v8(100.38,38.71) v8(100.38,37.49) v8(100.38,30.61) v8(100.53,29.69) v8(100.45,29.26) v8(100.68,39.34) v8(100.71,38.07) v8(100.71,37.67) v8(100.71,37.29) v8(100.73,32.56) v8(100.73,32.15) v8(100.73,31.01) v8(100.68,30.17) v8(100.68,28.9) v8(100.68,28.5) v8(100.68,28.12) v8(100.83,39.01) v8(100.76,31.77) v8(100.81,31.39) v8(100.78,30.61) v8(100.86,29.87) v8(100.96,55.07) v8(100.96,54.66) v8(100.96,53.82) v8(100.96,53.41) v8(100.96,52.5) v8(100.96,52.09) v8(101.06,77.82) v8(101.09,40.36) v8(101.14,30.71) v8(101.16,39.88) v8(101.24,39.01) v8(101.16,32.56) v8(101.21,32.18) v8(101.19,31.8) v8(101.16,31.22) v8(101.26,55.07) v8(101.26,54.66) v8(101.29,53.82) v8(101.29,53.41) v8(101.29,52.5) v8(101.29,52.09) v8(101.32,40.69) v8(101.34,30.2) v8(101.32,29.84) v8(101.34,28.9) v8(101.34,28.5) v8(101.34,28.11) v8(101.37,39.37) v8(101.37,38.07) v8(101.37,37.67) v8(101.37,37.29) v8(101.52,40.33) v8(101.54,30.71) v8(101.65,40.89) v8(101.57,39.88) v8(101.67,38.99) v8(101.75,30.2) v8(101.75,29.84) v8(101.77,39.37) v8(101.95,39.88) v8(101.92,30.71) v8(102.05,78.46) v8(102.05,77.85) v8(102.03,38.07) v8(102.03,37.67) v8(102.03,37.29) v8(102,28.9) v8(102,28.5) v8(102,28.11) v8(102.18,39.37) v8(102.15,30.2) v8(102.28,39.01) v8(102.33,30.71) v8(102.25,29.84) v8(102.36,39.88) v8(102.53,30.2) v8(102.57,78.46) v8(102.57,77.85) v8(102.56,39.37) v8(102.74,30.71) v8(102.71,29.84) v8(102.76,39.88) v8(102.93,71.99) v8(102.94,30.2) v8(102.97,39.37) v8(103.06,78.46) v8(103.06,77.85) v8(103.14,30.71) v8(103.12,29.84) v8(103.17,39.88) v8(103.35,30.2) v8(103.37,39.37) v8(103.58,78.46) v8(103.58,77.85) v8(103.58,39.88) v8(103.55,30.71) v8(103.55,29.84) v8(104.03,30.17) v8(104.1,78.46) v8(104.1,77.85) v8(104.06,39.34) v8(104.31,41.5) v8(104.31,41.17) v8(104.62,78.46) v8(104.62,77.85) v8(104.57,41.33) v8(104.85,41.5) v8(104.87,57.94) v8(104.87,57.53) v8(104.87,56.67) v8(104.87,56.26) v8(104.87,41.17) v8(104.95,34.9) v8(104.92,25.83) v8(105.14,78.46) v8(105.14,77.85) v8(105.18,57.94) v8(105.18,57.53) v8(105.18,56.67) v8(105.18,56.26) v8(105.23,34.67) v8(105.18,25.63) v8(105.67,78.46) v8(105.67,77.85) v8(105.86,49.59) v8(107.83,68.17) v8(107.83,67.54) v8(108.08,24.99) v8(108.08,24.64) v8(108.63,25.4) v8(108.55,25) v8(108.55,24.65) v8(109.02,25.75) v8(109.02,25.4) v8(108.99,24.99) v8(108.99,24.64) v8(109.38,26.14) v8(109.43,25.75) v8(109.43,25.4) v8(109.46,25) v8(109.46,24.65) v8(109.68,40.19) v8(109.7,39.84) v8(109.7,39.47) v8(109.7,39.11) v8(109.7,38.75) v8(109.7,38.38) v8(109.7,37.98) v8(109.7,37.62) v8(109.71,37.26) v8(109.71,36.89) v8(109.71,36.54) v8(109.71,36.17) v8(109.71,35.8) v8(109.71,35.44) v8(109.71,35.08) v8(109.72,34.72) v8(109.72,34.35) v8(109.72,34) v8(109.72,33.63) v8(109.72,33.26) v8(109.71,32.89) v8(109.71,32.52) v8(109.72,32.17) v8(109.72,31.8) v8(109.72,31.44) v8(109.72,31.08) v8(109.72,30.71) v8(109.72,30.31) v8(109.72,29.95) v8(109.74,29.59) v8(109.74,29.22) v8(109.74,28.87) v8(109.74,28.5) v8(109.74,28.13) v8(109.74,27.77) v8(109.74,27.41) v8(109.75,27.05) v8(109.75,26.68) v8(109.75,26.33) v8(109.75,25.96) v8(109.75,25.59) v8(109.75,25.23) v8(110.09,40.19) v8(110.1,39.84) v8(110.1,39.47) v8(110.1,39.11) v8(110.1,38.75) v8(110.1,38.38) v8(110.1,37.98) v8(110.1,37.62) v8(110.12,37.26) v8(110.12,36.89) v8(110.12,36.54) v8(110.12,36.17) v8(110.12,35.8) v8(110.12,35.44) v8(110.12,35.08) v8(110.13,34.72) v8(110.13,34.35) v8(110.13,34) v8(110.13,33.63) v8(110.13,33.26) v8(110.12,32.89) v8(110.12,32.52) v8(110.13,32.17) v8(110.13,31.8) v8(110.13,31.44) v8(110.13,31.08) v8(110.13,30.71) v8(110.13,30.31) v8(110.13,29.95) v8(110.14,29.59) v8(110.14,29.22) v8(110.14,28.87) v8(110.14,28.5) v8(110.14,28.13) v8(110.14,27.77) v8(110.14,27.41) v8(110.15,27.05) v8(110.15,26.68) v8(110.15,26.33) v8(110.15,25.96) v8(110.15,25.59) v8(110.15,25.23) v8(110.19,24.4) v8(110.42,67.06) v8(110.42,65.76) v8(110.42,63.16) v8(110.42,59.91) v8(110.42,58.61) v8(110.42,57.31) v8(110.55,24.4) v8(110.56,40.21) v8(110.57,39.85) v8(110.57,39.48) v8(110.57,39.13) v8(110.57,38.76) v8(110.57,38.39) v8(110.57,38) v8(110.57,37.63) v8(110.59,37.27) v8(110.59,36.9) v8(110.59,36.55) v8(110.59,36.18) v8(110.59,35.81) v8(110.59,35.46) v8(110.59,35.09) v8(110.6,34.73) v8(110.6,34.36) v8(110.6,34.01) v8(110.6,33.64) v8(110.6,33.27) v8(110.59,32.9) v8(110.59,32.54) v8(110.6,32.18) v8(110.6,31.81) v8(110.6,31.46) v8(110.6,31.09) v8(110.6,30.72) v8(110.6,30.33) v8(110.6,29.96) v8(110.61,29.6) v8(110.61,29.23) v8(110.61,28.88) v8(110.61,28.51) v8(110.61,28.14) v8(110.61,27.79) v8(110.61,27.42) v8(110.62,27.06) v8(110.62,26.69) v8(110.62,26.34) v8(110.62,25.97) v8(110.62,25.6) v8(110.62,25.25) v8(110.99,40.19) v8(111.01,39.84) v8(111.01,39.47) v8(111.01,39.11) v8(111.01,38.75) v8(111.01,38.38) v8(111.01,37.98) v8(111.01,37.62) v8(111.02,37.26) v8(111.02,36.89) v8(111.02,36.54) v8(111.02,36.17) v8(111.02,35.8) v8(111.02,35.44) v8(111.02,35.08) v8(111.03,34.72) v8(111.03,34.35) v8(111.03,34) v8(111.03,33.63) v8(111.03,33.26) v8(111.02,32.89) v8(111.02,32.52) v8(111.03,32.17) v8(111.03,31.8) v8(111.03,31.44) v8(111.03,31.08) v8(111.03,30.71) v8(111.03,30.31) v8(111.03,29.95) v8(111.04,29.59) v8(111.04,29.22) v8(111.04,28.87) v8(111.04,28.5) v8(111.04,28.13) v8(111.04,27.77) v8(111.04,27.41) v8(111.06,27.05) v8(111.06,26.68) v8(111.06,26.33) v8(111.06,25.96) v8(111.06,25.59) v8(111.06,25.23) v8(111.22,66.41) v8(111.22,62.51) v8(111.22,60.59) v8(111.21,24.88) v8(111.21,24.51) v8(111.21,24.15) v8(111.46,40.21) v8(111.48,39.85) v8(111.48,39.48) v8(111.48,39.13) v8(111.48,38.76) v8(111.48,38.39) v8(111.48,38) v8(111.48,37.63) v8(111.49,37.27) v8(111.49,36.9) v8(111.49,36.55) v8(111.49,36.18) v8(111.49,35.81) v8(111.49,35.46) v8(111.49,35.09) v8(111.5,34.73) v8(111.5,34.36) v8(111.5,34.01) v8(111.5,33.64) v8(111.5,33.27) v8(111.49,32.9) v8(111.49,32.54) v8(111.5,32.18) v8(111.5,31.81) v8(111.5,31.46) v8(111.5,31.09) v8(111.5,30.72) v8(111.5,30.33) v8(111.5,29.96) v8(111.51,29.6) v8(111.51,29.23) v8(111.51,28.88) v8(111.51,28.51) v8(111.51,28.14) v8(111.51,27.79) v8(111.51,27.42) v8(111.53,27.06) v8(111.53,26.69) v8(111.53,26.34) v8(111.53,25.97) v8(111.53,25.6) v8(111.53,25.25) v8(111.68,24.89) v8(111.68,24.52) v8(111.68,24.17) v8(112.02,68.36) v8(112.02,67.06) v8(112.02,64.46) v8(112.02,63.16) v8(112.02,58.61) v8(112.02,56.01) v8(112.02,54.71) v8(112.82,66.41) v8(112.82,62.51) v8(112.82,56.66) v8(113.62,67.06) v8(113.62,65.76) v8(113.62,64.46) v8(113.62,58.61) v8(113.62,57.31) v8(113.62,56.01) v8(113.62,54.71) v8(113.76,79.96) v8(113.77,79.28) v8(113.77,78.47) v8(113.77,78.07) v8(113.77,77.66) v8(113.77,77.25) v8(113.77,76.87) v8(114.28,78.47) v8(114.28,78.07) v8(114.28,77.66) v8(114.28,77.25) v8(114.28,76.87) v8(114.8,79.96) v8(114.81,79.28) v8(114.8,78.47) v8(114.8,78.07) v8(114.8,77.66) v8(114.8,77.25) v8(114.8,76.87) v8(115.29,78.47) v8(115.29,78.07) v8(115.29,77.66) v8(115.29,77.25) v8(115.29,76.87) v8(115.73,33.39) v8(115.84,79.96) v8(115.85,79.28) v8(115.81,78.47) v8(115.81,78.07) v8(115.81,77.66) v8(115.81,77.25) v8(115.81,76.87) v8(116.02,67.06) v8(116.02,65.76) v8(116.02,64.46) v8(116.02,58.61) v8(116.02,57.31) v8(116.02,56.01) v8(116.02,54.71) v8(116.01,33.39) v8(116.1,28.98) v8(116.1,28.32) v8(116.22,39.33) v8(116.22,38.96) v8(116.32,78.47) v8(116.32,78.07) v8(116.32,77.66) v8(116.32,77.25) v8(116.32,76.87) v8(116.29,33.39) v8(116.5,28.98) v8(116.5,28.32) v8(116.63,39.33) v8(116.63,38.96) v8(116.83,78.47) v8(116.83,78.07) v8(116.83,77.66) v8(116.83,77.25) v8(116.83,76.87) v8(116.82,66.41) v8(116.82,60.56) v8(116.88,79.96) v8(116.89,79.28) v8(116.94,28.98) v8(116.94,28.32) v8(117.06,39.33) v8(117.06,38.96) v8(117.09,33.92) v8(117.34,78.47) v8(117.34,78.07) v8(117.34,77.66) v8(117.34,77.25) v8(117.34,76.87) v8(117.34,28.98) v8(117.34,28.32) v8(117.47,39.33) v8(117.47,38.96) v8(117.62,68.36) v8(117.62,67.06) v8(117.62,64.46) v8(117.62,63.16) v8(117.62,59.91) v8(117.62,58.61) v8(117.62,54.71) v8(117.75,28.98) v8(117.75,28.32) v8(117.88,39.33) v8(117.88,38.96) v8(117.85,33.37) v8(118.13,33.37) v8(118.13,28.98) v8(118.13,28.32) v8(118.26,39.33) v8(118.26,38.96) v8(118.42,60.56) v8(118.42,56.66) v8(118.41,33.37) v8(119.22,67.06) v8(119.22,64.46) v8(119.22,63.16) v8(119.22,59.91) v8(119.2,33.92) v8(119.54,39.32) v8(119.54,38.95) v8(119.48,28.98) v8(119.48,28.32) v8(119.95,39.32) v8(119.95,38.95) v8(119.88,28.98) v8(119.88,28.32) v8(119.98,33.35) v8(120.26,33.35) v8(120.31,28.98) v8(120.31,28.32) v8(120.38,39.32) v8(120.38,38.95) v8(120.54,33.35) v8(120.72,28.98) v8(120.72,28.32) v8(120.78,39.32) v8(120.78,38.95) v8(121.13,28.98) v8(121.13,28.32) v8(121.19,39.32) v8(121.19,38.95) v8(121.33,33.91) v8(121.51,28.98) v8(121.51,28.32) v8(121.48,25.65) v8(121.57,39.32) v8(121.57,38.95) v8(121.76,25.65) v8(122.04,25.65) v8(122.1,33.36) v8(122.41,83.36) v8(122.41,82.6) v8(122.38,33.36) v8(122.45,32.42) v8(122.42,28.66) v8(122.55,78.6) v8(122.55,77.33) v8(122.47,39.33) v8(122.47,35.75) v8(122.71,66.94) v8(122.66,33.36) v8(122.73,32.42) v8(122.7,28.66) v8(122.75,39.33) v8(122.75,35.75) v8(122.85,26.19) v8(123.03,39.33) v8(123.03,35.75) v8(123.01,32.42) v8(122.98,28.66) v8(123.12,83.39) v8(123.12,82.62) v8(123.16,80.62) v8(123.16,79.86) v8(123.34,33.37) v8(123.51,84.91) v8(123.51,83.74) v8(123.56,80.75) v8(123.62,33.37) v8(123.82,78.6) v8(123.82,77.33) v8(123.79,39.44) v8(123.84,36.12) v8(123.81,32.47) v8(123.79,29.21) v8(123.9,33.37) v8(124.23,83.97) v8(124.23,83.67) v8(124.23,83.34) v8(124.23,83.01) v8(124.23,82.65) v8(124.23,82.35) v8(124.23,82.04) v8(124.38,84.28) v8(124.35,81.74) v8(124.5,85.1) v8(124.59,84.67) v8(124.56,20.57) v8(124.73,81.55) v8(125.28,67.06) v8(125.28,65.76) v8(125.28,64.46) v8(125.28,58.61) v8(125.28,56.01) v8(125.5,81.58) v8(125.46,80.41) v8(125.72,80.17) v8(125.8,81.58) v8(125.9,84.67) v8(125.93,79.87) v8(125.86,79.47) v8(125.9,79.12) v8(126.04,32.34) v8(126.08,81.58) v8(126.08,66.41) v8(126.08,60.56) v8(126.2,78.84) v8(126.33,84.45) v8(126.28,81.81) v8(126.27,80.64) v8(126.44,83.36) v8(126.44,83.06) v8(126.44,82.37) v8(126.44,82.07) v8(126.44,77.27) v8(126.54,80.37) v8(126.64,78.9) v8(126.63,27.91) v8(126.58,24.76) v8(126.69,36) v8(126.69,32.34) v8(126.68,25.4) v8(126.8,80.06) v8(126.8,79.69) v8(126.81,79.31) v8(126.88,68.36) v8(126.88,63.16) v8(126.88,58.61) v8(126.88,56.01) v8(126.88,54.71) v8(127.01,26.74) v8(127.1,84.67) v8(127.25,82.05) v8(127.34,32.34) v8(127.34,31.01) v8(127.71,78.54) v8(127.71,77.27) v8(127.68,66.41) v8(127.68,60.56) v8(127.68,56.66) v8(127.99,32.34) v8(128.04,27.91) v8(128.3,84.67) v8(128.3,81.01) v8(128.3,44.13) v8(128.43,81.98) v8(128.4,80.02) v8(128.48,67.06) v8(128.48,65.76) v8(128.48,58.61) v8(128.53,46.86) v8(128.53,45.66) v8(128.7,27.7) v8(128.98,78.54) v8(128.98,77.27) v8(129.05,26.17) v8(129.5,84.67) v8(129.5,81.01) v8(129.67,81.88) v8(129.67,80.02) v8(129.93,39.66) v8(129.93,32.34) v8(130,31.36) v8(130,30.45) v8(130,26.79) v8(130.4,31.89) v8(130.7,84.67) v8(130.7,81.01) v8(130.65,27.7) v8(130.86,81.84) v8(130.88,67.06) v8(130.88,65.76) v8(130.88,64.46) v8(130.86,39.66) v8(130.86,31.43) v8(131.06,44.91) v8(131.06,44.26) v8(131.06,43.61) v8(131.06,42.96) v8(131.4,80.99) v8(131.64,82.98) v8(131.68,66.41) v8(131.68,60.56) v8(131.66,41.39) v8(131.9,84.67) v8(132.19,83.01) v8(132.48,68.36) v8(132.48,67.06) v8(132.48,64.46) v8(132.48,59.91) v8(132.48,58.61) v8(132.48,56.01) v8(132.48,54.71) v8(132.9,79.18) v8(132.9,77.91) v8(132.89,43.61) v8(133.1,84.67) v8(133.1,81.01) v8(133.32,79.86) v8(133.28,56.67) v8(133.34,41.85) v8(133.33,25.51) v8(133.26,6.23) v8(133.26,5.67) v8(133.64,80.43) v8(133.8,43.61) v8(133.8,41.39) v8(133.82,6.23) v8(133.82,5.67) v8(134,26.17) v8(134.08,67.06) v8(134.08,65.76) v8(134.08,63.16) v8(134.08,57.31) v8(134.08,56.01) v8(134.17,79.18) v8(134.17,77.91) v8(134.3,84.67) v8(134.26,41.85) v8(134.5,25.18) v8(134.5,6.23) v8(134.5,5.67) v8(134.72,41.39) v8(134.7,23.82) v8(134.84,80.81) v8(134.9,45.66) v8(134.9,26.46) v8(134.87,25.18) v8(134.91,24.55) v8(135.04,6.23) v8(135.04,5.67) v8(135.17,41.85) v8(135.22,26.2) v8(135.44,79.18) v8(135.44,77.91) v8(135.5,84.67) v8(135.5,81.01) v8(135.53,12.37) v8(135.53,11.83) v8(135.63,42.31) v8(135.63,41.39) v8(135.59,26.45) v8(135.56,13.15) v8(135.66,44.91) v8(135.84,23.83) v8(135.94,13.15) v8(135.91,12.37) v8(135.91,11.83) v8(135.86,5.82) v8(136.12,81) v8(136.11,25.25) v8(136.15,24.93) v8(136.27,7.81) v8(136.29,7.06) v8(136.3,5.82) v8(136.55,44.91) v8(136.55,44.26) v8(136.55,43.61) v8(136.55,42.96) v8(136.55,42.31) v8(136.65,7.81) v8(136.7,84.67) v8(136.7,81.01) v8(136.75,80.24) v8(136.71,79.18) v8(136.71,77.91) v8(136.67,7.06) v8(136.75,5.82) v8(136.78,13.13) v8(136.75,12.37) v8(136.75,11.83) v8(137.13,12.37) v8(137.13,11.83) v8(137.16,13.13) v8(137.19,5.82) v8(137.41,45.66) v8(137.46,40.46) v8(137.51,8.36) v8(137.49,7.81) v8(137.51,7.03) v8(137.64,5.82) v8(137.71,81.63) v8(137.83,80.24) v8(137.9,84.67) v8(137.9,81.01) v8(137.92,41.85) v8(137.94,12.37) v8(137.89,8.36) v8(137.87,7.81) v8(137.89,7.03) v8(137.98,79.18) v8(137.98,77.91) v8(137.97,13.15) v8(137.97,11.83) v8(138.08,5.82) v8(138.33,12.37) v8(138.35,13.15) v8(138.35,11.83) v8(138.53,5.82) v8(138.66,45.66) v8(138.68,8.39) v8(138.71,7.81) v8(138.71,7.06) v8(138.83,41.85) v8(138.91,12.8) v8(138.91,12.42) v8(139,81.56) v8(138.97,5.82) v8(139.1,84.67) v8(139.1,81.01) v8(139.06,8.39) v8(139.09,7.81) v8(139.09,7.06) v8(139.22,80.17) v8(139.25,79.18) v8(139.25,77.91) v8(139.18,11.81) v8(139.29,44.91) v8(139.29,44.26) v8(139.29,43.61) v8(139.29,42.96) v8(139.29,42.31) v8(139.29,12.42) v8(139.42,5.82) v8(139.5,52) v8(139.63,56.74) v8(139.63,56.11) v8(139.75,51.76) v8(139.67,12.42) v8(139.73,11.97) v8(139.67,8.42) v8(139.67,8.04) v8(139.67,7.66) v8(139.67,7.28) v8(139.67,6.89) v8(139.67,6.51) v8(139.67,6.13) v8(139.8,11.59) v8(139.91,45.66) v8(139.92,8.8) v8(139.96,51.54) v8(140.15,80.21) v8(140.05,7.85) v8(140.05,7.47) v8(140.05,7.09) v8(140.05,6.7) v8(140.05,6.32) v8(140.24,11.59) v8(140.3,84.67) v8(140.3,81.01) v8(140.28,11.28) v8(140.28,9.28) v8(140.43,8.8) v8(140.37,7.85) v8(140.52,79.18) v8(140.52,77.91) v8(140.62,11.59) v8(140.66,41.85) v8(140.81,8.38) v8(140.94,79.86) v8(140.91,11.28) v8(140.91,9.28) v8(141.18,81) v8(141.16,45.66) v8(141.35,83.83) v8(141.52,77.93) v8(141.55,11.28) v8(141.55,9.28) v8(141.61,84.67) v8(141.58,41.85) v8(141.79,79.18) v8(141.94,83.13) v8(141.91,81) v8(142.02,76.62) v8(142.04,44.91) v8(142.04,44.26) v8(142.04,43.61) v8(142.04,42.96) v8(142.04,42.31) v8(142.21,81.57) v8(142.21,79.86) v8(142.42,67.06) v8(142.42,65.76) v8(142.42,64.46) v8(142.42,63.16) v8(142.42,59.91) v8(142.42,58.61) v8(142.42,57.31) v8(142.42,56.01) v8(142.64,81.94) v8(142.63,80.75) v8(142.69,84.91) v8(142.69,83.79) v8(143.03,76.62) v8(143.19,83.25) v8(143.19,82.48) v8(143.23,62.51) v8(143.23,60.56) v8(143.23,56.66) v8(143.49,79.41) v8(143.73,83.27) v8(143.73,82.51) v8(143.95,70.71) v8(143.87,26.88) v8(143.87,26.23) v8(143.87,25.58) v8(144.03,68.36) v8(144.03,67.06) v8(144.03,64.46) v8(144.03,59.91) v8(144.03,58.61) v8(144.03,56.01) v8(144.03,54.71) v8(144.11,76.62) v8(144.5,73.7) v8(144.6,27.24) v8(144.82,83.5) v8(144.81,82.71) v8(144.82,80.96) v8(144.83,66.41) v8(144.83,62.51) v8(144.83,60.56) v8(144.83,56.66) v8(144.78,44.91) v8(144.78,44.26) v8(144.78,43.61) v8(144.78,42.96) v8(144.78,42.31) v8(144.78,27.53) v8(144.78,25.58) v8(144.91,45.66) v8(145,25.89) v8(145.19,79.14) v8(145.63,68.36) v8(145.63,67.06) v8(145.63,65.76) v8(145.63,64.46) v8(145.63,58.61) v8(145.63,57.31) v8(145.63,56.01) v8(145.69,27.53) v8(145.77,77.79) v8(145.77,73.7) v8(145.98,70.71) v8(146.21,51.85) v8(146.21,51.28) v8(146.19,24.85) v8(146.19,24.2) v8(146.34,51.6) v8(146.61,27.53) v8(147.04,73.7) v8(147.07,41.81) v8(147.39,13.49) v8(147.53,44.26) v8(147.53,43.61) v8(147.53,42.96) v8(147.53,42.31) v8(147.52,27.53) v8(147.52,26.88) v8(147.86,13.5) v8(147.86,13.13) v8(148.03,68.36) v8(148.03,67.06) v8(148.03,65.76) v8(148.03,64.46) v8(148.03,58.61) v8(148.03,57.31) v8(148.24,13.52) v8(148.24,13.16) v8(148.24,12.8) v8(148.24,12.43) v8(148.24,12.06) v8(148.24,11.67) v8(148.24,11.3) v8(148.31,73.7) v8(148.25,10.95) v8(148.25,10.58) v8(148.25,10.22) v8(148.25,9.85) v8(148.25,9.49) v8(148.25,9.13) v8(148.25,8.76) v8(148.27,8.41) v8(148.27,8.04) v8(148.27,7.68) v8(148.27,7.31) v8(148.27,6.95) v8(148.39,70.71) v8(148.44,27.53) v8(148.71,13.54) v8(148.71,13.17) v8(148.71,12.81) v8(148.71,12.44) v8(148.71,12.08) v8(148.71,11.68) v8(148.71,11.31) v8(148.72,10.96) v8(148.72,10.59) v8(148.72,10.23) v8(148.72,9.87) v8(148.72,9.5) v8(148.72,9.14) v8(148.72,8.77) v8(148.74,8.42) v8(148.74,8.05) v8(148.74,7.69) v8(148.74,7.33) v8(148.74,6.96) v8(148.83,66.41) v8(149.16,13.55) v8(149.16,13.18) v8(149.16,12.83) v8(149.16,12.46) v8(149.16,12.09) v8(149.16,11.7) v8(149.16,11.33) v8(149.17,10.97) v8(149.17,10.6) v8(149.17,10.25) v8(149.17,9.88) v8(149.17,9.51) v8(149.17,9.16) v8(149.17,8.79) v8(149.18,8.43) v8(149.18,8.06) v8(149.18,7.71) v8(149.18,7.34) v8(149.18,6.97) v8(149.33,73.71) v8(149.36,43.61) v8(149.52,6.59) v8(149.63,68.36) v8(149.63,67.06) v8(149.63,64.46) v8(149.63,59.91) v8(149.63,58.61) v8(149.63,56.01) v8(149.63,54.71) v8(149.64,13.56) v8(149.64,13.19) v8(149.64,12.84) v8(149.64,12.47) v8(149.64,12.1) v8(149.64,11.71) v8(149.64,11.34) v8(149.65,10.98) v8(149.65,10.62) v8(149.65,10.26) v8(149.65,9.89) v8(149.65,9.52) v8(149.65,9.17) v8(149.65,8.8) v8(149.66,8.44) v8(149.66,8.08) v8(149.66,7.72) v8(149.66,7.35) v8(149.66,6.98) v8(149.82,41.86) v8(150.01,6.6) v8(150.11,13.57) v8(150.11,13.21) v8(150.11,12.85) v8(150.11,12.48) v8(150.11,12.11) v8(150.11,11.72) v8(150.11,11.35) v8(150.12,11) v8(150.12,10.63) v8(150.12,10.27) v8(150.12,9.9) v8(150.12,9.54) v8(150.12,9.18) v8(150.12,8.81) v8(150.13,8.46) v8(150.13,8.09) v8(150.13,7.73) v8(150.13,7.36) v8(150.13,7) v8(150.08,6.01) v8(150.08,5.75) v8(150.08,5.5) v8(150.26,70.71) v8(150.43,66.41) v8(150.43,62.51) v8(150.43,60.56) v8(150.43,56.66) v8(150.48,6.62) v8(150.76,6.25) v8(150.77,5.76) v8(150.78,5.29) v8(151.12,6.25) v8(151.14,5.76) v8(151.15,5.29) v8(151.23,67.06) v8(151.23,65.76) v8(151.23,64.46) v8(151.23,63.16) v8(151.23,59.91) v8(151.23,58.61) v8(151.23,57.31) v8(151.23,56.01) v8(151.19,26.23) v8(151.49,6.25) v8(151.51,5.76) v8(151.52,5.29) v8(151.85,6.25) v8(151.86,5.76) v8(151.87,5.29) v8(151.99,82.65) v8(151.99,81.51) v8(152.04,24.85) v8(152.04,24.2) v8(152.1,44.91) v8(152.22,6.25) v8(152.23,5.76) v8(152.24,5.29) v8(152.42,45.66) v8(152.45,16.61) v8(152.57,6.26) v8(152.58,5.78) v8(152.6,5.31) v8(152.94,6.26) v8(153.02,44.91) v8(153.02,44.26) v8(153.02,43.61) v8(153.02,42.96) v8(152.95,5.78) v8(152.97,5.31) v8(153.08,83.13) v8(153.08,82.37) v8(153.63,83.16) v8(153.63,82.4) v8(153.68,67.83) v8(153.92,73.82) v8(153.93,69.7) v8(153.93,69.11) v8(153.96,71.13) v8(154.12,84.91) v8(154.17,80.75) v8(154.27,80.05) v8(154.33,12.73) v8(154.36,11.77) v8(154.57,81.64) v8(154.59,71.13) v8(154.64,12.86) v8(154.66,11.9) v8(154.8,6.13) v8(154.8,5.57) v8(154.92,45.66) v8(154.94,12.86) v8(154.97,11.9) v8(155.25,80.12) v8(155.39,73.82) v8(155.36,6.13) v8(155.36,5.57) v8(155.54,83.81) v8(155.54,26.57) v8(155.68,12.98) v8(155.71,11.7) v8(155.76,44.91) v8(155.76,44.26) v8(155.76,43.61) v8(155.93,80.11) v8(156.01,67.06) v8(156.01,65.76) v8(156.01,64.46) v8(156.01,63.16) v8(156.01,58.61) v8(156.01,57.31) v8(156.01,56.01) v8(156.04,6.13) v8(156.04,5.57) v8(156.42,82.2) v8(156.42,12.89) v8(156.44,11.87) v8(156.5,73.81) v8(156.58,6.13) v8(156.58,5.57) v8(156.71,12.89) v8(156.75,11.87) v8(156.81,66.41) v8(156.9,84.67) v8(156.9,81.01) v8(156.97,82.56) v8(157.05,11.87) v8(157.22,75.5) v8(157.42,45.66) v8(157.53,82.65) v8(157.61,68.36) v8(157.61,67.06) v8(157.61,64.46) v8(157.61,63.16) v8(157.61,59.91) v8(157.61,54.71) v8(157.75,74.75) v8(157.84,73.76) v8(157.79,70.71) v8(157.77,13.03) v8(157.79,11.71) v8(157.99,6.12) v8(158.1,84.67) v8(158.1,81.01) v8(158.34,76.62) v8(158.36,75.41) v8(158.41,66.41) v8(158.41,62.51) v8(158.37,6.12) v8(158.53,12.86) v8(158.59,81.89) v8(158.56,26.52) v8(158.55,11.9) v8(158.81,63.27) v8(158.78,27.79) v8(158.83,12.86) v8(158.86,11.9) v8(159.11,77.4) v8(159.14,12.86) v8(159.21,73.76) v8(159.21,68.36) v8(159.21,67.06) v8(159.21,65.76) v8(159.21,64.46) v8(159.21,57.31) v8(159.21,56.01) v8(159.16,11.9) v8(159.3,84.67) v8(159.3,81.01) v8(159.5,24.53) v8(159.46,6.14) v8(159.58,80.26) v8(159.62,74.76) v8(159.74,27.72) v8(159.74,27.21) v8(159.74,23.83) v8(159.84,6.14) v8(159.88,80.98) v8(159.92,45.66) v8(159.88,13.01) v8(159.9,11.71) v8(160.04,76.97) v8(160.12,81.95) v8(160.08,70.71) v8(160.12,27.21) v8(160.15,27.85) v8(160.26,78.52) v8(160.29,75.47) v8(160.38,79.75) v8(160.5,84.67) v8(160.5,81.01) v8(160.47,73.75) v8(160.59,44.26) v8(160.56,24.55) v8(160.63,12.86) v8(160.71,76.45) v8(160.66,11.92) v8(160.81,23.82) v8(160.94,12.86) v8(160.96,11.92) v8(161.17,45.66) v8(161.24,12.86) v8(161.22,6.09) v8(161.22,5.53) v8(161.27,77.29) v8(161.27,11.92) v8(161.39,80.11) v8(161.45,27.85) v8(161.5,42.96) v8(161.59,76.38) v8(161.56,75.53) v8(161.61,68.36) v8(161.61,67.06) v8(161.61,65.76) v8(161.61,64.46) v8(161.61,58.61) v8(161.7,84.67) v8(161.7,81.01) v8(161.74,74.75) v8(161.73,28.16) v8(161.77,81.57) v8(161.78,6.09) v8(161.78,5.53) v8(162.01,63.16) v8(161.99,13.03) v8(161.99,11.73) v8(162.11,81.39) v8(162.11,70.71) v8(162.41,66.41) v8(162.41,62.51) v8(162.48,75.45) v8(162.47,6.09) v8(162.47,5.53) v8(162.68,27.85) v8(162.72,12.86) v8(162.74,11.9) v8(162.9,84.67) v8(162.9,81.01) v8(162.95,66.08) v8(162.95,23.09) v8(162.98,26.34) v8(163.02,12.86) v8(163.05,11.9) v8(163,6.09) v8(163,5.53) v8(163.08,81.81) v8(163.21,68.36) v8(163.21,67.06) v8(163.21,64.46) v8(163.21,63.16) v8(163.21,59.91) v8(163.21,58.61) v8(163.21,54.71) v8(163.33,42.96) v8(163.32,23.82) v8(163.33,12.86) v8(163.35,11.9) v8(163.48,81.01) v8(163.98,70.71) v8(164.01,62.51) v8(164.01,60.56) v8(164.01,56.66) v8(164.04,14.57) v8(164.1,84.67) v8(164.1,81.01) v8(164.08,11.56) v8(164.23,13.82) v8(164.23,12.33) v8(164.22,10.83) v8(164.23,6.17) v8(164.26,64.13) v8(164.54,81.75) v8(164.61,6.17) v8(164.7,81) v8(164.82,67.06) v8(164.82,65.76) v8(164.82,63.16) v8(164.82,59.91) v8(164.82,58.61) v8(164.82,57.31) v8(164.93,45.66) v8(165.16,43.61) v8(165.3,84.67) v8(165.3,81.01) v8(165.62,39.9) v8(165.61,6.14) v8(165.83,28.18) v8(166.02,81.25) v8(165.99,6.14) v8(166.08,42.31) v8(166.08,39.44) v8(166.18,45.66) v8(166.5,84.67) v8(166.47,81.57) v8(166.5,81.01) v8(167.27,6.13) v8(167.27,5.57) v8(167.41,82.66) v8(167.43,81.61) v8(167.36,79.73) v8(167.43,78.51) v8(167.44,77.28) v8(167.44,76.34) v8(167.43,75.51) v8(167.44,74.6) v8(167.43,39.72) v8(167.43,37.23) v8(167.43,36.4) v8(167.43,35.57) v8(167.43,34.74) v8(167.43,33.91) v8(167.43,33.08) v8(167.43,32.25) v8(167.43,31.42) v8(167.8,80.17) v8(167.83,6.13) v8(167.83,5.57) v8(167.86,50.68) v8(167.91,41.01) v8(168.08,39.72) v8(168.08,34.74) v8(168.37,69.88) v8(168.51,6.13) v8(168.51,5.57) v8(168.88,52.2) v8(169.05,6.13) v8(169.05,5.57) v8(169.24,80.75) v8(169.29,84.91) v8(169.27,45.98) v8(169.38,39.63) v8(169.38,38.72) v8(169.38,36.89) v8(169.38,33.23) v8(169.69,81.09) v8(169.69,79.73) v8(169.69,78.57) v8(169.7,77.34) v8(169.69,76.24) v8(169.7,75.32) v8(169.77,83.21) v8(169.77,82.45) v8(170.39,74.48) v8(170.36,68.2) v8(170.36,44.02) v8(170.44,6.1) v8(170.44,5.54) v8(170.58,73.49) v8(170.72,10.96) v8(170.72,10.65) v8(170.72,10.35) v8(171.01,44.37) v8(171.04,29.02) v8(171,6.1) v8(171,5.54) v8(171.27,72.36) v8(171.33,41.46) v8(171.33,33.23) v8(171.36,83.98) v8(171.48,83.16) v8(171.48,82.33) v8(171.48,81.25) v8(171.5,71.6) v8(171.69,6.1) v8(171.69,5.54) v8(172.19,28.99) v8(172.22,6.1) v8(172.22,5.54) v8(172.44,45.06) v8(172.84,25.48) v8(173.11,44.85) v8(173.21,45.56) v8(173.79,33.95) v8(173.95,45.68) v8(174.44,33.95) v8(174.76,24.66) v8(174.98,67.92) v8(175.36,64.83) v8(176.63,64.83) v8(176.59,58.33) v8(176.75,11.15) v8(179.97,28.17) v8(180.42,68.87) v8(180.42,63.37) v8(180.69,57.12) v8(182.17,67.37) v8(182.17,63.37) v8(182.42,57.72) v8(182.47,53.82) v8(182.65,61.31) v8(182.66,60.87) v8(182.66,60.36) v8(182.66,59.91) v8(182.66,59.34) v8(182.66,58.89) v8(182.77,57.02) v8(183.1,30.86) v8(183.19,56.54) v8(183.35,6.31) v8(183.48,6.89) v8(183.71,6.31) v8(183.8,57.5) v8(183.8,53.82) v8(183.87,6.89) v8(184.04,6.31) v8(184.1,76.88) v8(184.1,76.44) v8(184.1,76.01) v8(184.1,75.58) v8(184.1,75.15) v8(184.27,57.02) v8(184.4,6.31) v8(184.5,54.01) v8(184.61,76.88) v8(184.61,76.44) v8(184.61,76.01) v8(184.61,75.58) v8(184.61,75.15) v8(184.69,6.89) v8(184.73,6.31) v8(184.84,77.91) v8(184.82,57.5) v8(184.85,77.23) v8(185.11,76.88) v8(185.11,76.44) v8(185.11,76.01) v8(185.11,75.58) v8(185.11,75.15) v8(185.18,57.49) v8(185.35,74.76) v8(185.38,73.88) v8(185.41,54) v8(185.62,76.88) v8(185.62,76.44) v8(185.62,76.01) v8(185.62,75.58) v8(185.62,75.15) v8(185.77,57.02) v8(185.88,77.91) v8(185.89,77.23) v8(186.13,76.88) v8(186.13,76.44) v8(186.13,76.04) v8(186.13,75.58) v8(186.13,75.15) v8(186.06,57.44) v8(186.39,74.76) v8(186.43,73.88) v8(186.41,54) v8(186.41,6.89) v8(186.38,6.31) v8(186.64,76.88) v8(186.64,76.44) v8(186.64,76.01) v8(186.64,75.58) v8(186.64,75.15) v8(186.71,6.31) v8(186.92,77.91) v8(186.93,77.23) v8(186.91,57.47) v8(187.15,76.88) v8(187.15,76.44) v8(187.15,76.01) v8(187.15,75.58) v8(187.15,75.15) v8(187.06,6.31) v8(187.27,57.02) v8(187.29,54) v8(187.29,6.89) v8(187.42,10.98) v8(187.39,6.31) v8(187.56,49.58) v8(187.61,6.89) v8(187.65,76.88) v8(187.65,76.44) v8(187.65,76.01) v8(187.65,75.58) v8(187.65,75.15) v8(187.69,74.76) v8(187.75,6.31) v8(188.27,17.75) v8(189.62,48.74) v8(189.62,48.11) v8(190.24,42.42) v8(190.24,40.41) v8(190.22,38.28) v8(190.22,36.91) v8(190.22,36.21) v8(190.22,35.47) v8(190.27,43.23) v8(190.27,41.84) v8(190.27,41.04) v8(190.27,39.66) v8(190.27,39.04) v8(190.27,37.69) v8(190.27,34.9) v8(190.27,34.26) v8(190.62,32.25) v8(190.72,65.57) v8(191.37,32.25) v8(191.52,57.12) v8(191.62,70.37) v8(192.11,68.36) v8(192.12,67.85) v8(192.63,52.81) v8(192.76,74.08) v8(192.76,73.06) v8(192.76,72.24) v8(192.76,71.41) v8(192.76,70.59) v8(193.15,71.85) v8(193.33,72.68) v8(193.45,70.84) v8(193.71,74.08) v8(193.77,70.33) v8(194.1,73.5) v8(194.26,69.25) v8(194.45,67.47) v8(194.47,66.14) v8(194.66,74.08) v8(195.04,73.76) v8(195.61,74.08) v8(195.71,56.49) v8(195.71,52.17) v8(195.71,51.54) v8(196,73.5) v8(196.2,70.32) v8(196.44,67.49) v8(196.57,73) v8(196.66,9.6) v8(196.8,69.25) v8(196.78,11.77) v8(196.78,10.98) v8(196.78,10.63) v8(196.97,72.11) v8(197.01,11.54) v8(197.14,10.98) v8(197.14,10.63) v8(197.2,50.87) v8(197.16,9.6) v8(197.47,10.98) v8(197.47,10.63) v8(197.71,73) v8(197.71,72.3) v8(197.66,9.6) v8(197.66,5.32) v8(197.82,10.98) v8(197.82,10.63) v8(197.94,6.16) v8(198.07,69.25) v8(198.15,10.98) v8(198.15,10.63) v8(198.25,5.42) v8(198.51,10.98) v8(198.51,10.63) v8(199.12,11.11) v8(199.34,69.25) v8(199.27,10.3) v8(199.3,7.02) v8(199.63,10.3) v8(199.72,24.32) v8(199.72,19.69) v8(199.8,11.11) v8(200.08,24.32) v8(200.08,19.69) v8(200.16,11.11) v8(200.31,7.03) v8(200.38,51.64) v8(200.49,11.11) v8(200.51,10.32) v8(200.61,69.25) v8(200.84,11.11) v8(200.9,53.04) v8(200.87,10.32) v8(200.97,24.35) v8(200.97,19.71) v8(201.32,24.35) v8(201.88,69.25) v8(201.86,24.54) v8(201.85,24.23) v8(202.21,24.54) v8(202.21,24.23) v8(203.04,26.52) v8(203.15,73.06) v8(203.15,71.79) v8(203.15,70.52) v8(203.15,69.25) v8(203.15,67.53) v8(203.98,63.85) v8(204.02,25.04) v8(204.31,73.63) v8(205.51,69.06) v8(205.58,73.63) v8(205.79,8.39) v8(205.99,12.46) v8(206.42,8.39) v8(206.67,10.84) v8(206.67,5.84) v8(206.84,10.08) v8(206.81,6.58) v8(206.94,75.82) v8(206.94,75.13) v8(206.85,73.63) v8(207.09,78.48) v8(207.09,77.93) v8(207.09,77.52) v8(207.09,77.14) v8(207.09,76.76) v8(207.6,78.48) v8(207.6,77.93) v8(207.6,77.52) v8(207.6,77.14) v8(207.6,76.76) v8(207.8,75.82) v8(207.8,75.13) v8(208.1,78.48) v8(208.1,77.93) v8(208.1,77.52) v8(208.1,77.14) v8(208.1,76.76) v8(208.12,73.63) v8(208.61,78.48) v8(208.61,77.93) v8(208.61,77.52) v8(208.61,77.14) v8(208.61,76.76) v8(208.56,75.82) v8(208.56,75.13) v8(209.12,78.48) v8(209.12,77.93) v8(209.12,77.52) v8(209.12,77.14) v8(209.12,76.76) v8(209.37,75.82) v8(209.37,75.13) v8(209.39,73.63) v8(209.63,78.48) v8(209.63,77.93) v8(209.63,77.52) v8(209.63,77.14) v8(209.63,76.76) v8(209.67,5.78) v8(210.14,78.48) v8(210.14,77.93) v8(210.14,77.52) v8(210.14,77.14) v8(210.14,76.76) v8(210.11,75.82) v8(210.11,75.13) v8(210.14,23.94) v8(210.13,23.63) v8(210.05,23.32) v8(210.22,23.09) v8(210.55,23.94) v8(210.54,23.63) v8(210.54,23.34) v8(210.47,22.96) v8(210.64,78.48) v8(210.64,77.93) v8(210.64,77.52) v8(210.64,77.14) v8(210.64,76.76) v8(210.63,22.36) v8(210.66,73.63) v8(210.76,75.82) v8(210.84,23.32) v8(210.84,22.96) v8(210.93,75.08) v8(211.1,65.96) v8(211.13,22.36) v8(211.23,24.36) v8(211.23,24.01) v8(211.23,23.68) v8(211.64,24.36) v8(211.64,24.01) v8(211.64,23.68) v8(211.93,73.63) v8(212.11,69.03) v8(212.11,24.05) v8(212.11,23.7) v8(212.19,3.87) v8(212.39,22.83) v8(212.74,23.39) v8(212.72,22.86) v8(213.13,22.86) v8(213.2,73.63) v8(213.15,23.39) v8(213.17,5.78) v8(213.54,22.86) v8(213.73,25.62) v8(213.99,23.39) v8(213.97,22.83) v8(214.4,23.39) v8(214.37,22.83) v8(214.47,73.63) v8(214.6,37.06) v8(214.6,36.74) v8(214.61,25.26) v8(214.61,24.37) v8(214.74,38.24) v8(214.74,37.83) v8(214.99,19.21) v8(215.74,73.63) v8(216.25,6.21) v8(216.64,8.65) v8(216.99,78.48) v8(216.99,77.93) v8(216.99,77.52) v8(216.99,77.14) v8(216.99,76.76) v8(217.01,73.63) v8(217.1,28.34) v8(217.1,27.85) v8(217.1,27.33) v8(217.1,26.3) v8(217.08,25.91) v8(217.13,6.64) v8(217.2,25.37) v8(217.35,75.86) v8(217.35,75.1) v8(217.39,9.75) v8(217.5,78.48) v8(217.5,77.93) v8(217.5,77.52) v8(217.5,77.14) v8(217.5,76.76) v8(217.46,28.68) v8(217.46,28.32) v8(217.46,27.96) v8(217.46,27.61) v8(217.46,27.25) v8(217.46,26.45) v8(217.46,26.14) v8(217.46,25.78) v8(217.48,7.4) v8(217.81,24.1) v8(217.81,23.7) v8(217.86,26.41) v8(217.86,26.06) v8(217.86,25.75) v8(218,78.48) v8(218,77.93) v8(218,77.52) v8(218,77.14) v8(218,76.76) v8(218.15,28.92) v8(218.15,28.42) v8(218.15,27.92) v8(218.15,27.42) v8(218.24,26.44) v8(218.24,26.08) v8(218.24,25.75) v8(218.28,73.63) v8(218.39,75.86) v8(218.39,75.1) v8(218.41,25.37) v8(218.51,78.48) v8(218.51,77.93) v8(218.51,77.52) v8(218.51,77.14) v8(218.51,76.76) v8(218.73,26.39) v8(218.73,26.03) v8(218.83,28.95) v8(218.83,27.46) v8(218.88,38.19) v8(218.88,37.78) v8(218.88,37.03) v8(218.88,36.63) v8(218.85,28.47) v8(218.85,27.94) v8(219.02,78.48) v8(219.02,77.93) v8(219.02,77.52) v8(219.02,77.14) v8(219.02,76.76) v8(219.07,26.01) v8(219.23,27.96) v8(219.31,27.45) v8(219.43,75.86) v8(219.43,75.1) v8(219.53,78.48) v8(219.53,77.93) v8(219.53,77.52) v8(219.53,77.14) v8(219.53,76.76) v8(219.49,29.12) v8(219.51,28.6) v8(219.55,73.63) v8(219.62,27.96) v8(219.88,66.78) v8(219.88,65.89) v8(220.04,78.48) v8(220.04,77.93) v8(220.04,77.52) v8(220.04,77.14) v8(220.04,76.76) v8(220.45,75.86) v8(220.45,75.1) v8(220.54,78.48) v8(220.54,77.93) v8(220.54,77.52) v8(220.54,77.14) v8(220.54,76.76) v8(220.82,73.63) v8(220.82,8.89) v8(222.09,73.63) v8(222.79,72.67) v8(222.79,71.4) v8(222.79,70.13) v8(227.5,0.83) v8(228.77,0.83) v8(230.04,0.83) v8(230.8,7.81) v8(231.31,0.83) v8(232.58,0.83) v8(233.85,0.83) v8(235.12,0.83) v8(236.39,0.83) v8(237.66,0.83) v8(238.01,18.77) v8(238.86,20.89) v8(238.93,0.83) v8(239.16,2.95) v8(239.64,20.61) v8(239.77,1.99) v8(240.2,0.83) v8(240.38,5.45) v8(240.49,20.34) v8(241.04,1.99) v8(241.35,20.1) v8(241.47,0.83) v8(242.31,19.87) v8(242.31,1.99) v8(242.39,0.9) v8(242.88,11.24) v8(242.95,6.13) v8(243.22,11.24) v8(243.4,19.66) v8(243.4,1.83) v8(243.65,5.63) v8(244.25,5.63) v8(244.58,19.49) v8(244.67,1.83) v8(245.87,19.38) v8(245.94,1.83) v8(246.05,5.63) v8(247.23,19.34) v8(247.21,1.83) v8(247.77,11.4) v8(248.36,11.4) v8(248.49,19.37) v8(248.48,1.83) v8(248.94,11.4) v8(249.65,19.45) v8(249.75,1.83) v8(250.44,10.39) v8(250.84,19.6) v8(251.02,1.83) v8(251.83,10.39) v8(252.04,19.82) v8(252.29,1.83) v8(253.33,11.36) v8(253.37,20.13) v8(253.56,1.83) v8(254.16,11.36) v8(254.15,8.93) v8(254.45,5.63) v8(254.69,20.52) v8(254.83,1.83) v8(254.99,11.36) v8(255.62,11.44) v8(255.89,20.96) v8(255.95,8.93) v8(256.1,1.83) v8(256.85,5.63) v8(257.02,11.44) v8(257.3,21.56) v8(257.37,1.83) v8(257.45,5.63) v8(257.59,9.74) v8(258.22,7.91) v8(258.64,1.83) v8(258.75,22.3) v8(259.35,6.13) v8(260.04,0.85) v8(260.15,23.14) v8(260.38,4.95) v8(260.4,4.44) v8(260.4,3.88) v8(260.4,3.35) v8(260.4,2.87) v8(260.57,1.75) v8(261.01,4.95) v8(261.04,4.44) v8(261.04,3.88) v8(261.04,3.35) v8(261.04,2.87) v8(261.09,0.83) v8(261.53,24.11) v8(261.84,1.75) v8(262.36,0.83) v8(262.72,25.07) v8(263.11,1.75) v8(263.63,0.83) v8(263.72,25.98) v8(264.4,20.53) v8(264.38,1.75) v8(264.47,21.32) v8(264.9,0.83) v8(265.15,3.4) v8(265.15,2.89) v8(265.15,2.39) v8(265.16,4.6) v8(265.21,4.04) v8(265.49,4.6) v8(265.52,4.04) v8(265.84,4.6) v8(265.8,4.04) v8(265.78,3.4) v8(265.78,2.89) v8(265.78,2.39) v8(266.02,8.61) v8(265.97,7.76) v8(266.17,0.83) v8(266.42,3.4) v8(266.42,2.89) v8(266.42,2.39) v8(266.48,4.6) v8(266.51,4.04) v8(266.81,4.6) v8(266.81,4.04) v8(266.93,7.75) v8(267.09,4.04) v8(267.05,3.4) v8(267.05,2.89) v8(267.05,2.39) v8(267.16,4.6) v8(267.44,0.83) v8(267.69,2.51) v8(267.88,22.96) v8(267.89,4.37) v8(267.89,3.99) v8(267.89,3.61) v8(267.89,3.22) v8(267.96,19.96) v8(267.97,4.86) v8(268.18,17.08) v8(268.25,10.9) v8(268.68,4.86) v8(268.71,0.83) v8(268.82,17.08) v8(269.01,4.49) v8(269.1,3.81) v8(269.18,3.17) v8(269.18,2.79) v8(269.2,2.07) v8(269.34,4.49) v8(269.42,58.27) v8(269.42,57) v8(269.42,55.73) v8(269.4,23.21) v8(269.35,4.86) v8(269.45,17.08) v8(269.6,3.81) v8(269.67,4.49) v8(269.78,23.66) v8(269.82,3.17) v8(269.82,2.79) v8(269.83,2.07) v8(270.02,4.86) v8(270,4.49) v8(269.98,0.83) v8(270.09,17.08) v8(270.1,3.81) v8(270.33,4.49) v8(270.49,19.91) v8(270.45,3.17) v8(270.45,2.79) v8(270.47,2.07) v8(270.6,3.81) v8(270.85,17.31) v8(270.79,8.65) v8(271.29,11.44) v8(271.25,0.83) v8(272.03,71.35) v8(272.03,70.08) v8(272.18,11.52) v8(272.52,0.83) v8(272.56,11.52) v8(273.06,10.45) v8(273.3,71.35) v8(273.3,70.08) v8(273.36,10.45) v8(273.64,10.45) v8(274.57,71.35) v8(274.57,70.08) v8(275.11,71.09) v8(275.92,71.09) v8(275.9,42.13) v8(276.13,10.32) v8(276.45,32.83) v8(276.63,55.04) v8(276.92,70.09) v8(276.89,9.61) v8(277.02,59.47) v8(277.15,69.24) v8(277.31,64.11) v8(277.55,39.76) v8(277.72,70.59) v8(278.41,64.11) v8(278.55,69.24) v8(278.61,71.41) v8(278.92,69.16) v8(278.89,27.76) v8(278.89,25.53) v8(279.43,72.24) v8(279.43,68.27) v8(279.62,38.34) v8(279.65,42.86) v8(279.93,72.77) v8(279.92,70.51) v8(280,26.64) v8(280.25,65.8) v8(280.63,42.86) v8(280.6,2.54) v8(280.85,41.62) v8(280.91,2.54) v8(281.12,27.76) v8(281.12,25.53) v8(281.19,6.83) v8(281.16,6.49) v8(281.19,2.54) v8(281.26,66.46) v8(281.41,13.55) v8(281.63,41.62) v8(281.78,67.54) v8(281.85,6.81) v8(281.85,6.49) v8(281.82,2.54) v8(282.13,2.54) v8(282.35,6.49) v8(282.41,2.54) v8(282.47,7.8) v8(282.88,16.08) v8(282.88,14.82) v8(282.88,13.55) v8(282.88,12.29) v8(282.88,11.03) v8(282.99,6.64) v8(283.02,2.57) v8(283.23,7.53) v8(283.32,2.57) v8(283.58,6.64) v8(283.6,2.57) v8(283.69,35.67) v8(284.27,35.67) v8(284.36,14.82) v8(284.36,13.55) v8(284.36,12.29) v8(284.68,39.01) v8(284.68,38.27) v8(285.08,34.96) v8(285.4,34.96) v8(285.47,33.56) v8(285.5,27.28) v8(285.5,26.64) v8(285.5,26.01) v8(285.5,23.34) v8(285.72,28.64) v8(285.78,33.56) v8(285.95,27.41) v8(286.25,30.3) v8(286.38,29.36) v8(287.5,21) v8(287.62,25.87) v8(287.66,19.74) v8(288.02,13.55) v8(288.73,26.01) v8(288.74,21) v8(288.89,3.07) v8(289.07,19.71) v8(289.41,4.33) v8(289.41,1.81) v8(289.83,21) v8(290.67,4.85) v8(290.67,1.29) v8(290.99,44.04) v8(291.17,45.55) v8(291.18,19.79) v8(291.88,43.98) v8(291.93,4.33) v8(291.93,1.81) v8(292.45,3.07) v9(0.4,3.11) v9(0.92,4.37) v9(0.92,1.85) v9(2.18,4.89) v9(2.18,1.33) v9(3.44,4.37) v9(3.44,1.85) v9(3.96,3.11) v9(4.86,17.11) v9(5.43,17.11) v9(6,17.11) v9(6.57,17.11) v9(8.88,20.57) v9(8.89,6.51) v9(8.99,5.62) v9(9.07,63.92) v9(9.07,63.35) v9(9.07,61.82) v9(9.07,61.25) v9(9.33,20.12) v9(9.78,19.67) v9(10.4,16.84) v9(10.65,18.8) v9(10.69,6.52) v9(10.72,5.64) v9(11.1,18.35) v9(12.18,58.9) v9(12.35,60.87) v9(12.41,6.52) v9(12.44,5.64) v9(12.91,62.96) v9(12.91,61.57) v9(12.91,60.55) v9(12.91,59.14) v9(13.2,65.56) v9(13.2,63.65) v9(13.92,65.36) v9(13.92,63.98) v9(14.57,60.4) v9(14.57,59.3) v9(15.76,66.13) v9(15.76,65.04) v9(16.96,61.8) v9(17.06,62.61) v9(20.11,0.83) v9(21.38,0.83) v9(22.65,0.83) v9(23.02,18.64) v9(23.92,0.83) v9(25.19,0.83) v9(26.46,0.83) v9(27.73,0.83) v9(29,0.83) v9(30.27,0.83) v9(31.54,0.83) v9(50.32,3.02) v9(51.59,3.02) v9(52.99,3.02) v9(53.86,0.83) v9(54.33,2.26) v9(55.13,0.83) v9(55.6,2.26) v9(56.4,0.83) v9(56.99,2.26) v9(57.67,0.83) v9(58.26,2.26) v9(58.94,0.83) v9(59.53,2.26) v9(60.21,0.83) v9(61.06,2.51) v9(61.48,0.83) v9(62.33,2.51) v9(62.75,0.83) v9(63.6,2.51) v9(64.02,0.83) v9(64.87,2.51) v9(65.29,0.83) v9(66.14,2.51) v9(69.79,70.53) v9(69.79,69.26) v9(69.79,67.99) v9(69.79,66.72) v9(69.79,65.45) v9(69.79,64.18) v9(69.79,62.91) v9(69.79,61.64) v9(69.79,60.37) v9(69.79,59.1) v9(69.79,57.83) v9(69.79,56.56) v9(69.79,55.29) v9(69.79,54.02) v9(69.79,52.75) v9(69.79,51.48) v9(69.79,50.21) v9(69.79,48.94) v9(69.79,47.67) v9(69.79,46.4) v9(69.79,45.13) v9(69.79,43.86) v9(69.79,42.59) v9(69.79,41.32) v9(69.79,40.05) v9(69.79,38.78) v9(69.79,37.51) v9(69.79,36.24) v9(69.79,34.97) v9(69.79,33.7) v9(69.79,32.43) v9(69.79,31.16) v9(69.79,28.62) v9(69.79,27.35) v9(69.79,26.08) v9(69.79,24.81) v9(69.79,23.54) v9(69.79,22.27) v9(69.79,21) v9(69.79,19.73) v9(70.45,74.4) v9(70.78,71.37) v9(71.47,72.06) v9(71.72,74.4) v9(72.3,73.1) v9(72.55,68.45) v9(72.55,67.18) v9(72.94,73.53) v9(72.99,74.4) v9(73.83,73.53) v9(73.82,69.72) v9(73.82,68.45) v9(73.82,67.18) v9(74.18,66.58) v9(74.16,65.85) v9(74.2,65.06) v9(74.19,64.21) v9(74.2,63.65) v9(74.26,76.94) v9(74.26,75.63) v9(74.26,74.4) v9(75.1,73.53) v9(75.09,69.72) v9(75.09,68.45) v9(75.09,67.18) v9(75.53,76.94) v9(75.53,75.63) v9(75.53,74.4) v9(75.79,2.01) v9(76.17,77.82) v9(76.36,69.72) v9(76.36,68.45) v9(76.36,67.18) v9(76.8,76.94) v9(76.8,75.63) v9(76.8,74.4) v9(77.06,2.01) v9(77.64,73.53) v9(77.63,69.72) v9(77.63,68.45) v9(77.63,67.18) v9(78.07,76.94) v9(78.07,75.63) v9(78.07,74.4) v9(78.26,62.48) v9(78.26,61.21) v9(78.33,2.01) v9(78.9,69.72) v9(78.9,68.45) v9(78.9,67.18) v9(79.34,76.94) v9(79.34,75.63) v9(79.34,74.4) v9(79.53,62.48) v9(79.53,61.21) v9(79.6,2.01) v9(80.17,69.72) v9(80.17,68.45) v9(80.17,67.18) v9(80.61,76.94) v9(80.61,75.63) v9(80.61,74.4) v9(80.8,62.48) v9(80.8,61.21) v9(80.87,2.01) v9(81.07,73.51) v9(81.44,69.72) v9(81.44,68.45) v9(81.44,67.18) v9(81.88,76.94) v9(81.88,75.63) v9(81.88,74.4) v9(82.07,62.48) v9(82.07,61.21) v9(82.14,2.01) v9(82.21,73.51) v9(82.71,69.72) v9(82.71,68.45) v9(82.71,67.18) v9(83.15,76.94) v9(83.15,75.63) v9(83.15,74.4) v9(83.34,62.48) v9(83.34,61.21) v9(83.28,2.01) v9(83.48,73.51) v9(83.98,69.72) v9(83.98,68.45) v9(83.98,67.18) v9(84.42,76.94) v9(84.42,75.63) v9(84.42,74.4) v9(84.61,62.48) v9(84.61,61.21) v9(84.55,2.01) v9(84.75,73.51) v9(85.25,68.45) v9(85.25,67.18) v9(85.31,77.82) v9(85.54,73.14) v9(85.63,62.65) v9(85.63,61.63) v9(85.63,60.68) v9(85.69,76.94) v9(85.69,75.63) v9(85.69,74.4) v9(85.82,2.01) v9(86.39,62.97) v9(86.39,60.3) v9(86.58,73.13) v9(86.61,72.19) v9(86.96,76.94) v9(86.96,75.63) v9(86.96,74.4) v9(87.03,62.97) v9(87.03,60.3) v9(87.15,71.86) v9(87.45,71.35) v9(87.73,62.65) v9(87.73,61.63) v9(87.79,60.68) v9(87.85,73.13) v9(88.23,76.94) v9(88.23,75.63) v9(88.23,74.4) v9(88.42,71.86) v9(88.42,70.59) v9(88.64,62.05) v9(88.84,69.98) v9(89.12,73.13) v9(89.06,61.66) v9(89.08,61.06) v9(89.08,60.3) v9(89.14,59.54) v9(89.44,59.1) v9(89.38,57.06) v9(89.38,56.04) v9(89.38,55.09) v9(89.5,76.94) v9(89.5,75.63) v9(89.5,74.4) v9(89.69,71.86) v9(89.69,70.59) v9(89.9,66.67) v9(89.89,58.69) v9(90.08,57.38) v9(90.08,54.77) v9(90.34,58.23) v9(90.39,73.13) v9(90.49,69.95) v9(90.71,57.38) v9(90.71,54.77) v9(90.8,77.67) v9(90.77,76.94) v9(90.77,75.63) v9(90.77,74.4) v9(91.02,58.15) v9(91.33,66.7) v9(91.43,77.67) v9(91.47,57.06) v9(91.47,56.04) v9(91.47,55.09) v9(91.64,58.16) v9(91.93,66.41) v9(92.04,76.94) v9(92.04,75.63) v9(92.04,74.4) v9(92.13,77.67) v9(92.25,58.15) v9(92.32,69.95) v9(92.49,65.84) v9(92.87,58.16) v9(93.07,65.26) v9(93.31,76.94) v9(93.31,75.63) v9(93.31,74.4) v9(93.31,64.29) v9(93.33,63.12) v9(93.39,58.16) v9(93.4,56.78) v9(93.4,55.83) v9(93.5,77.82) v9(93.7,69.95) v9(94.14,58.15) v9(94.13,57.08) v9(94.11,55.61) v9(94.14,54.25) v9(94.34,56.84) v9(94.36,57.49) v9(94.42,56.09) v9(94.52,65.17) v9(94.51,64.6) v9(94.5,64.02) v9(94.58,76.94) v9(94.58,75.63) v9(94.58,74.4) v9(94.63,71.99) v9(94.59,71.01) v9(94.7,62.1) v9(94.66,54.77) v9(94.77,77.82) v9(94.81,55.23) v9(94.88,65.92) v9(94.91,63.24) v9(94.89,53.5) v9(94.97,73.25) v9(94.97,69.95) v9(95.08,56.07) v9(95.15,54.31) v9(95.19,57.52) v9(95.22,56.83) v9(95.3,65.2) v9(95.28,64.6) v9(95.26,64.02) v9(95.28,58.15) v9(95.52,52.87) v9(95.73,63.63) v9(95.74,62.09) v9(95.79,71.98) v9(95.85,76.94) v9(95.85,75.63) v9(95.85,74.4) v9(95.86,71.01) v9(95.88,58.15) v9(96.04,77.82) v9(96.06,53.38) v9(96.24,73.25) v9(96.55,52.06) v9(96.65,58.16) v9(96.65,52.78) v9(97,63.63) v9(97.01,62.09) v9(97.09,76.94) v9(97.12,75.63) v9(97.12,74.4) v9(97.06,71.98) v9(97.44,69.95) v9(97.43,58.14) v9(97.51,73.25) v9(97.61,69.54) v9(97.82,52.04) v9(98.08,70.97) v9(98.08,69.95) v9(98.33,71.98) v9(98.27,63.63) v9(98.28,62.09) v9(98.39,75.63) v9(98.39,74.4) v9(98.36,52.81) v9(98.78,73.25) v9(98.9,75.67) v9(98.88,69.54) v9(98.88,58.14) v9(99.04,52.03) v9(99.22,76.94) v9(99.16,70.46) v9(99.54,69.95) v9(99.54,63.63) v9(99.55,62.09) v9(99.6,71.98) v9(99.56,58.14) v9(99.66,76.94) v9(99.66,75.63) v9(99.66,74.4) v9(99.74,52.79) v9(100.05,73.25) v9(100.15,69.54) v9(100.11,58.16) v9(100.62,52.06) v9(100.81,69.95) v9(100.82,68.5) v9(100.93,76.94) v9(100.94,75.72) v9(100.93,74.4) v9(100.87,72.68) v9(100.87,71.98) v9(101.09,69.54) v9(101.24,52.78) v9(101.32,73.25) v9(101.44,77.82) v9(101.38,69.76) v9(101.38,68.49) v9(101.38,67.22) v9(101.38,65.95) v9(101.38,64.68) v9(101.38,63.41) v9(101.38,62.14) v9(101.38,60.87) v9(101.38,59.6) v9(101.38,58.33) v9(101.38,57.06) v9(101.38,55.79) v9(101.38,54.52) v9(101.82,70.97) v9(101.84,52.32) v9(102.2,76.94) v9(102.21,75.72) v9(102.2,74.4) v9(102.27,72.68) v9(102.27,71.98) v9(102.27,68.74) v9(102.65,70.24) v9(102.64,69.52) v9(102.71,77.82) v9(102.71,73.25) v9(102.94,58.3) v9(103.22,62.06) v9(103.18,57.47) v9(103.35,69.75) v9(103.3,56.17) v9(103.47,76.94) v9(103.47,75.63) v9(103.47,74.4) v9(103.54,72.68) v9(103.54,71.98) v9(103.52,61.45) v9(103.52,60.72) v9(103.52,59.79) v9(103.52,58.99) v9(103.66,70.2) v9(103.74,63.7) v9(103.93,68.79) v9(103.93,67.16) v9(103.92,65.91) v9(103.87,64.87) v9(103.98,77.82) v9(103.98,73.25) v9(104.55,70.97) v9(104.74,76.94) v9(104.74,75.63) v9(104.74,74.4) v9(104.81,72.68) v9(105,62.14) v9(105.2,57.35) v9(105.25,73.25) v9(105.63,60.95) v9(105.67,59.09) v9(105.8,72.78) v9(105.89,75.54) v9(106.01,76.94) v9(106.01,74.4) v9(106.34,62.15) v9(106.52,73.25) v9(106.53,60.35) v9(106.55,58.52) v9(106.65,74.78) v9(106.8,72.77) v9(106.9,76.3) v9(107.21,76.94) v9(107.41,74.01) v9(107.67,75.54) v9(107.79,73.25) v9(107.92,76.33) v9(108.07,72.77) v9(108.43,74.9) v9(108.43,73.63) v9(108.55,76.94) v9(108.55,75.69) v9(109.06,73.25) v9(109.19,76.33) v9(109.34,72.77) v9(109.44,75.03) v9(109.44,73.38) v9(109.66,18.96) v9(109.82,76.94) v9(109.82,75.69) v9(109.99,75.21) v9(109.99,73.29) v9(110.33,74.71) v9(110.33,74.27) v9(110.33,73.82) v9(110.46,76.33) v9(110.55,75.21) v9(110.55,73.29) v9(110.61,72.77) v9(110.84,74.71) v9(110.84,74.27) v9(110.84,73.82) v9(111.09,76.94) v9(111.09,75.69) v9(111.11,75.21) v9(111.11,73.29) v9(111.55,74.25) v9(111.73,76.33) v9(111.73,75.03) v9(111.88,72.77) v9(111.98,77.82) v9(111.98,73.38) v9(112.36,76.94) v9(112.36,75.69) v9(112.36,74.4) v9(112.97,72.77) v9(113.15,76.34) v9(113.15,75.04) v9(113.51,73.38) v9(113.63,76.94) v9(113.63,75.69) v9(113.63,74.4) v9(114.24,72.77) v9(114.29,76.33) v9(114.27,75.03) v9(114.78,73.38) v9(114.9,76.94) v9(114.9,75.69) v9(114.9,74.4) v9(115.54,76.33) v9(115.54,75.03) v9(115.51,72.77) v9(116.05,77.82) v9(116.05,73.38) v9(116.17,76.94) v9(116.17,75.69) v9(116.17,74.4) v9(116.81,76.33) v9(116.81,75.03) v9(116.78,72.77) v9(117.32,73.38) v9(117.44,76.94) v9(117.44,75.69) v9(117.44,74.4) v9(118.13,76.33) v9(118.13,75.04) v9(118.05,72.77) v9(118.59,73.38) v9(118.71,76.94) v9(118.71,75.69) v9(118.71,74.4) v9(119.35,76.33) v9(119.35,75.03) v9(119.32,72.77) v9(119.86,73.38) v9(119.98,76.94) v9(119.98,75.69) v9(119.98,74.4) v9(120.31,72.82) v9(121.01,73.39) v9(121.27,79.64) v9(121.28,78.36) v9(121.37,80.64) v9(121.6,33.89) v9(121.74,76.58) v9(121.74,75.84) v9(121.69,74.24) v9(122.09,80.4) v9(122.35,29.91) v9(122.36,81.6) v9(122.47,76.55) v9(122.52,75.06) v9(122.99,35.37) v9(123.24,75.74) v9(123.35,82.65) v9(123.61,76.6) v9(123.86,36.24) v9(123.88,33.46) v9(124.04,79.14) v9(124.07,83.39) v9(124.12,29.11) v9(124.68,74.33) v9(124.82,80.45) v9(125.1,83.96) v9(125.06,76.6) v9(125.32,75.09) v9(126.02,75.92) v9(125.95,74.33) v9(126.33,83.96) v9(126.28,76.6) v9(126.59,75.09) v9(126.92,77.99) v9(126.97,73.73) v9(127.29,75.92) v9(127.43,76.59) v9(127.81,80.5) v9(127.81,80.12) v9(127.79,74.78) v9(127.95,79.14) v9(128.24,73.73) v9(128.52,76.62) v9(128.72,84.17) v9(128.72,77.4) v9(129.13,81.48) v9(129.06,74.78) v9(129.2,84.45) v9(129.51,73.73) v9(129.95,81.48) v9(130.14,75.47) v9(130.13,74.65) v9(130.3,76.81) v9(130.3,75.87) v9(130.8,84.45) v9(130.78,81.48) v9(130.78,73.73) v9(131.16,76.81) v9(131.16,75.87) v9(131.16,75.47) v9(131.4,74.65) v9(132.05,84.45) v9(132.01,76.81) v9(132.01,75.87) v9(132.05,73.73) v9(132.24,75.47) v9(132.67,74.65) v9(133.12,84.43) v9(133.32,73.73) v9(133.94,74.65) v9(134.45,83.83) v9(134.59,73.73) v9(135.21,74.65) v9(135.8,83.88) v9(135.86,73.73) v9(136.18,75.28) v9(136.48,74.65) v9(137.07,83.88) v9(137.13,73.73) v9(137.45,75.28) v9(137.75,74.65) v9(138.4,73.73) v9(138.58,83.83) v9(138.72,75.28) v9(138.96,74.65) v9(139.54,72.74) v9(139.67,73.73) v9(140.04,83.83) v9(140.34,74.65) v9(140.81,72.74) v9(141.13,76.07) v9(141.28,83.87) v9(141.42,74.65) v9(142.13,77.7) v9(142.08,72.74) v9(142.16,76.27) v9(142.16,75.82) v9(142.37,79.31) v9(142.51,83.83) v9(142.84,79.32) v9(143.05,79.98) v9(143.02,77.72) v9(143.03,76.38) v9(143.02,75.82) v9(143.38,83.02) v9(143.39,81.84) v9(143.35,79.3) v9(143.35,72.74) v9(143.94,79.32) v9(143.86,77.7) v9(143.86,76.35) v9(143.86,75.79) v9(144.01,72.74) v9(145.16,78.71) v9(145.24,27.42) v9(146.02,78.08) v9(147.04,78.1) v9(147.97,24.78) v9(148.53,78.15) v9(149.8,27.21) v9(149.96,78.13) v9(150.13,23.42) v9(151.23,78.76) v9(151.16,26.58) v9(151.61,23.47) v9(152.34,81.41) v9(152.34,79.91) v9(152.42,83.41) v9(152.69,82.79) v9(152.71,80.64) v9(153.02,84.03) v9(153.02,77.2) v9(153.87,84.5) v9(153.93,83.39) v9(154.99,83.41) v9(155.26,84.5) v9(155.9,83.39) v9(156.05,72.17) v9(156.33,84.5) v9(156.64,83.4) v9(156.88,72.87) v9(157.25,84.5) v9(157.32,72.17) v9(158.11,84.5) v9(158.15,72.87) v9(158.15,21.25) v9(158.59,72.17) v9(159.25,84.5) v9(159.42,72.87) v9(159.86,72.17) v9(160.34,84.5) v9(160.39,26.17) v9(160.69,72.87) v9(161.13,72.17) v9(161.96,72.87) v9(162.2,84.5) v9(162.4,72.17) v9(162.4,58.56) v9(162.74,84.77) v9(163.23,72.87) v9(164.05,84.5) v9(164.36,47.6) v9(164.5,72.87) v9(165.27,84.5) v9(166.41,44.06) v9(166.69,84.5) v9(167.46,77.68) v9(167.82,76.87) v9(168.07,84.53) v9(168.4,77.1) v9(168.4,45.86) v9(168.85,76.01) v9(169.26,84.53) v9(169.77,36.13) v9(169.96,25.82) v9(170.13,84.03) v9(170.34,45.31) v9(170.7,44.93) v9(170.83,82.98) v9(170.81,81.94) v9(170.81,80.8) v9(170.83,79.78) v9(170.98,44.61) v9(171.9,78.61) v9(171.88,77.19) v9(171.88,76.15) v9(171.99,57.38) v9(172.05,55.73) v9(172.37,74.99) v9(172.52,22.33) v9(173.64,73.89) v9(174.09,73.32) v9(174.48,64.11) v9(174.51,62.06) v9(174.66,73.82) v9(175.23,73.32) v9(175.31,64.08) v9(175.4,74.25) v9(175.74,61.78) v9(175.84,75.21) v9(175.84,73.29) v9(176.12,74.71) v9(176.12,74.27) v9(176.12,73.82) v9(176.19,64.11) v9(176.4,75.21) v9(176.4,73.29) v9(176.37,62.81) v9(176.61,60.51) v9(176.63,7.73) v9(176.69,74.71) v9(176.69,74.27) v9(176.69,73.82) v9(176.84,62.01) v9(176.96,75.21) v9(176.96,73.29) v9(177.07,61.23) v9(177.25,62.83) v9(177.64,75.09) v9(177.58,73.38) v9(177.9,61.44) v9(178.15,70.56) v9(178.24,63.12) v9(178.24,62.1) v9(178.25,64.03) v9(178.59,74.9) v9(178.59,73.57) v9(178.72,70.56) v9(178.67,60.63) v9(179.13,63.05) v9(179.2,61.16) v9(179.29,70.56) v9(179.36,73.06) v9(179.36,72.55) v9(179.36,72.05) v9(179.36,71.47) v9(179.86,74.9) v9(179.86,73.57) v9(179.86,72.81) v9(179.86,72.05) v9(179.86,64.06) v9(179.93,62.11) v9(180.12,73.06) v9(180.31,71.47) v9(180.52,60.83) v9(180.5,60.15) v9(180.56,63.02) v9(181.13,74.9) v9(181.13,73.57) v9(181.13,73.13) v9(181.13,72.81) v9(181.13,72.05) v9(181.29,64.04) v9(181.49,62.15) v9(181.78,60.86) v9(181.85,60.06) v9(181.95,58.53) v9(182.15,63.02) v9(182.4,74.9) v9(182.4,73.57) v9(182.4,73.13) v9(182.4,72.81) v9(182.4,72.05) v9(182.63,60.39) v9(182.72,64.04) v9(182.68,59.04) v9(182.68,58.24) v9(183.1,62.03) v9(183.67,74.9) v9(183.67,73.57) v9(183.67,72.68) v9(183.67,72.05) v9(183.78,58.98) v9(183.87,63.13) v9(184.12,77.32) v9(184.26,64.04) v9(184.33,60.92) v9(184.94,74.9) v9(184.94,73.57) v9(184.94,72.68) v9(184.94,72.05) v9(184.94,62.09) v9(185.07,76.43) v9(185.07,73.13) v9(185.62,35.74) v9(185.68,62.62) v9(185.66,58.98) v9(185.91,60.7) v9(186.03,7.73) v9(186.21,74.9) v9(186.21,73.57) v9(186.21,73.13) v9(186.21,72.68) v9(186.21,72.05) v9(186.2,64.11) v9(186.34,76.43) v9(186.65,61.63) v9(187.04,77.82) v9(187.48,74.9) v9(187.48,73.57) v9(187.48,73.13) v9(187.48,72.68) v9(187.48,72.05) v9(187.74,77.89) v9(187.74,77.38) v9(187.74,76.87) v9(187.74,76.36) v9(187.74,75.86) v9(187.74,75.35) v9(187.74,64.08) v9(187.68,60.35) v9(187.7,58.56) v9(188.44,62.23) v9(188.51,63.46) v9(188.56,77.89) v9(188.56,77.38) v9(188.56,76.87) v9(188.56,76.36) v9(188.56,75.86) v9(188.56,75.35) v9(188.75,74.9) v9(188.75,73.57) v9(188.75,73.13) v9(188.75,72.68) v9(188.75,72.05) v9(188.92,61.62) v9(189.07,61.02) v9(189.1,60.02) v9(189.06,58.48) v9(189.33,77.89) v9(189.33,77.38) v9(189.33,76.87) v9(189.33,76.36) v9(189.33,75.86) v9(189.33,75.35) v9(189.59,64.03) v9(189.8,63.07) v9(190.02,74.9) v9(190.02,73.57) v9(190.02,73.13) v9(190.02,72.81) v9(190.02,72.05) v9(190.22,77.89) v9(190.22,77.38) v9(190.22,76.87) v9(190.22,76.36) v9(190.22,75.86) v9(190.22,75.35) v9(190.41,68.74) v9(190.47,59.89) v9(190.47,59.37) v9(190.6,70.5) v9(190.58,63.68) v9(190.62,35.74) v9(190.98,73.13) v9(190.98,72.81) v9(191.06,58.88) v9(191.17,70.5) v9(191.29,74.9) v9(191.29,73.57) v9(191.29,72.05) v9(191.29,71.47) v9(191.42,76.43) v9(191.68,77.84) v9(191.74,70.5) v9(191.99,75.55) v9(192.07,73.76) v9(192.06,73.06) v9(192.06,72.68) v9(192.06,72.05) v9(192.06,71.47) v9(192.56,74.27) v9(192.76,76.31) v9(193.15,71.85) v9(193.39,76.94) v9(193.64,75.35) v9(193.77,70.33) v9(194.14,77.66) v9(194.1,73.5) v9(194.06,62.58) v9(194.06,60.17) v9(194.72,76.43) v9(195.51,76.71) v9(195.84,78.61) v9(195.84,78.07) v9(195.9,74.22) v9(196,73.5) v9(196.2,70.32) v9(196.53,76.71) v9(196.49,63.84) v9(196.97,72.11) v9(197.11,78.61) v9(197.11,78.07) v9(197.1,73.29) v9(197.33,72.85) v9(197.52,72.29) v9(197.64,73.25) v9(197.8,76.71) v9(198.15,72.82) v9(198.19,73.25) v9(198.28,72.3) v9(198.38,78.61) v9(198.5,78.08) v9(198.75,73.25) v9(199.07,76.71) v9(199.3,78.05) v9(199.65,78.61) v9(199.71,78.15) v9(199.77,3.66) v9(199.77,3.02) v9(200.12,37.86) v9(200.53,77.07) v9(200.76,37.86) v9(201,78.61) v9(201,77.89) v9(201,76.67) v9(201.39,37.86) v9(201.51,78.61) v9(201.51,77.89) v9(201.51,76.67) v9(201.89,74.1) v9(202.03,37.86) v9(202.11,75.45) v9(202.11,74.83) v9(202.56,74.31) v9(202.56,73.7) v9(202.56,73.09) v9(202.72,78.61) v9(202.72,77.89) v9(202.72,76.67) v9(202.72,75.45) v9(202.71,74.83) v9(202.66,37.86) v9(203.17,74.31) v9(203.17,73.7) v9(203.17,73.09) v9(203.78,74.31) v9(203.85,73.07) v9(203.99,78.61) v9(203.99,77.89) v9(203.99,76.67) v9(203.99,75.45) v9(203.98,74.83) v9(204.39,74.31) v9(204.39,73.7) v9(205,74.31) v9(205.26,78.61) v9(205.26,77.89) v9(205.26,76.67) v9(205.26,75.45) v9(205.25,74.83) v9(205.61,74.31) v9(205.61,73.7) v9(206.02,75.45) v9(206.22,74.31) v9(206.53,78.61) v9(206.53,77.89) v9(206.53,76.67) v9(206.94,77.57) v9(206.94,76.76) v9(206.94,75.82) v9(206.94,75.13) v9(206.94,74.56) v9(206.94,74.05) v9(207.75,77.57) v9(207.75,76.76) v9(207.75,75.82) v9(207.75,75.13) v9(207.75,74.56) v9(207.75,74.05) v9(208.56,77.57) v9(208.56,76.76) v9(208.56,75.82) v9(208.56,75.13) v9(208.56,74.56) v9(208.56,74.05) v9(209.2,71.54) v9(209.27,70.39) v9(209.37,77.57) v9(209.37,76.76) v9(209.37,75.82) v9(209.37,75.13) v9(209.37,74.56) v9(209.37,74.05) v9(209.52,22.73) v9(210.19,77.57) v9(210.19,76.76) v9(210.19,75.82) v9(210.19,75.13) v9(210.19,74.56) v9(210.19,74.05) v9(211.19,75.74) v9(211.19,74.05) v9(212,75.74) v9(212,74.05) v9(212.31,72.74) v9(212.82,75.74) v9(212.82,74.05) v9(213.63,75.74) v9(213.63,74.05) v9(214.35,72.74) v9(214.44,75.74) v9(214.44,74.06) v9(215.11,71.41) v9(215.25,75.74) v9(215.25,74.06) v9(216.07,75.74) v9(216.07,74.81) v9(216.07,74.06) v9(216.69,58.33) v9(216.88,75.74) v9(216.88,74.81) v9(216.88,74.06) v9(217.27,71.41) v9(217.52,77.51) v9(217.52,76.87) v9(217.52,76.24) v9(217.52,75.6) v9(217.69,74.81) v9(217.69,74.06) v9(217.96,1.84) v9(218.16,77.51) v9(218.16,76.87) v9(218.16,76.24) v9(218.16,75.6) v9(218.16,72.55) v9(218.51,74.81) v9(218.51,74.06) v9(218.54,1.84) v9(218.79,77.51) v9(218.79,76.87) v9(218.79,76.24) v9(218.79,75.6) v9(219.17,77.82) v9(219.32,74.81) v9(219.32,74.06) v9(219.43,77.51) v9(219.43,76.87) v9(219.43,76.24) v9(219.43,75.6) v9(220.13,75.6) v9(220.13,74.81) v9(220.13,74.06) v9(220.31,72.81) v9(220.31,71.92) v9(220.84,75.69) v9(220.84,75.13) v9(220.84,74.56) v9(220.85,74.06) v9(222.09,70.97) v9(222.6,69.82) v9(226.85,2.64) v9(227.5,0.83) v9(227.93,2.64) v9(228.77,0.83) v9(229.2,2.64) v9(229.27,7.59) v9(229.71,9.12) v9(230.04,0.83) v9(230.47,2.64) v9(231.31,0.83) v9(231.74,2.64) v9(232.58,0.83) v9(233.85,0.83) v9(234.28,2.64) v9(234.54,7.59) v9(234.79,5.56) v9(235.12,0.83) v9(235.55,2.64) v9(235.81,7.59) v9(235.99,21.32) v9(236.19,5.56) v9(236.39,0.83) v9(236.82,2.64) v9(237.21,7.59) v9(237.38,20.18) v9(237.66,0.83) v9(238.09,2.64) v9(238.48,7.59) v9(238.86,20.89) v9(238.93,0.83) v9(239.05,19.92) v9(239.36,2.64) v9(239.64,20.61) v9(239.75,7.59) v9(240.2,0.83) v9(240.49,20.34) v9(240.63,2.64) v9(241.35,20.1) v9(241.47,0.83) v9(241.9,2.64) v9(242.31,19.87) v9(242.42,1.15) v9(242.77,18.78) v9(243.17,2.64) v9(243.4,19.66) v9(243.4,1.83) v9(244.18,18.78) v9(244.44,2.64) v9(244.58,19.49) v9(244.67,1.83) v9(245.35,18.77) v9(245.71,2.64) v9(245.87,19.38) v9(245.94,1.83) v9(246.98,2.64) v9(247.23,19.34) v9(247.21,18.77) v9(247.21,1.83) v9(248.25,2.64) v9(248.49,19.37) v9(248.48,1.83) v9(249.52,2.64) v9(249.65,19.45) v9(249.79,18.78) v9(249.75,1.83) v9(250.84,19.6) v9(250.79,2.64) v9(251.02,1.83) v9(252.04,19.82) v9(252.06,2.64) v9(252.23,18.88) v9(252.29,1.83) v9(253.33,2.64) v9(253.37,20.13) v9(253.56,1.83) v9(254.31,19.09) v9(254.6,2.64) v9(254.69,20.52) v9(254.83,1.83) v9(255.8,19.63) v9(255.89,20.96) v9(255.87,2.64) v9(256.1,1.83) v9(257.06,19.02) v9(257.14,2.64) v9(257.3,21.56) v9(257.37,1.83) v9(257.49,20.61) v9(258.41,2.64) v9(258.64,1.83) v9(258.75,22.3) v9(258.83,20.5) v9(259.68,2.64) v9(259.8,22.08) v9(260.15,23.14) v9(260.09,0.83) v9(260.95,2.64) v9(261.09,0.83) v9(261.53,24.11) v9(262.07,21.79) v9(262.22,2.64) v9(262.35,23.28) v9(262.36,0.83) v9(262.72,25.07) v9(263.49,2.64) v9(263.63,0.83) v9(263.72,25.98) v9(264.19,24.69) v9(264.76,2.64) v9(264.9,0.83) v9(265.01,23.81) v9(266.03,2.64) v9(266.17,0.83) v9(266.86,26.12) v9(267.3,24.34) v9(267.3,2.64) v9(267.44,0.83) v9(268.07,61.05) v9(268.29,55.26) v9(268.29,53.99) v9(268.57,2.64) v9(268.71,0.83) v9(268.93,60.95) v9(268.93,59.68) v9(269.46,62.39) v9(269.76,55.8) v9(269.76,54.53) v9(269.84,2.64) v9(269.96,25.03) v9(269.98,0.83) v9(270.06,60.93) v9(270.06,59.73) v9(270.11,57.91) v9(270.1,33.65) v9(270.25,26.27) v9(270.36,63.29) v9(270.81,54.65) v9(270.81,53.38) v9(271,57.92) v9(271.11,64) v9(271.11,2.64) v9(271.24,32.26) v9(271.3,42.57) v9(271.3,41.3) v9(271.27,26.15) v9(271.25,0.83) v9(271.41,51.24) v9(271.41,49.97) v9(271.38,49.01) v9(271.38,47.74) v9(271.38,46.47) v9(271.38,45.2) v9(271.38,43.93) v9(271.41,39.19) v9(271.41,37.92) v9(271.41,36.65) v9(271.41,35.38) v9(271.41,34.11) v9(271.61,69.78) v9(271.61,68.51) v9(271.6,62.84) v9(271.64,62.23) v9(271.79,63.5) v9(271.88,67.16) v9(271.88,65.89) v9(272.01,64.9) v9(271.99,58.37) v9(271.99,57.1) v9(272.12,71.79) v9(272.12,70.52) v9(272.08,61.72) v9(272.13,59.36) v9(272.08,29.07) v9(272.52,0.83) v9(272.6,63.14) v9(273.43,68.96) v9(273.4,63.45) v9(273.6,71.75) v9(273.6,70.48) v9(273.61,62.79) v9(273.64,62.21) v9(274.44,70.31) v9(274.87,70.92) v9(275.09,26.21) v9(275.24,38.93) v9(275.83,71.44) v9(275.98,69.19) v9(275.95,68.51) v9(276.26,64.26) v9(276.3,57.03) v9(276.59,59.31) v9(276.73,67.66) v9(276.7,53.57) v9(276.7,53.1) v9(276.83,70.44) v9(276.96,67.03) v9(277.06,49.67) v9(277.06,48.4) v9(277.06,47.13) v9(277.06,46.29) v9(277.27,67.54) v9(277.73,72.91) v9(277.89,70.57) v9(278.1,66.76) v9(278.1,65.49) v9(278.26,71.08) v9(278.54,45.5) v9(278.88,69.59) v9(279,74.22) v9(279.03,39.55) v9(279.09,71.75) v9(279.34,65.91) v9(279.52,36.33) v9(279.69,64.86) v9(279.71,38.96) v9(279.69,38.37) v9(279.92,70.51) v9(279.99,72.68) v9(280.16,75.39) v9(280.27,38.42) v9(280.39,35.75) v9(280.46,63.18) v9(280.64,67.16) v9(280.68,76.64) v9(280.8,64.36) v9(281.13,79.46) v9(281.08,67.03) v9(281.17,65.96) v9(281.54,68.99) v9(281.78,30.96) v9(282.54,80.82) v9(282.52,64.31) v9(283.15,45.34) v9(284.14,81.76) v9(284.13,65.94) v9(284.12,63.45) v9(284.83,82.71) v9(285.8,44.3) v9(286.43,63.55) v9(286.9,65.8) v9(288.65,63.47) v9(288.78,65.91) v9(288.89,3.07) v9(289.36,64.72) v9(289.41,4.33) v9(289.41,1.81) v9(289.55,63.14) v9(290.1,66.44) v9(290.67,4.85) v9(290.67,1.29) v9(291.93,4.33) v9(291.93,1.81) v9(292.45,3.07) v10(5.93,47.88) v10(5.93,47.29) v10(5.93,46.71) v10(5.93,45.54) v10(7.15,50.6) v10(7.15,49.33) v10(7.15,48.06) v10(7.15,46.79) v10(7.15,45.52) v10(7.15,44.25) v10(7.15,42.98) v10(7.15,41.71) v10(7.15,40.44) v10(7.15,39.17) v10(7.15,37.9) v10(7.15,36.63) v10(7.15,35.36) v10(7.69,65.42) v10(7.69,59.92) v10(8.05,51.5) v10(8.08,34.5) v10(8.13,24.39) v10(8.69,14.75) v10(8.86,28.93) v10(9.34,65.17) v10(9.34,59.67) v10(9.32,51.5) v10(9.35,34.5) v10(9.68,47.69) v10(10.03,50.37) v10(10.03,49.78) v10(10.29,26.48) v10(10.44,17.14) v10(10.59,51.5) v10(10.62,34.5) v10(10.74,25.02) v10(10.83,27.02) v10(11.31,55.98) v10(11.29,27.54) v10(11.28,25.49) v10(11.55,63.21) v10(11.55,61.81) v10(11.55,60.73) v10(11.59,58.39) v10(11.75,46.92) v10(11.75,46.27) v10(11.75,44.97) v10(11.75,44.32) v10(11.86,51.5) v10(11.89,34.5) v10(12,13.43) v10(12.19,60.58) v10(12.27,13.7) v10(12.4,46.27) v10(12.4,44.97) v10(12.42,37.86) v10(12.73,63.66) v10(12.76,60.58) v10(12.78,26.98) v10(12.85,14.28) v10(13.13,51.5) v10(13.05,46.92) v10(13.1,37.79) v10(13.12,14.55) v10(13.16,34.5) v10(13.43,58.61) v10(13.56,64.05) v10(14.32,58.39) v10(14.4,51.5) v10(14.43,34.5) v10(14.69,14.06) v10(14.97,55.71) v10(14.97,54.47) v10(15.43,64.52) v10(15.4,41.54) v10(15.41,39.03) v10(15.38,37.55) v10(15.59,55.09) v10(15.67,51.5) v10(15.7,34.5) v10(16.14,58.39) v10(16.09,14.28) v10(16.21,55.71) v10(16.21,54.47) v10(16.48,36.8) v10(16.76,53.57) v10(16.81,45.67) v10(16.78,38.84) v10(16.94,51.5) v10(16.88,25.45) v10(16.97,34.5) v10(17.34,57.82) v10(17.75,40.11) v10(18.21,51.5) v10(18.24,34.5) v10(18.54,39.22) v10(18.65,16.84) v10(18.7,23.66) v10(18.97,51.5) v10(19.17,33.73) v10(19.17,32.69) v10(19.17,31.72) v10(19.3,52.5) v10(19.75,16.73) v10(20.01,17) v10(20.09,18.27) v10(20.66,12.23) v10(20.95,12.99) v10(21.9,20.55) v10(23.18,33.63) v10(23.24,32.76) v10(23.21,31.93) v10(23.24,16.48) v10(23.24,15.85) v10(23.26,14.77) v10(23.26,13.88) v10(25.39,11.85) v10(27.97,16.23) v10(27.97,14.26) v10(30.83,9.46) v10(34.11,11.97) v10(34.11,11.09) v10(34.2,13.08) v10(35.28,14.29) v10(36.04,13.87) v10(39.66,12.99) v10(39.91,12.99) v10(40.16,12.99) v10(41.85,15.47) v10(42.85,12.23) v10(44.95,14.64) v10(53.9,12.94) v10(56.31,13.85) v10(57.82,11.95) v10(67.15,12.47) v10(68.61,8.93) v10(68.61,8.55) v10(68.71,11.15) v10(69.31,5.99) v10(69.95,72.36) v10(70.04,73.7) v10(70.04,71.16) v10(70.04,69.89) v10(70.04,68.62) v10(70.04,67.35) v10(70.04,66.08) v10(70.04,64.81) v10(70.04,63.54) v10(70.04,62.27) v10(70.04,61) v10(70.04,59.73) v10(70.04,58.46) v10(70.04,57.19) v10(70.04,55.92) v10(70.04,54.65) v10(70.04,53.38) v10(70.04,52.11) v10(70.04,50.84) v10(70.04,49.57) v10(70.04,48.3) v10(70.04,47.03) v10(70.04,45.76) v10(70.04,44.49) v10(70.04,43.22) v10(70.04,41.95) v10(70.04,40.68) v10(70.04,39.41) v10(70.04,38.14) v10(70.04,36.87) v10(70.04,35.6) v10(70.04,34.33) v10(70.04,33.06) v10(70.04,31.79) v10(70.04,30.52) v10(70.04,29.25) v10(70.04,27.98) v10(70.04,26.71) v10(70.04,25.44) v10(70.04,24.17) v10(70.04,22.9) v10(70.04,21.63) v10(70.04,20.36) v10(70.04,19.09) v10(70.04,17.82) v10(70.04,16.55) v10(70.04,15.28) v10(70.04,14.01) v10(70.04,12.74) v10(70.04,11.47) v10(70.04,10.2) v10(70.3,8.96) v10(70.33,5.97) v10(70.96,72.36) v10(71.2,8.06) v10(72.1,7.16) v10(72.21,73.7) v10(72.23,72.36) v10(72.82,21.03) v10(73,6.27) v10(73.16,76.33) v10(73.16,75.7) v10(73.16,75.06) v10(73.48,73.7) v10(73.5,72.36) v10(73.9,5.37) v10(74.18,76.33) v10(74.18,75.7) v10(74.18,75.06) v10(74.75,73.7) v10(74.77,72.55) v10(74.79,4.47) v10(75.33,77.06) v10(75.34,76.75) v10(75.32,76.33) v10(75.32,75.7) v10(75.32,75.06) v10(75.69,3.57) v10(75.85,23.47) v10(75.97,77.06) v10(75.97,76.75) v10(76.02,73.7) v10(76.04,72.36) v10(76.23,23.47) v10(76.4,76.33) v10(76.4,75.7) v10(76.4,75.06) v10(76.55,15.25) v10(76.55,76.74) v10(76.59,2.67) v10(76.74,18.72) v10(77.06,23.47) v10(77.2,76.04) v10(77.29,73.7) v10(77.31,72.36) v10(77.44,23.47) v10(77.49,1.78) v10(77.73,14.19) v10(77.79,73.7) v10(77.9,10.92) v10(77.9,10.51) v10(77.9,10.08) v10(78.1,74.34) v10(78.33,23.65) v10(78.29,10.92) v10(78.29,10.51) v10(78.29,10.08) v10(78.39,76.05) v10(78.58,72.36) v10(78.67,10.94) v10(78.67,10.54) v10(78.67,10.11) v10(78.76,1.7) v10(79.04,73) v10(79.1,74.41) v10(79.22,23.65) v10(79.63,72.47) v10(79.6,22.2) v10(79.66,76.05) v10(79.93,74.41) v10(80.03,1.7) v10(80.28,72.99) v10(80.69,74.34) v10(80.93,76.05) v10(81.15,73.7) v10(81.3,1.7) v10(81.38,72.39) v10(81.55,12.77) v10(81.63,10.64) v10(81.96,77.03) v10(81.96,76.74) v10(82.13,76.26) v10(82.13,75.63) v10(82.13,74.99) v10(82.29,12.9) v10(82.42,77.03) v10(82.42,76.74) v10(82.37,73.7) v10(82.39,72.36) v10(82.57,1.7) v10(82.94,77.03) v10(82.94,76.74) v10(83.14,76.26) v10(83.14,75.63) v10(83.14,74.99) v10(83.46,77.03) v10(83.46,76.74) v10(83.64,73.7) v10(83.66,72.36) v10(83.84,1.7) v10(83.97,77.03) v10(83.97,76.74) v10(84.28,76.26) v10(84.28,75.63) v10(84.28,74.99) v10(84.48,77.03) v10(84.48,76.74) v10(84.91,73.7) v10(84.93,72.36) v10(84.99,77.03) v10(84.99,76.74) v10(85.11,1.7) v10(85.25,53.93) v10(85.45,76.74) v10(85.36,76.26) v10(85.36,75.63) v10(85.36,74.99) v10(85.51,77.03) v10(86.18,73.7) v10(86.2,72.36) v10(86.28,76.03) v10(86.38,1.7) v10(87.09,5.46) v10(87.17,66.39) v10(87.19,57.72) v10(87.28,76.05) v10(87.45,73.7) v10(87.47,72.36) v10(87.45,8.66) v10(87.65,1.7) v10(87.74,13.82) v10(87.72,12.73) v10(88.04,71.41) v10(88.02,11.71) v10(88.45,72.92) v10(88.55,76.05) v10(88.68,70.52) v10(88.94,71.75) v10(88.92,1.7) v10(89.25,12.75) v10(89.44,70.59) v10(89.82,76.05) v10(89.94,69.42) v10(89.91,5.96) v10(90.19,1.7) v10(91.09,76.05) v10(91.2,69.25) v10(91.46,1.7) v10(91.71,61.7) v10(91.79,59.12) v10(92.25,6.45) v10(92.25,5.43) v10(92.36,76.05) v10(92.47,69.25) v10(92.73,1.7) v10(93.05,48.57) v10(93.63,76.05) v10(93.74,69.25) v10(93.89,65.96) v10(93.95,63.69) v10(93.93,47.92) v10(93.9,43.52) v10(93.99,4.04) v10(94,1.7) v10(94.82,69.92) v10(94.9,76.05) v10(95.08,11.38) v10(95.31,71.09) v10(95.27,1.7) v10(95.81,72.26) v10(96.17,76.05) v10(96.3,73.43) v10(96.38,12.98) v10(96.54,1.7) v10(97.44,76.05) v10(97.54,73.7) v10(97.74,16.14) v10(97.81,1.7) v10(98.71,76.05) v10(98.81,73.7) v10(99.08,1.7) v10(99.98,76.05) v10(100.08,73.7) v10(100.35,1.7) v10(100.6,15.59) v10(100.6,14.71) v10(100.76,41.76) v10(101.35,73.7) v10(101.62,1.7) v10(102.1,76.81) v10(102.1,76.3) v10(102.1,75.79) v10(102.1,75.28) v10(102.61,76.81) v10(102.61,76.3) v10(102.61,75.79) v10(102.61,75.28) v10(102.62,73.7) v10(102.89,1.7) v10(103.12,76.81) v10(103.12,76.3) v10(103.12,75.79) v10(103.12,75.28) v10(103.31,71.18) v10(103.31,70.71) v10(103.63,76.81) v10(103.63,76.3) v10(103.63,75.79) v10(103.63,75.28) v10(103.8,68.55) v10(103.89,73.7) v10(104.14,76.8) v10(104.14,76.29) v10(104.14,75.78) v10(104.14,75.27) v10(104.16,1.7) v10(104.65,76.8) v10(104.65,76.29) v10(104.65,75.78) v10(104.65,75.27) v10(105.16,76.8) v10(105.16,76.29) v10(105.16,75.78) v10(105.16,75.27) v10(105.16,73.7) v10(105.43,1.7) v10(105.67,76.8) v10(105.67,76.29) v10(105.67,75.78) v10(105.67,75.27) v10(106.33,76.05) v10(106.43,73.7) v10(106.7,1.7) v10(106.95,64.34) v10(107.32,71.86) v10(107.7,73.7) v10(107.79,66.88) v10(107.83,64.12) v10(107.83,62.28) v10(107.83,61.67) v10(107.84,59.54) v10(107.84,55.61) v10(107.97,1.7) v10(108.24,65.64) v10(108.24,53.94) v10(108.3,75.35) v10(108.29,50.84) v10(108.39,66.89) v10(108.43,56.83) v10(108.41,55.62) v10(108.97,73.7) v10(109.24,1.7) v10(110.24,73.7) v10(110.27,75.03) v10(110.42,56.01) v10(110.51,1.7) v10(111.22,56.66) v10(111.51,73.7) v10(111.83,23.67) v10(111.83,23.07) v10(111.78,1.7) v10(112.02,59.91) v10(112.53,18.71) v10(112.78,73.7) v10(112.82,60.56) v10(112.87,75.92) v10(113.05,1.7) v10(113.76,76.23) v10(113.76,75.19) v10(114.05,73.7) v10(114.08,51.75) v10(114.27,71.13) v10(114.32,1.7) v10(114.65,51.75) v10(114.8,76.23) v10(114.8,75.19) v10(115.03,71.49) v10(115.22,52.07) v10(115.32,73.7) v10(115.59,1.7) v10(115.84,76.23) v10(115.84,75.19) v10(115.98,51.65) v10(116.59,73.7) v10(116.82,62.51) v10(116.82,56.66) v10(116.89,76.23) v10(116.89,75.19) v10(116.86,1.7) v10(117.62,56.01) v10(117.86,73.7) v10(118.13,1.7) v10(118.42,66.41) v10(118.42,62.51) v10(118.97,75.6) v10(119.13,73.7) v10(119.22,65.76) v10(119.22,57.31) v10(119.22,56.01) v10(119.4,1.7) v10(120.24,75.6) v10(120.4,73.7) v10(120.67,1.7) v10(121.29,63.08) v10(121.28,61.07) v10(121.38,67.26) v10(121.38,65.47) v10(121.44,57.3) v10(121.51,75.6) v10(121.64,69.86) v10(121.67,73.7) v10(121.66,54.02) v10(121.83,59.03) v10(121.94,1.7) v10(122.07,65.45) v10(122.3,64.11) v10(122.32,24.61) v10(122.35,23.87) v10(122.74,66.14) v10(122.69,58.65) v10(122.78,75.6) v10(122.94,73.7) v10(123.21,1.7) v10(123.29,62.44) v10(123.29,60.67) v10(123.29,57.3) v10(123.29,56.72) v10(123.29,51.98) v10(123.58,41.38) v10(123.9,51.98) v10(124.18,75.6) v10(124.21,73.7) v10(124.48,1.7) v10(125.28,57.31) v10(125.45,75.6) v10(125.48,73.7) v10(125.75,1.7) v10(126.02,52) v10(126.04,47.48) v10(126.04,46.18) v10(126.04,45.52) v10(126.04,25.3) v10(126.08,56.66) v10(126.39,40.25) v10(126.36,31.69) v10(126.36,29.21) v10(126.5,47.94) v10(126.52,20.57) v10(126.59,52) v10(126.72,75.6) v10(126.66,47.31) v10(126.75,73.7) v10(126.88,67.06) v10(127.04,40.25) v10(127.01,31.69) v10(127.01,30.45) v10(127.01,29.21) v10(127.02,1.7) v10(127.15,47.94) v10(127.16,52) v10(127.31,47.3) v10(127.73,52) v10(127.66,30.45) v10(127.8,47.94) v10(127.91,45.42) v10(127.99,75.6) v10(128.02,73.7) v10(128,29.21) v10(128,26.74) v10(128.31,40.25) v10(128.29,1.7) v10(128.42,52) v10(128.48,56.01) v10(129.09,47.94) v10(129.05,25.18) v10(129.18,71.03) v10(129.29,73.7) v10(129.26,51.46) v10(129.56,1.7) v10(129.7,75.6) v10(129.76,47.61) v10(129.76,45.66) v10(130.02,71.47) v10(130.33,21.52) v10(130.56,73.7) v10(130.83,1.7) v10(130.88,58.61) v10(130.88,57.31) v10(130.88,56.01) v10(130.88,54.71) v10(130.91,21.52) v10(130.97,75.6) v10(131.07,46.93) v10(131.13,18.09) v10(131.11,14.83) v10(131.53,26.17) v10(131.53,25.18) v10(131.68,62.51) v10(131.68,56.66) v10(131.67,50.68) v10(131.83,73.7) v10(132.1,1.7) v10(132.24,75.6) v10(132.38,47.61) v10(132.37,45.66) v10(132.48,63.16) v10(132.62,52.17) v10(132.6,27.7) v10(132.68,21.52) v10(133.1,73.7) v10(133.37,1.7) v10(133.51,75.6) v10(133.65,46.93) v10(133.8,44.91) v10(134,25.18) v10(134.08,64.46) v10(134.08,59.91) v10(134.08,58.61) v10(134.08,21.52) v10(134.21,50.52) v10(134.34,50.27) v10(134.37,73.7) v10(134.64,1.7) v10(134.71,29.48) v10(134.9,47.61) v10(134.97,21.11) v10(135.29,24.8) v10(135.54,73.7) v10(135.86,21.11) v10(135.91,1.7) v10(136.11,64.29) v10(136.11,52.21) v10(136.16,57.39) v10(136.18,56.78) v10(136.17,46.93) v10(136.15,45.66) v10(136.19,14.45) v10(136.47,66.32) v10(136.55,26.88) v10(136.48,25.18) v10(136.75,52.21) v10(136.75,50.52) v10(136.81,73.7) v10(136.88,63.9) v10(136.93,61.72) v10(136.93,61.09) v10(136.94,56.98) v10(136.88,50.27) v10(137.18,1.7) v10(137.41,47.61) v10(137.72,18.29) v10(138.08,73.7) v10(138.27,52.21) v10(138.37,26.88) v10(138.45,1.7) v10(138.66,46.93) v10(138.91,52.21) v10(138.95,26.17) v10(138.95,25.18) v10(138.95,24.53) v10(139.21,62.08) v10(139.21,58.77) v10(139.29,29.11) v10(139.29,28.18) v10(139.63,65) v10(139.63,62.97) v10(139.63,60.55) v10(139.63,57.89) v10(139.73,73.52) v10(139.75,41.85) v10(139.69,24.85) v10(139.7,1.7) v10(139.78,74.03) v10(139.91,47.61) v10(139.95,21.12) v10(140.22,74.4) v10(140.24,73.02) v10(140.18,50.27) v10(140.2,25.58) v10(140.3,50.52) v10(140.34,24.85) v10(140.77,73.01) v10(140.86,74.43) v10(140.87,21.12) v10(141.12,26.88) v10(141.16,46.93) v10(141.38,73.01) v10(141.54,74.45) v10(141.69,6.47) v10(141.84,21.12) v10(141.99,73.01) v10(141.99,50.39) v10(142.04,26.88) v10(142.29,24.85) v10(142.41,47.61) v10(142.41,45.66) v10(142.48,74.38) v10(142.54,52.42) v10(142.56,74.88) v10(142.59,73.07) v10(142.93,73.4) v10(142.95,29.11) v10(142.95,28.18) v10(142.95,27.53) v10(142.95,25.58) v10(142.94,24.2) v10(142.96,73.99) v10(143.23,66.41) v10(143.35,73.7) v10(143.4,1.7) v10(143.47,74.93) v10(143.66,46.93) v10(143.66,45.66) v10(143.87,27.53) v10(144.03,63.16) v10(144.03,52.55) v10(144.34,75.78) v10(144.27,50.39) v10(144.32,41.85) v10(144.67,1.7) v10(144.91,47.61) v10(145.35,76.43) v10(145.42,51.54) v10(145.63,75.25) v10(145.69,25.58) v10(145.88,77.37) v10(145.94,1.7) v10(146.16,46.93) v10(146.46,74.61) v10(146.45,50.39) v10(146.97,77.79) v10(147.21,1.7) v10(147.41,47.61) v10(147.41,45.66) v10(147.53,44.91) v10(147.7,74.52) v10(147.67,50.77) v10(147.8,15.59) v10(148.03,56.01) v10(148.14,24.85) v10(148.14,24.2) v10(148.24,77.79) v10(148.48,1.7) v10(148.66,46.93) v10(148.83,62.51) v10(148.83,60.56) v10(148.83,56.66) v10(148.97,74.52) v10(149.15,50.39) v10(149.15,20.07) v10(149.36,27.53) v10(149.51,77.79) v10(149.63,63.16) v10(149.74,52.42) v10(149.72,1.7) v10(149.77,73.71) v10(149.92,47.61) v10(149.92,45.66) v10(150.13,74.31) v10(150.13,73.09) v10(150.09,24.85) v10(150.09,24.2) v10(150.21,50.56) v10(150.21,20.76) v10(150.27,44.91) v10(150.27,43.61) v10(150.27,27.53) v10(150.27,25.58) v10(150.35,14.25) v10(150.43,74.57) v10(150.46,52.34) v10(150.74,73) v10(150.78,77.6) v10(150.85,50.56) v10(150.92,74.41) v10(151.1,52.34) v10(151.1,20.61) v10(151.17,46.93) v10(151.17,45.66) v10(151.19,27.53) v10(151.19,26.88) v10(151.19,25.58) v10(151.33,75.18) v10(151.38,80.62) v10(151.38,79.35) v10(151.38,78.08) v10(151.38,77.06) v10(151.42,73) v10(151.54,74.99) v10(151.65,76.17) v10(151.59,74.42) v10(151.99,52.34) v10(152.08,73) v10(152.1,27.53) v10(152.1,25.58) v10(152.19,74.41) v10(152.24,20.98) v10(152.42,47.61) v10(152.65,80.62) v10(152.65,79.35) v10(152.65,78.08) v10(152.65,76.81) v10(152.65,75.54) v10(152.62,52.34) v10(152.7,74.32) v10(152.67,73.11) v10(153.03,73.7) v10(153.02,25.58) v10(153.13,20.98) v10(153.35,66.19) v10(153.35,59.6) v10(153.35,59.03) v10(153.26,53.73) v10(153.54,73.68) v10(153.64,62.63) v10(153.64,61.64) v10(153.64,54.63) v10(153.67,46.93) v10(153.68,45.68) v10(153.69,1.7) v10(153.87,77.88) v10(153.92,76.81) v10(153.92,75.54) v10(153.92,65.58) v10(153.93,64.93) v10(153.93,57.82) v10(153.93,57) v10(153.93,56.36) v10(153.93,25.58) v10(154.02,53.73) v10(153.99,24.85) v10(153.99,24.2) v10(154.12,83.82) v10(154.11,22.07) v10(154.11,21.44) v10(154.11,20.8) v10(154.17,81.94) v10(154.39,41.85) v10(154.69,73.7) v10(154.85,27.53) v10(154.85,26.88) v10(154.85,26.23) v10(154.85,25.58) v10(154.92,47.61) v10(154.88,19.66) v10(154.91,18.87) v10(154.96,1.7) v10(155.19,78.08) v10(155.19,76.81) v10(155.19,75.54) v10(155.16,52.04) v10(155.29,52.42) v10(155.6,84.67) v10(155.66,81.01) v10(155.76,42.31) v10(155.76,25.58) v10(155.96,73.7) v10(156.01,59.91) v10(155.96,22.07) v10(155.96,21.44) v10(155.96,20.8) v10(156.06,19.63) v10(156.17,46.93) v10(156.17,45.66) v10(156.22,41.85) v10(156.23,1.7) v10(156.43,52.42) v10(156.46,80.57) v10(156.46,79.35) v10(156.46,78.08) v10(156.46,76.81) v10(156.46,75.54) v10(156.55,25.18) v10(156.65,22.07) v10(156.65,21.44) v10(156.65,20.8) v10(156.69,52.3) v10(156.81,62.51) v10(156.81,60.56) v10(156.81,56.66) v10(156.85,16.09) v10(157.23,73.7) v10(157.42,47.61) v10(157.51,52.14) v10(157.5,1.7) v10(157.64,80.62) v10(157.61,58.61) v10(157.61,56.01) v10(157.73,79.35) v10(157.73,78.08) v10(157.73,76.81) v10(157.73,75.54) v10(157.83,27.18) v10(158.34,50.68) v10(158.41,60.56) v10(158.4,52) v10(158.5,73.7) v10(158.51,44.91) v10(158.51,28.18) v10(158.67,46.93) v10(158.67,45.66) v10(158.85,80.81) v10(158.77,1.7) v10(159,79.35) v10(159,78.08) v10(158.97,50.68) v10(159.02,26.17) v10(159.02,25.18) v10(159.42,28.18) v10(159.61,50.68) v10(159.67,44.26) v10(159.77,73.7) v10(159.78,52.6) v10(159.92,47.61) v10(160.04,1.7) v10(160.07,52.42) v10(160.08,25.51) v10(160.24,50.68) v10(160.31,79.35) v10(160.34,28.18) v10(160.37,78.01) v10(160.37,26.51) v10(160.55,47.94) v10(160.87,28.17) v10(161.04,73.7) v10(161.17,46.93) v10(161.25,28.18) v10(161.31,1.7) v10(161.44,27.21) v10(161.5,41.66) v10(161.5,26.17) v10(161.5,25.18) v10(161.61,57.31) v10(161.61,56.01) v10(161.6,52.04) v10(161.96,20.12) v10(162.17,28.18) v10(162.18,21.92) v10(162.18,20.99) v10(162.24,19.66) v10(162.23,19.08) v10(162.31,73.7) v10(162.41,56.66) v10(162.43,47.61) v10(162.43,45.66) v10(162.42,39.44) v10(162.49,79.77) v10(162.53,23.03) v10(162.64,77.53) v10(162.58,1.7) v10(163.21,56.01) v10(163.33,44.26) v10(163.42,50.68) v10(163.48,25.82) v10(163.49,24.54) v10(163.58,73.7) v10(163.68,47.58) v10(163.68,46.93) v10(163.68,45.66) v10(163.85,1.7) v10(163.94,52.42) v10(164.01,66.41) v10(163.97,26.17) v10(164,25.78) v10(163.97,25.18) v10(164.05,13.09) v10(164.1,79.77) v10(164.05,50.68) v10(164.25,40.36) v10(164.71,77.52) v10(164.82,56.01) v10(164.85,73.7) v10(164.93,47.61) v10(164.91,28.18) v10(165.01,79.67) v10(165.12,1.7) v10(165.37,28.64) v10(165.39,24.11) v10(165.5,24.6) v10(165.75,82) v10(166.12,73.7) v10(166.18,47.58) v10(166.18,46.93) v10(166.23,25.5) v10(166.35,77.52) v10(166.38,75.75) v10(166.44,25.18) v10(166.41,20.04) v10(166.42,19.48) v10(166.39,1.7) v10(166.48,21.94) v10(166.54,21.16) v10(166.45,20.64) v10(166.8,47.94) v10(166.99,44.26) v10(166.99,41.66) v10(167.29,50.68) v10(167.39,73.7) v10(167.43,45.66) v10(167.43,38.06) v10(167.43,30.59) v10(167.58,65.63) v10(167.65,63.98) v10(167.65,62.77) v10(167.65,62.2) v10(167.65,61.57) v10(167.65,60.93) v10(167.58,54.96) v10(167.58,54.33) v10(167.74,81.01) v10(167.66,28.83) v10(167.66,1.7) v10(167.81,84.67) v10(167.81,59.73) v10(167.83,27.86) v10(167.91,42.96) v10(167.88,26.18) v10(168,64.74) v10(168.08,37.23) v10(168.08,30.59) v10(168.18,65.59) v10(168.55,75.78) v10(168.59,82.37) v10(168.59,79.83) v10(168.59,78.56) v10(168.59,77.29) v10(168.57,28.83) v10(168.57,26.88) v10(168.66,73.7) v10(168.73,34.74) v10(168.73,31.42) v10(168.73,30.59) v10(168.73,29.76) v10(168.84,81.64) v10(168.76,27.85) v10(168.89,84.01) v10(168.93,1.7) v10(169.23,81.94) v10(169.38,44.21) v10(169.38,34.14) v10(169.93,73.7) v10(170.02,44.68) v10(170.03,27.74) v10(170.16,25.83) v10(170.16,25.18) v10(170.24,20.23) v10(170.24,18.26) v10(170.2,1.7) v10(170.28,21.52) v10(170.32,11.72) v10(170.37,13.85) v10(170.49,16.23) v10(170.58,46.63) v10(170.68,45.12) v10(170.68,28.65) v10(170.75,15.22) v10(170.75,14.92) v10(170.75,14.61) v10(170.91,21.52) v10(171.08,61.7) v10(171.14,46.96) v10(171.2,73.7) v10(171.33,44.21) v10(171.33,35.97) v10(171.33,31.4) v10(171.47,1.7) v10(171.67,45.32) v10(171.77,55.79) v10(172.03,45.98) v10(172.31,70.8) v10(172.39,59.44) v10(172.36,47.94) v10(172.47,73.7) v10(172.74,1.7) v10(172.81,44.43) v10(172.81,41.81) v10(172.81,39.19) v10(172.81,36.57) v10(172.81,33.95) v10(172.81,31.33) v10(172.81,28.71) v10(172.81,26.76) v10(172.88,64.69) v10(173,47.94) v10(173,24.2) v10(173.45,64.69) v10(173.45,61.23) v10(173.51,52.84) v10(173.51,50.99) v10(173.49,47.31) v10(173.48,46.64) v10(173.49,24.83) v10(173.74,73.7) v10(173.71,58.05) v10(173.71,54.93) v10(173.71,54.24) v10(173.65,47.94) v10(173.65,24.2) v10(173.79,41.81) v10(173.79,36.57) v10(173.96,17.25) v10(174.01,1.7) v10(174.15,52.84) v10(174.14,47.31) v10(174.12,45.1) v10(174.11,28.05) v10(174.23,50.99) v10(174.16,20.56) v10(174.3,47.94) v10(174.3,24.2) v10(174.44,36.57) v10(174.47,71.16) v10(174.72,52.84) v10(174.8,50.99) v10(174.76,47.48) v10(174.76,46.17) v10(174.77,45.1) v10(174.94,71.86) v10(175.01,73.7) v10(175.29,52.84) v10(175.28,1.7) v10(175.36,71.16) v10(175.37,50.99) v10(175.48,20.84) v10(175.86,52.84) v10(176.28,73.7) v10(176.44,52.84) v10(176.51,50.99) v10(176.55,1.7) v10(176.77,42.19) v10(176.82,38.9) v10(177.08,50.99) v10(177.35,41.5) v10(177.35,16.93) v10(177.38,39.61) v10(177.39,38.9) v10(177.43,37.57) v10(177.43,35.85) v10(177.43,35.28) v10(177.55,73.7) v10(177.82,1.7) v10(177.93,42.77) v10(177.93,42.14) v10(177.96,47.84) v10(178.25,51.54) v10(178.34,19.93) v10(178.51,50.39) v10(178.57,26.9) v10(178.57,26.27) v10(178.57,25.63) v10(178.7,73.16) v10(178.7,71.89) v10(178.7,70.62) v10(178.7,69.35) v10(178.7,68.08) v10(178.7,66.81) v10(178.7,65.54) v10(178.7,64.27) v10(178.7,63) v10(178.7,61.73) v10(178.7,60.46) v10(178.7,59.19) v10(178.7,57.92) v10(178.7,56.65) v10(178.72,48.17) v10(178.75,39.6) v10(178.96,55.47) v10(179.04,46.05) v10(179.09,1.7) v10(179.79,19.72) v10(180.01,39.83) v10(180.23,18.26) v10(180.42,60.37) v10(180.42,58.87) v10(180.36,1.7) v10(180.52,55.5) v10(180.53,29.7) v10(180.65,39.85) v10(180.75,36.93) v10(180.92,37.23) v10(180.98,43.34) v10(181.13,14.63) v10(181.63,31.1) v10(181.63,1.7) v10(181.79,55.5) v10(182.28,18.88) v10(182.53,38.42) v10(182.71,42.09) v10(182.9,1.7) v10(183.06,55.5) v10(183.53,35.79) v10(183.6,42.82) v10(184.09,74.76) v10(184.09,73.88) v10(184.17,1.7) v10(184.33,55.5) v10(184.64,39.96) v10(184.77,36.64) v10(184.75,32.64) v10(185.01,6.89) v10(185.01,6.32) v10(185.35,32.36) v10(185.44,1.7) v10(185.6,55.5) v10(185.83,28.14) v10(186.09,6.89) v10(186.09,6.32) v10(186.62,29.42) v10(186.71,1.7) v10(186.87,55.5) v10(186.9,28.18) v10(187.68,73.88) v10(187.98,1.7) v10(188.14,55.5) v10(188.09,43.79) v10(188.09,42.07) v10(188.09,41.5) v10(188.18,14.07) v10(188.44,10.98) v10(188.5,26.88) v10(188.56,53.73) v10(188.93,15.17) v10(189.22,34.6) v10(189.25,1.7) v10(189.3,53.31) v10(189.39,60.88) v10(189.39,60.37) v10(189.41,55.5) v10(189.45,31.77) v10(189.45,31.13) v10(189.62,57.72) v10(189.87,67.37) v10(189.9,14.63) v10(190.34,51.19) v10(190.34,46.67) v10(190.52,1.7) v10(190.68,55.5) v10(191.53,53.56) v10(191.62,68.87) v10(191.62,67.37) v10(191.62,64.37) v10(191.79,1.7) v10(191.95,55.5) v10(193.1,68.74) v10(193.1,67.47) v10(193.1,66.2) v10(193.1,64.93) v10(193.1,63.66) v10(193.1,62.39) v10(193.1,61.12) v10(193.1,59.85) v10(193.1,58.58) v10(193.1,57.31) v10(193.1,56.04) v10(193.06,1.7) v10(193.9,31.67) v10(194.33,1.7) v10(195.24,57.96) v10(195.17,18.52) v10(195.17,17.31) v10(195.53,69.25) v10(195.5,44.47) v10(195.5,39.67) v10(195.6,1.7) v10(195.8,25.84) v10(196.3,44.47) v10(196.3,42.87) v10(196.3,39.67) v10(196.3,33.27) v10(196.53,27.28) v10(196.77,59.03) v10(196.82,24.93) v10(196.87,1.7) v10(197.1,44.47) v10(197.1,42.87) v10(197.1,41.27) v10(197.1,39.67) v10(197.1,38.07) v10(197.1,36.47) v10(197.1,33.27) v10(197.9,45.27) v10(197.9,43.67) v10(197.9,33.27) v10(198.09,24.93) v10(198.14,1.7) v10(198.52,60.74) v10(198.7,44.47) v10(199.3,54.34) v10(199.41,1.7) v10(199.73,27.28) v10(199.78,13.44) v10(200.3,38.87) v10(200.68,1.7) v10(201.1,38.87) v10(201.18,66.27) v10(201.19,62.08) v10(201.2,15.94) v10(201.33,19.72) v10(201.65,63.09) v10(201.84,59.49) v10(201.84,56.79) v10(201.84,19.47) v10(201.9,45.27) v10(201.9,44.47) v10(201.9,33.27) v10(201.9,32.47) v10(201.94,27.27) v10(201.95,1.7) v10(201.96,19.72) v10(202.09,19.47) v10(202.22,19.72) v10(202.79,9.71) v10(202.92,56.93) v10(203.04,63.5) v10(203.22,1.7) v10(203.42,10.3) v10(203.5,32.47) v10(203.55,15.92) v10(203.99,12.74) v10(204.31,60.72) v10(204.3,44.47) v10(204.3,42.87) v10(204.3,41.27) v10(204.3,39.67) v10(204.3,38.07) v10(204.3,36.47) v10(204.3,34.87) v10(204.3,33.27) v10(204.3,31.67) v10(204.39,58.27) v10(204.44,15.92) v10(204.49,1.7) v10(204.95,60.72) v10(204.99,65.51) v10(205.1,46.07) v10(205.1,44.47) v10(205.1,42.87) v10(205.1,41.27) v10(205.1,39.67) v10(205.1,38.07) v10(205.1,36.47) v10(205.1,34.87) v10(205.1,33.27) v10(205.1,31.67) v10(205.77,53.53) v10(205.76,1.7) v10(206.89,26.52) v10(207.03,1.7) v10(208.3,1.7) v10(208.54,14.71) v10(208.58,69.06) v10(208.87,9.58) v10(209.5,64.36) v10(209.5,60.36) v10(209.65,53.24) v10(209.65,51.46) v10(209.57,1.7) v10(209.67,10.88) v10(210.13,22.36) v10(210.41,53.53) v10(210.83,32.99) v10(210.84,1.7) v10(210.85,17.99) v10(211.04,53.53) v10(211.1,62.76) v10(211.08,29.5) v10(211.44,48.89) v10(211.68,53.53) v10(211.92,51.4) v10(212.06,26.1) v10(212.11,1.7) v10(212.31,53.53) v10(212.78,20.12) v10(212.87,27.41) v10(213.04,30.33) v10(213.38,1.7) v10(213.67,20.11) v10(213.97,9.58) v10(214.6,43.95) v10(214.65,1.7) v10(214.74,50.4) v10(214.71,17.6) v10(215.33,10.63) v10(215.57,10.8) v10(215.81,9.04) v10(215.92,1.7) v10(216.25,44.3) v10(216.28,7.4) v10(217,45.4) v10(217.09,46.52) v10(217.19,1.7) v10(217.53,50.2) v10(217.96,2.58) v10(218.29,48.93) v10(218.73,3.39) v10(219.43,51.28) v10(219.49,61.61) v10(219.46,50.52) v10(219.63,4.29) v10(219.78,52.42) v10(219.88,60.04) v10(220.53,5.18) v10(221.43,6.08) v10(222.28,6.96) v10(222.79,68.86) v10(222.79,67.59) v10(222.79,66.32) v10(222.79,65.05) v10(222.79,63.78) v10(222.79,62.51) v10(222.79,61.24) v10(222.79,59.97) v10(222.79,58.7) v10(222.79,57.43) v10(222.79,56.16) v10(222.79,54.89) v10(222.79,53.62) v10(222.79,52.35) v10(222.79,51.08) v10(222.79,49.81) v10(222.79,48.54) v10(222.79,47.27) v10(222.79,46) v10(222.79,44.73) v10(222.79,43.46) v10(222.79,38.38) v10(222.79,37.11) v10(222.79,35.84) v10(222.79,34.57) v10(222.79,33.3) v10(222.79,32.03) v10(222.79,30.76) v10(222.79,29.49) v10(222.79,28.22) v10(222.79,26.95) v10(222.79,25.68) v10(222.79,24.41) v10(222.79,23.14) v10(222.79,21.87) v10(222.79,20.6) v10(222.79,19.33) v10(222.79,18.06) v10(222.79,16.79) v10(222.79,15.52) v10(222.79,14.25) v10(222.79,12.98) v10(222.79,11.71) v10(222.79,10.44) v10(222.79,9.17) v10(222.79,7.9) v10(225.78,12.29) v10(226.7,8.82) v10(228.3,16.11) v10(228.3,12.28) v10(229.08,10.41) v10(231.25,16.11) v10(231.25,12.28) v10(233.3,8.81) v10(235.49,10.96) v10(236.42,15.09) v10(236.43,5.45) v10(239.24,17.91) v10(239.88,18.9) v10(240.34,17.16) v10(240.66,18.74) v10(250.38,13.82) v10(253.33,15.72) v10(256.38,11.36) v10(268.56,11.61) v10(269.2,11.61) v10(269.83,11.61) v10(270.47,11.61) v10(271.74,17.31) v10(272.12,69.12) v10(272.05,14.21) v10(272.27,57.75) v10(272.27,56.5) v10(272.82,17.22) v10(272.89,57.12) v10(272.9,43.4) v10(272.9,42.13) v10(272.9,40.86) v10(272.9,39.59) v10(272.9,38.32) v10(272.9,37.05) v10(272.9,35.78) v10(272.9,34.51) v10(272.9,33.24) v10(272.9,31.97) v10(272.9,30.7) v10(272.9,29.43) v10(272.9,28.16) v10(272.9,26.89) v10(272.9,25.62) v10(272.9,24.35) v10(272.9,23.08) v10(272.9,21.81) v10(272.9,20.54) v10(273.29,13.36) v10(273.39,64.53) v10(273.51,57.75) v10(273.51,56.5) v10(273.45,53.38) v10(273.45,52.49) v10(273.58,69.12) v10(274.16,20.4) v10(274.33,17.11) v10(274.35,64.49) v10(274.5,41.06) v10(274.63,34.75) v10(274.63,34.17) v10(274.63,32.46) v10(274.62,17.11) v10(274.66,12.73) v10(274.83,43.4) v10(274.76,37.06) v10(274.76,36.49) v10(274.92,64.87) v10(274.92,63.92) v10(274.94,62.98) v10(274.99,58.27) v10(275.04,12.73) v10(275.43,20.4) v10(275.41,14.7) v10(275.41,13.68) v10(275.55,16.98) v10(275.56,64.49) v10(275.9,68.43) v10(275.9,67.85) v10(275.86,12.73) v10(276.1,43.4) v10(276.24,12.73) v10(276.26,7.81) v10(276.49,64.53) v10(276.63,47.35) v10(276.7,20.4) v10(277.37,43.4) v10(277.36,23.34) v10(277.97,20.4) v10(278.4,22.2) v10(278.54,8.55) v10(278.64,43.4) v10(278.7,22.96) v10(279.24,20.4) v10(279.29,19.18) v10(279.91,43.4) v10(280.27,38.34) v10(280.51,20.4) v10(281.18,43.4) v10(281.27,30.87) v10(281.44,22.96) v10(281.73,22.2) v10(281.78,20.4) v10(282.04,31.29) v10(282.45,43.4) v10(282.35,6.81) v10(282.47,19.18) v10(283.05,20.4) v10(283.1,19.18) v10(283.31,6.64) v10(283.46,76.73) v10(283.46,71.23) v10(283.72,43.4) v10(283.74,19.18) v10(284.23,28.68) v10(284.32,20.4) v10(284.37,19.18) v10(284.99,43.4) v10(285.02,17.63) v10(285.02,17.25) v10(285.12,76.48) v10(285.12,70.98) v10(285.16,37.31) v10(285.27,10.6) v10(285.53,30.8) v10(285.59,20.4) v10(286.04,10.51) v10(286.26,43.4) v10(286.86,20.4) v10(286.95,16.42) v10(287.53,43.4) v10(287.54,19.28) v10(287.59,14.44) v10(287.83,36.68) v10(288.13,20.4) v10(288.8,43.4) v10(289.4,20.4) v10(290.07,43.4) v10(290.67,20.4) v10(291.3,43.09) v10(291.3,41.82) v10(291.3,40.55) v10(291.3,39.28) v10(291.3,38.01) v10(291.3,36.74) v10(291.3,35.47) v10(291.3,34.2) v10(291.3,32.93) v10(291.3,31.66) v10(291.3,30.39) v10(291.3,29.12) v10(291.3,27.85) v10(291.3,26.58) v10(291.3,25.31) v10(291.3,24.04) v10(291.3,22.77) v10(291.3,21.5) v11(0.88,57.3) v11(3.06,75.88) v11(3.08,45.64) v11(3.21,48.28) v11(3.28,47.03) v11(4.33,48.97) v11(4.31,44.7) v11(4.35,45.64) v11(4.48,48.28) v11(4.55,47.03) v11(4.69,68.74) v11(5.4,70.38) v11(5.43,57.45) v11(5.65,43.51) v11(5.75,48.28) v11(5.75,42.09) v11(5.82,47.03) v11(5.79,40.36) v11(5.86,49.31) v11(6.14,68.74) v11(6.67,70.38) v11(6.78,44.35) v11(6.94,42.96) v11(6.87,39.1) v11(7.13,49.31) v11(7.23,68.74) v11(7.32,59.88) v11(7.42,63.66) v11(7.37,61.91) v11(7.46,65.37) v11(7.94,70.38) v11(8.2,40.35) v11(8.34,53.58) v11(8.39,51.03) v11(8.4,49.31) v11(8.5,68.74) v11(8.5,38.21) v11(8.45,34.59) v11(8.5,31.71) v11(8.59,32.57) v11(9.43,49.92) v11(9.47,36.07) v11(9.66,51.03) v11(9.7,32.36) v11(9.96,35.18) v11(10.21,51.74) v11(10.24,36.4) v11(10.47,45.57) v11(10.47,44.93) v11(10.47,44.3) v11(10.69,67.85) v11(10.66,52.41) v11(10.7,49.92) v11(10.73,46.49) v11(10.93,51.03) v11(11,35.21) v11(11.18,55.98) v11(11.42,32.14) v11(11.48,51.74) v11(11.63,35.42) v11(11.7,34.75) v11(11.78,46.24) v11(11.87,46.84) v11(11.87,44.3) v11(11.93,29.53) v11(11.97,49.92) v11(12.15,54.47) v11(12.2,51.03) v11(12.24,33.87) v11(12.42,46.24) v11(12.45,55.98) v11(12.63,57.71) v11(12.75,51.74) v11(12.92,52.41) v11(12.97,34.75) v11(13.05,46.87) v11(13.05,43.62) v11(13.24,49.92) v11(13.2,29.53) v11(13.3,67.07) v11(13.42,54.47) v11(13.47,51.03) v11(13.51,33.87) v11(13.62,46.87) v11(13.6,45.69) v11(13.56,36.32) v11(13.72,55.98) v11(13.75,41.58) v11(13.88,42.73) v11(13.89,31.24) v11(13.88,24.04) v11(14.02,51.74) v11(14.08,32.85) v11(14.12,6.52) v11(14.19,52.41) v11(14.23,37.4) v11(14.24,34.75) v11(14.15,5.64) v11(14.52,57.69) v11(14.51,49.92) v11(14.47,32.26) v11(14.47,29.53) v11(14.69,54.47) v11(14.74,51.03) v11(14.73,28.19) v11(14.78,33.87) v11(14.87,66.88) v11(14.99,55.98) v11(14.97,36.13) v11(15.12,45.82) v11(15.13,42.24) v11(15.16,31.24) v11(15.35,32.85) v11(15.53,61.33) v11(15.46,52.41) v11(15.51,34.75) v11(15.74,32.26) v11(15.74,29.53) v11(15.76,63) v11(15.79,57.69) v11(15.78,37.17) v11(15.95,43.31) v11(16.05,59.88) v11(15.96,54.47) v11(16.05,33.87) v11(16.14,64.18) v11(16.2,36.26) v11(16.26,55.98) v11(16.25,21.88) v11(16.43,31.24) v11(16.62,42.56) v11(16.62,32.85) v11(16.73,52.41) v11(16.8,61.33) v11(16.78,34.75) v11(17.03,63) v11(17.01,32.26) v11(17.01,29.53) v11(17.06,57.69) v11(17.23,54.47) v11(17.15,46.96) v11(17.15,45.06) v11(17.3,65.69) v11(17.32,59.88) v11(17.32,33.87) v11(17.41,64.18) v11(17.53,55.98) v11(17.65,39.22) v11(17.65,37.62) v11(18.07,61.33) v11(18.3,63) v11(18.33,57.69) v11(18.26,39.64) v11(18.28,29.53) v11(18.36,51.43) v11(18.36,50.16) v11(18.36,48.89) v11(18.36,47.62) v11(18.36,46.35) v11(18.36,45.08) v11(18.36,43.81) v11(18.36,42.54) v11(18.36,41.27) v11(18.59,59.88) v11(18.78,52.46) v11(18.92,39.22) v11(18.92,37.62) v11(19.17,50.99) v11(19.17,49.72) v11(19.17,48.45) v11(19.17,47.18) v11(19.17,45.91) v11(19.17,44.64) v11(19.17,43.37) v11(19.17,42.1) v11(19.17,40.83) v11(19.16,35.44) v11(19.18,33.39) v11(19.18,31.24) v11(19.34,61.33) v11(19.6,57.69) v11(19.84,55.32) v11(19.86,59.88) v11(20.47,62.51) v11(20.61,61.33) v11(20.82,56.37) v11(20.82,54.14) v11(21.13,59.88) v11(21.85,57.1) v11(22.03,60.43) v11(22,58.6) v11(35.28,15.71) v11(93.39,62.65) v11(93.39,61.38) v11(93.39,60.11) v11(93.39,58.84) v11(93.76,63.46) v11(94.11,62.63) v11(94.11,61.36) v11(94.11,60.09) v11(94.11,58.82) v11(94.65,39.46) v11(94.65,38.19) v11(94.65,36.92) v11(94.65,35.65) v11(94.65,34.38) v11(94.65,33.11) v11(95.78,38.95) v11(95.78,37.68) v11(95.75,36.43) v11(95.75,35.16) v11(95.77,33.11) v11(95.77,31.84) v11(96.11,41.84) v11(96.11,40.57) v11(96.77,39.71) v11(96.77,38.44) v11(96.79,37.16) v11(96.79,35.89) v11(96.79,34.62) v11(96.79,33.35) v11(96.79,32.08) v11(96.79,30.81) v11(97.15,42.67) v11(97.15,41.4) v11(97.49,52.79) v11(98.6,42.71) v11(98.6,41.44) v11(98.66,37.92) v11(98.66,36.65) v11(98.66,35.38) v11(98.66,34.11) v11(98.66,32.84) v11(98.66,31.57) v11(99.31,28.75) v11(99.96,42.7) v11(99.96,41.43) v11(99.96,35.53) v11(99.96,34.26) v11(100.91,30.3) v11(101.12,28.75) v11(101.16,34.59) v11(101.16,33.32) v11(101.16,27.48) v11(101.29,37.59) v11(101.29,36.32) v11(101.42,43.28) v11(101.42,42.01) v11(102.14,53.19) v11(102.2,72.3) v11(102.2,71.03) v11(102.2,69.76) v11(102.2,68.49) v11(102.2,67.22) v11(102.2,65.95) v11(102.2,64.68) v11(102.2,63.41) v11(102.2,62.14) v11(102.2,60.87) v11(102.2,59.6) v11(102.2,58.33) v11(102.2,57.06) v11(102.2,55.79) v11(102.2,54.52) v11(102.18,2.08) v11(102.51,30.01) v11(102.51,28.74) v11(102.51,27.47) v11(102.75,44.56) v11(102.75,43.29) v11(103.02,39.25) v11(103.02,37.98) v11(103,36.65) v11(103,35.38) v11(102.99,34.22) v11(102.99,32.95) v11(103.22,72.17) v11(103.45,2.08) v11(103.69,45.4) v11(103.69,44.13) v11(103.68,42.62) v11(103.74,30.03) v11(103.74,28.76) v11(103.74,27.49) v11(103.92,69.7) v11(103.99,56.89) v11(104.03,3.35) v11(104.39,58.47) v11(104.49,72.17) v11(104.49,61.42) v11(104.46,59.97) v11(104.55,38.35) v11(104.55,37.08) v11(104.57,34.78) v11(104.57,33.51) v11(104.72,71.77) v11(104.72,2.08) v11(104.87,70.78) v11(105.05,4.49) v11(105.1,46.63) v11(105.1,45.36) v11(105.1,44.28) v11(105.1,43.01) v11(105.11,30.2) v11(105.11,28.93) v11(105.11,27.66) v11(105.11,26.39) v11(105.15,41.53) v11(105.15,40.26) v11(105.39,5.36) v11(105.63,3.35) v11(105.76,72.17) v11(105.99,71.77) v11(106.01,14.06) v11(105.99,12.51) v11(105.99,2.08) v11(106.05,48) v11(106.05,46.73) v11(106.13,38.4) v11(106.13,37.13) v11(106.13,35.96) v11(106.13,34.69) v11(106.13,33.42) v11(106.13,32.15) v11(106.13,30.88) v11(106.13,29.61) v11(106.13,28.34) v11(106.13,27.07) v11(106.13,25.8) v11(106.22,45.77) v11(106.22,44.5) v11(106.22,43.14) v11(106.22,41.87) v11(106.18,40.71) v11(106.18,39.44) v11(106.33,9.96) v11(106.26,8.39) v11(106.36,7) v11(106.47,4.46) v11(106.59,15.12) v11(106.79,11.34) v11(106.86,5.35) v11(107.03,72.17) v11(107.03,48.54) v11(107.03,47.27) v11(107.03,46) v11(106.95,44.19) v11(106.95,42.92) v11(106.95,41.65) v11(106.95,40.38) v11(106.95,39.11) v11(106.95,37.84) v11(107.11,35.99) v11(107.11,34.72) v11(107.11,33.45) v11(107.11,32.18) v11(107.11,30.91) v11(107.11,29.64) v11(107.11,28.37) v11(107.11,27.1) v11(107.11,25.83) v11(107.11,24.56) v11(107.07,23.16) v11(107.07,3.35) v11(107.26,71.77) v11(107.27,21.91) v11(107.26,2.08) v11(107.54,12.5) v11(107.51,8.41) v11(107.72,62.37) v11(107.74,60.92) v11(107.72,59.49) v11(107.72,58.1) v11(107.72,57.35) v11(107.68,9.99) v11(107.89,4.47) v11(107.96,49.86) v11(107.96,48.59) v11(107.96,47.32) v11(107.96,46.05) v11(108.03,6.97) v11(108.25,5.33) v11(108.3,72.17) v11(108.3,43.08) v11(108.3,41.81) v11(108.3,40.54) v11(108.3,39.27) v11(108.3,38) v11(108.3,36.73) v11(108.33,35.29) v11(108.33,34.02) v11(108.33,32.75) v11(108.33,31.48) v11(108.33,30.21) v11(108.33,28.94) v11(108.33,27.67) v11(108.33,26.4) v11(108.33,25.13) v11(108.33,23.86) v11(108.44,23.2) v11(108.4,11.38) v11(108.4,2.07) v11(108.53,71.77) v11(108.91,8.36) v11(109.14,4.56) v11(109.15,12.43) v11(109.19,9.12) v11(109.33,22.36) v11(109.28,20.29) v11(109.28,9.93) v11(109.54,50.1) v11(109.51,16.39) v11(109.46,6.91) v11(109.53,5.33) v11(109.57,72.17) v11(109.61,47.06) v11(109.71,41.12) v11(109.72,40.04) v11(109.72,38.77) v11(109.72,37.5) v11(109.67,36.18) v11(109.67,34.91) v11(109.67,33.64) v11(109.67,32.37) v11(109.67,31.1) v11(109.67,29.83) v11(109.67,28.56) v11(109.67,27.29) v11(109.67,26.02) v11(109.67,24.75) v11(109.67,2.07) v11(109.8,71.77) v11(109.89,21.61) v11(110,48.73) v11(110.03,23.2) v11(110.26,8.48) v11(110.74,39.89) v11(110.74,38.62) v11(110.74,37.35) v11(110.74,36.08) v11(110.84,72.17) v11(110.81,50.1) v11(110.84,35.29) v11(110.84,34.02) v11(110.84,32.75) v11(110.84,31.48) v11(110.84,30.21) v11(110.84,28.94) v11(110.84,27.67) v11(110.84,26.4) v11(110.84,25.13) v11(110.84,23.86) v11(110.81,10.04) v11(110.78,3.69) v11(110.88,47.06) v11(110.94,2.07) v11(111.03,22.4) v11(111.07,71.77) v11(111.09,21.5) v11(111.27,48.73) v11(112.05,21.14) v11(112.05,3.11) v11(112.11,72.17) v11(112.08,50.1) v11(112.15,47.06) v11(112.21,2.07) v11(112.34,71.77) v11(112.4,20.29) v11(112.4,18.9) v11(112.54,48.73) v11(112.66,18.44) v11(113.02,21.69) v11(113,6.25) v11(113.08,20.14) v11(113.11,17.25) v11(113.06,14.54) v11(113.27,8.53) v11(113.32,3.11) v11(113.38,72.17) v11(113.35,50.1) v11(113.42,47.06) v11(113.5,6.25) v11(113.48,2.07) v11(113.61,71.77) v11(113.62,4.85) v11(113.74,20.31) v11(113.81,48.73) v11(113.77,21.21) v11(113.81,18.88) v11(113.82,14.54) v11(114.54,19.34) v11(114.65,72.17) v11(114.56,45.17) v11(114.56,21.56) v11(114.59,14.54) v11(114.56,2.09) v11(114.84,8.53) v11(114.88,71.77) v11(115.02,50.06) v11(114.99,17.54) v11(114.98,4.81) v11(115.35,14.54) v11(115.84,7.86) v11(115.83,2.09) v11(115.92,72.17) v11(116.15,71.77) v11(116.09,43.75) v11(116.11,17.44) v11(116.11,14.54) v11(116.11,8.53) v11(116.06,4.82) v11(116.29,50.06) v11(116.81,4.25) v11(116.87,14.54) v11(117.11,7.86) v11(117.1,2.09) v11(117.19,72.17) v11(117.42,71.77) v11(117.39,4.81) v11(117.63,14.54) v11(117.76,3.11) v11(118.4,14.54) v11(118.4,3.11) v11(118.37,2.09) v11(118.46,72.17) v11(118.69,71.77) v11(118.85,9.63) v11(118.97,8.57) v11(119.16,14.54) v11(119.54,17.44) v11(119.64,2.09) v11(119.73,72.17) v11(119.82,7.72) v11(119.92,14.54) v11(119.96,71.77) v11(120.24,8.57) v11(120.43,9.12) v11(120.81,14.54) v11(121,72.17) v11(121.09,7.72) v11(121.23,71.77) v11(121.17,9.99) v11(121.25,19.72) v11(121.52,43.85) v11(121.47,18.63) v11(121.51,14.54) v11(121.51,8.57) v11(121.86,45.32) v11(122.05,21.64) v11(122.21,14.54) v11(122.27,72.17) v11(122.55,46.91) v11(122.46,20.2) v11(122.56,71.77) v11(122.79,43.85) v11(122.97,14.54) v11(123.13,45.32) v11(123.1,8.28) v11(123.4,24.04) v11(123.54,72.17) v11(123.58,18.64) v11(123.73,14.54) v11(123.77,71.77) v11(123.81,23.64) v11(124,11.99) v11(124.06,43.85) v11(124.3,20.04) v11(124.4,45.32) v11(124.39,21.66) v11(124.37,8.28) v11(124.49,14.54) v11(124.81,72.17) v11(124.92,18.62) v11(125.03,2.02) v11(125.06,12.83) v11(125.05,10.25) v11(125.17,30.49) v11(125.19,7.96) v11(125.33,43.85) v11(125.32,9.12) v11(125.9,21.44) v11(125.85,20.08) v11(125.9,4.99) v11(125.97,3.28) v11(126.08,72.17) v11(126.2,43.4) v11(126.33,12.83) v11(126.32,10.25) v11(126.3,2.02) v11(126.49,18.6) v11(126.52,17.42) v11(126.54,13.78) v11(126.46,7.96) v11(127.09,42.5) v11(127.17,21.44) v11(127.22,20.08) v11(127.17,4.99) v11(127.24,3.28) v11(127.35,72.17) v11(127.32,18.36) v11(127.44,15.07) v11(127.6,12.83) v11(127.59,10.25) v11(127.57,2.02) v11(127.73,7.96) v11(127.81,31.06) v11(127.99,84.25) v11(127.99,41.6) v11(128.14,14.74) v11(128.2,17.23) v11(128.3,19.06) v11(128.44,21.44) v11(128.44,4.99) v11(128.54,20.05) v11(128.51,3.28) v11(128.62,72.17) v11(128.84,2.02) v11(129.03,19.19) v11(129.19,17.87) v11(129.18,16) v11(129.71,21.44) v11(129.81,20.05) v11(129.83,16.01) v11(129.89,72.17) v11(129.95,78.01) v11(129.95,77.38) v11(129.95,76.55) v11(129.95,76.17) v11(130.3,19.19) v11(130.35,18.15) v11(130.36,17.16) v11(130.72,78.01) v11(130.72,77.38) v11(130.72,76.55) v11(130.72,76.17) v11(130.98,21.44) v11(131.08,20.05) v11(131.16,72.17) v11(131.48,78.01) v11(131.48,77.38) v11(131.48,76.55) v11(131.48,76.17) v11(131.57,19.19) v11(131.62,18.15) v11(131.63,17.16) v11(132.24,78.01) v11(132.24,77.38) v11(132.24,76.55) v11(132.24,76.17) v11(132.18,27.32) v11(132.25,21.44) v11(132.43,72.17) v11(132.35,20.05) v11(132.72,25.18) v11(132.84,19.19) v11(132.89,18.15) v11(132.9,17.16) v11(133.32,25.16) v11(133.45,27.32) v11(133.52,21.44) v11(133.62,20.05) v11(133.7,72.17) v11(134.11,19.19) v11(134.79,21.44) v11(134.89,20.05) v11(134.97,72.17) v11(134.97,27.44) v11(135.38,19.19) v11(135.61,27.44) v11(136.06,21.44) v11(136.24,72.17) v11(136.16,20.05) v11(137.33,21.44) v11(137.38,26.86) v11(137.51,72.17) v11(138.6,21.44) v11(138.78,72.17) v11(138.91,25.77) v11(138.89,24.37) v11(138.87,23.09) v11(139.87,21.44) v11(140.05,72.17) v11(140.14,23.09) v11(140.18,25.77) v11(140.16,24.37) v11(140.89,28.19) v11(141.14,21.44) v11(141.32,72.17) v11(141.45,25.77) v11(141.43,24.37) v11(141.41,23.09) v11(141.89,77.25) v11(141.89,76.74) v11(142.16,28.19) v11(142.45,74.66) v11(142.59,72.17) v11(142.65,77.25) v11(142.65,76.74) v11(142.72,25.77) v11(142.7,24.37) v11(142.68,23.09) v11(143.21,74.66) v11(143.19,21.41) v11(143.26,73.85) v11(143.42,77.25) v11(143.42,76.74) v11(143.43,28.19) v11(143.66,23.06) v11(143.86,72.17) v11(143.92,24.19) v11(143.97,74.66) v11(144.03,25.54) v11(144.18,77.25) v11(144.18,76.74) v11(144.53,73.85) v11(144.47,21.42) v11(144.74,74.66) v11(144.7,28.19) v11(144.93,23.06) v11(145.13,72.17) v11(145.19,24.19) v11(145.35,76.35) v11(145.3,25.54) v11(145.41,75.73) v11(145.54,76.91) v11(145.5,74.66) v11(145.69,75.16) v11(145.8,73.85) v11(145.77,21.56) v11(145.9,77.39) v11(146.2,74.69) v11(146.4,72.17) v11(146.54,77.72) v11(146.46,24.19) v11(146.48,22.21) v11(146.57,25.54) v11(146.95,74.52) v11(147.07,73.85) v11(147.1,22.81) v11(147.17,77.79) v11(147.67,72.17) v11(147.81,74.51) v11(147.96,77.8) v11(148.34,73.85) v11(148.67,74.51) v11(148.81,77.79) v11(148.94,72.17) v11(149.44,74.51) v11(149.58,77.79) v11(149.61,73.85) v11(149.94,25.82) v11(150.2,74.53) v11(150.21,72.17) v11(150.35,77.75) v11(150.95,77.51) v11(150.98,74.83) v11(151.21,25.82) v11(151.43,76.97) v11(151.47,75.4) v11(151.45,74.66) v11(151.48,72.17) v11(151.65,76.17) v11(152.08,24.47) v11(152.22,74.66) v11(152.37,23) v11(152.75,72.17) v11(152.98,74.66) v11(153.03,73.84) v11(153.35,24.47) v11(153.64,23) v11(153.74,74.66) v11(153.88,76.34) v11(154.02,72.17) v11(154.3,73.84) v11(154.73,75.53) v11(154.66,22.99) v11(154.9,74.65) v11(154.93,26.39) v11(155.29,72.17) v11(155.57,73.84) v11(155.65,24.71) v11(155.8,71.77) v11(155.91,74.65) v11(155.93,22.99) v11(156.2,26.39) v11(156.55,25.64) v11(156.84,73.84) v11(156.92,24.71) v11(157.07,71.77) v11(157.27,50.11) v11(157.27,49.46) v11(157.82,25.64) v11(157.96,83.4) v11(158.11,73.84) v11(158.34,71.77) v11(158.3,24.87) v11(158.53,79.26) v11(158.88,83.84) v11(159.38,73.84) v11(159.61,71.77) v11(159.57,24.87) v11(159.99,45.6) v11(159.99,42.99) v11(160.05,80.53) v11(160.05,75.72) v11(160.15,83.84) v11(160.28,27.02) v11(160.65,73.84) v11(160.88,71.77) v11(161.07,80.53) v11(161.26,45.02) v11(161.42,83.84) v11(161.63,28.03) v11(161.55,27.02) v11(161.77,49.39) v11(161.92,73.84) v11(161.89,30.5) v11(162.15,80.53) v11(162.15,71.77) v11(162.53,42.99) v11(162.69,83.84) v11(162.66,24.9) v11(162.9,28.03) v11(163.14,49.41) v11(163.16,80.53) v11(163.19,73.84) v11(163.16,47.56) v11(163.16,30.5) v11(163.42,71.77) v11(163.74,72.17) v11(163.7,50.68) v11(163.75,25.92) v11(163.93,83.67) v11(163.93,24.9) v11(163.99,80.53) v11(164.24,27.94) v11(164.31,50.68) v11(164.31,40.96) v11(164.43,30.5) v11(164.46,73.84) v11(164.5,45.34) v11(164.69,71.77) v11(164.94,83.91) v11(165.01,80.53) v11(165.01,72.17) v11(165.02,25.92) v11(165.2,44.64) v11(165.2,42.23) v11(165.51,27.94) v11(165.73,73.84) v11(165.7,30.5) v11(165.77,80.45) v11(165.96,71.77) v11(166.3,78.37) v11(166.28,72.17) v11(166.4,80.45) v11(166.47,42.23) v11(167.04,80.45) v11(167,73.84) v11(167.23,71.77) v11(167.27,83.88) v11(167.29,79.5) v11(167.74,45.86) v11(167.9,75.03) v11(168.35,80.14) v11(168.27,73.84) v11(168.42,83.87) v11(168.55,71.21) v11(168.63,53.06) v11(168.69,54.44) v11(168.82,72.17) v11(169.45,83.87) v11(169.51,80.14) v11(169.54,73.84) v11(169.49,70.25) v11(169.51,53.77) v11(169.53,52.35) v11(170.02,41.72) v11(170.13,83.16) v11(170.14,82.11) v11(170.13,80.98) v11(170.14,79.41) v11(170.14,78.14) v11(170.14,76.87) v11(170.14,75.6) v11(170.14,74.33) v11(170.09,72.17) v11(170.15,19.89) v11(170.4,69.37) v11(170.53,50.68) v11(170.62,54.81) v11(170.61,53.53) v11(170.58,52.32) v11(170.85,68.02) v11(170.85,66.75) v11(170.85,65.48) v11(170.85,64.21) v11(170.85,62.94) v11(170.85,61.67) v11(170.85,60.4) v11(170.85,59.13) v11(170.85,57.86) v11(170.85,56.59) v11(170.85,55.32) v11(171.29,70.97) v11(171.29,69.7) v11(171.29,68.43) v11(171.29,67.16) v11(171.29,65.89) v11(171.29,63.35) v11(171.29,60.81) v11(171.29,59.54) v11(171.29,58.27) v11(171.29,57) v11(171.29,55.73) v11(171.34,54.05) v11(171.32,52.74) v11(171.36,72.17) v11(171.36,64.62) v11(171.39,21.28) v11(172.02,53.36) v11(172.02,19.76) v11(172.08,52.39) v11(172.27,54.79) v11(172.49,54.06) v11(172.94,35.48) v11(172.94,33.63) v11(172.99,20.9) v11(173.12,22.99) v11(173.24,45.69) v11(173.34,54.05) v11(174.02,67.33) v11(174,36.55) v11(173.98,22.01) v11(174.1,19.77) v11(174.19,72.79) v11(174.19,71.52) v11(174.19,70.22) v11(174.19,68.95) v11(174.47,58.22) v11(174.98,54.38) v11(175.01,23.24) v11(175.23,55.66) v11(175.28,57.75) v11(175.46,72.79) v11(175.46,71.52) v11(175.46,70.22) v11(175.46,68.95) v11(175.51,20.84) v11(175.65,53.38) v11(175.57,18.43) v11(175.58,16.75) v11(175.65,15.02) v11(175.57,12.41) v11(175.56,9.69) v11(175.69,57.29) v11(176.04,68.64) v11(176.05,68.15) v11(176.12,36.93) v11(176.25,56.3) v11(176.25,55.35) v11(176.21,54.18) v11(176.37,22.11) v11(176.52,32.51) v11(176.63,19.75) v11(176.68,53.4) v11(176.75,36.52) v11(176.88,40.33) v11(176.88,38.54) v11(176.87,29.68) v11(177.2,18.32) v11(177.32,36.52) v11(177.35,35.15) v11(177.43,41.88) v11(177.45,41.18) v11(177.52,40.33) v11(177.46,37.95) v11(177.54,20.98) v11(177.59,53.78) v11(177.71,10.82) v11(177.77,65.16) v11(177.87,53.22) v11(177.93,32.61) v11(177.98,68.2) v11(178.01,12.84) v11(178.07,54.52) v11(178.14,27.61) v11(178.15,32.13) v11(178.24,29.84) v11(178.43,53.81) v11(178.59,16.37) v11(178.66,66.58) v11(178.94,55.12) v11(178.94,19.54) v11(179.08,54.47) v11(179.1,14.46) v11(179.57,65.68) v11(179.75,32.05) v11(179.83,13.21) v11(179.94,56.13) v11(179.9,55.27) v11(179.85,28.65) v11(180.02,38.71) v11(180.02,37.95) v11(180.02,37.18) v11(179.99,18.38) v11(180.16,34.01) v11(180.73,56.95) v11(180.77,68.16) v11(180.92,56.25) v11(181.02,16.61) v11(181.15,66.55) v11(181.25,32.65) v11(181.35,14.83) v11(181.45,56.79) v11(181.6,9.9) v11(181.71,34.48) v11(181.92,57.5) v11(182.01,55.78) v11(181.96,13.17) v11(182.02,8.51) v11(182.16,6.63) v11(182.28,33.92) v11(182.38,65.58) v11(182.6,12.23) v11(182.6,11.78) v11(182.6,11.34) v11(182.91,33.92) v11(182.99,31.42) v11(182.95,18.36) v11(183.23,55.76) v11(183.28,70.61) v11(183.28,69.34) v11(183.55,33.92) v11(183.65,42.01) v11(183.65,40.11) v11(183.56,16.65) v11(183.61,14.39) v11(183.65,6.41) v11(183.67,73.13) v11(183.71,37.95) v11(183.8,68.36) v11(183.8,67.09) v11(183.84,12.23) v11(183.84,11.78) v11(183.84,11.34) v11(183.76,8.14) v11(184.21,41.4) v11(184.18,37.43) v11(184.16,31.57) v11(184.3,43.45) v11(184.31,35.75) v11(184.28,9.96) v11(184.55,70.61) v11(184.55,69.34) v11(184.73,55.78) v11(184.74,8.1) v11(184.73,6.79) v11(184.94,41.69) v11(184.86,13.21) v11(185.02,32.54) v11(185.07,68.36) v11(185.07,67.09) v11(185.21,9.42) v11(185.69,49.78) v11(185.68,18.32) v11(185.83,65.8) v11(185.83,64.53) v11(185.95,16.23) v11(185.92,11.54) v11(185.96,39.36) v11(186.02,14.2) v11(186.06,70.65) v11(186.06,69.38) v11(186.14,45.12) v11(186.19,55.78) v11(186.43,40.01) v11(186.66,47.89) v11(186.8,10.84) v11(186.86,68.21) v11(186.86,66.94) v11(187.04,12.61) v11(187.1,65.8) v11(187.1,64.53) v11(187.12,6.28) v11(187.33,70.65) v11(187.33,69.38) v11(187.28,36.23) v11(187.31,14.15) v11(187.54,42.89) v11(187.78,55.21) v11(187.84,18.74) v11(187.81,7.3) v11(187.9,49.22) v11(187.87,32.17) v11(187.87,9.55) v11(188.02,16.42) v11(187.97,13.68) v11(187.97,11.9) v11(187.98,10.87) v11(188.13,68.21) v11(188.13,66.94) v11(188.2,47.52) v11(188.84,15.54) v11(188.92,65.78) v11(188.92,64.51) v11(188.93,45.51) v11(188.93,39.01) v11(189.14,56.7) v11(189.15,20.01) v11(189.19,55.36) v11(189.21,6.27) v11(189.35,62.9) v11(189.38,48.23) v11(189.39,41.55) v11(189.54,17.96) v11(189.69,68.2) v11(189.69,66.93) v11(189.71,44.65) v11(189.83,32.31) v11(189.76,11.7) v11(189.9,30.71) v11(190.05,54.56) v11(190.19,65.78) v11(190.19,64.51) v11(190.15,55.98) v11(190.18,20.97) v11(190.58,17.4) v11(190.74,38.31) v11(190.82,14.5) v11(190.96,68.2) v11(190.96,66.93) v11(190.98,12.2) v11(191.09,33.41) v11(191.21,16.76) v11(191.34,54.17) v11(191.27,39.62) v11(191.31,19.71) v11(191.42,45.57) v11(191.4,42.37) v11(191.47,60.41) v11(191.46,57.42) v11(191.62,56.26) v11(191.74,58.49) v11(191.82,65.78) v11(191.82,64.51) v11(192.31,18.76) v11(192.5,12.2) v11(192.55,20.93) v11(192.74,58.33) v11(192.93,43.69) v11(192.93,40.92) v11(192.97,38.12) v11(193.09,65.78) v11(193.09,64.51) v11(193.09,17.51) v11(193.21,54.34) v11(193.22,14.55) v11(193.85,12.2) v11(193.89,20.61) v11(194.04,25.06) v11(193.97,19.15) v11(194.38,67.71) v11(194.47,65.8) v11(194.48,64.54) v11(194.72,16.66) v11(195.26,59.39) v11(195.32,20.22) v11(195.31,12.25) v11(195.71,18.96) v11(195.85,65.39) v11(195.96,58.54) v11(196.06,68.6) v11(196.5,17.5) v11(196.45,14.32) v11(196.87,23.81) v11(196.91,21.69) v11(196.88,20.22) v11(196.93,11.45) v11(197.03,42.65) v11(197.03,42.01) v11(197.03,41.38) v11(197.2,67.26) v11(197.16,36.74) v11(197.16,36.1) v11(197.5,16.03) v11(197.56,40.36) v11(197.62,39.03) v11(197.67,37.45) v11(197.71,12.91) v11(197.95,47.85) v11(198.09,18.85) v11(198.36,68.39) v11(198.36,10.17) v11(198.72,65.72) v11(198.83,39.18) v11(198.91,44.33) v11(198.99,40.21) v11(199.04,12.03) v11(199.32,15.05) v11(199.42,37.9) v11(199.38,27.47) v11(199.54,62.01) v11(199.55,44.33) v11(199.46,24.03) v11(199.46,22.59) v11(199.47,17.44) v11(199.6,59.79) v11(199.65,64.74) v11(199.77,67.24) v11(199.85,25.89) v11(200.01,20.88) v11(200.06,49.52) v11(200.08,47.89) v11(200.34,10.17) v11(200.36,39.3) v11(200.62,40.16) v11(200.64,12.8) v11(200.9,27.57) v11(200.98,19.56) v11(201.15,63.93) v11(201.07,59.59) v11(201.14,12.8) v11(201.24,66.39) v11(201.18,21.46) v11(201.33,65.09) v11(201.29,24.04) v11(201.47,60.95) v11(201.53,25.63) v11(201.49,16.84) v11(201.57,51.61) v11(201.75,39.41) v11(201.76,68.48) v11(202.03,44.33) v11(202.14,62.79) v11(202.25,48.21) v11(202.6,44.33) v11(202.61,14.76) v11(202.75,10.15) v11(202.76,59.41) v11(202.86,40.14) v11(202.89,33.12) v11(202.89,32.49) v11(202.89,31.85) v11(203.05,27.57) v11(203.22,63.88) v11(203.51,61.36) v11(203.49,18.02) v11(203.74,67.66) v11(203.66,65.09) v11(203.68,16.71) v11(203.85,38.3) v11(204.01,25.79) v11(204.07,39.1) v11(204.21,62.72) v11(204.22,36.42) v11(204.22,35.79) v11(204.22,35.15) v11(204.19,19.51) v11(204.44,70.2) v11(204.35,42.65) v11(204.35,42.01) v11(204.35,41.38) v11(204.38,10.16) v11(204.45,51.57) v11(204.64,12.8) v11(204.67,40.75) v11(204.68,37.1) v11(204.77,59.84) v11(204.85,44.3) v11(205,63.84) v11(205.05,27.62) v11(205.1,33.65) v11(205.16,46.99) v11(205.25,48.09) v11(205.29,39.13) v11(205.28,37.39) v11(205.33,35.61) v11(205.51,41.35) v11(205.61,42.98) v11(205.67,65.48) v11(206.12,59.24) v11(206.06,56.2) v11(206.14,12.8) v11(206.15,16.74) v11(206.27,17.98) v11(206.47,28.56) v11(206.47,27.56) v11(206.47,26.56) v11(206.57,10.17) v11(206.88,51.13) v11(207,73.33) v11(207.24,61.25) v11(207.19,19.48) v11(207.61,65.34) v11(207.63,33.12) v11(207.64,12.8) v11(207.83,34.3) v11(207.84,10.17) v11(207.95,55.3) v11(207.87,49.67) v11(207.89,32.04) v11(207.87,30.35) v11(208.13,48.04) v11(208.24,65.67) v11(208.22,42.89) v11(208.22,40.16) v11(208.26,38.23) v11(208.29,26.8) v11(208.35,58.09) v11(208.4,47.09) v11(208.38,41.93) v11(208.53,43.99) v11(208.77,73.37) v11(208.85,66.65) v11(208.92,20.98) v11(209.01,54.48) v11(209.14,12.8) v11(209.24,40.77) v11(209.15,39.27) v11(209.24,37.68) v11(209.24,36.45) v11(209.19,17.99) v11(209.25,33.25) v11(209.32,31.39) v11(209.49,16.69) v11(209.86,57.03) v11(209.96,19.51) v11(210.08,72.38) v11(210.15,65.73) v11(210.28,59.62) v11(210.57,58.24) v11(210.64,12.8) v11(210.69,54.47) v11(210.92,73.37) v11(211.02,71.23) v11(211.25,18.02) v11(211.28,21.12) v11(211.55,72.3) v11(211.62,65.68) v11(211.74,50.01) v11(211.84,53.77) v11(212.05,68.4) v11(211.98,66.58) v11(212.08,16.72) v11(212.14,12.8) v11(212.41,59.24) v11(212.39,13.93) v11(212.48,55.54) v11(212.57,70.89) v11(212.95,56.45) v11(213,15.28) v11(213.14,52.36) v11(213.58,56.45) v11(213.95,61.34) v11(213.96,14.27) v11(214.05,44.85) v11(214.14,42.18) v11(214.15,39.47) v11(214.35,69.25) v11(214.33,55.18) v11(214.6,57.48) v11(214.62,40.78) v11(214.7,70.41) v11(214.68,10.37) v11(214.88,50.58) v11(215.09,54.56) v11(215.45,14.81) v11(215.36,12.05) v11(215.46,52.4) v11(215.62,13.37) v11(215.67,61.4) v11(215.65,30.36) v11(215.67,28.14) v11(215.88,69.44) v11(215.96,70.76) v11(215.97,40.8) v11(216.03,29.14) v11(216.12,42.49) v11(216.14,12.8) v11(216.22,57.97) v11(216.21,43.85) v11(216.5,10.69) v11(216.67,56.37) v11(216.89,46.95) v11(217.09,45.49) v11(217.23,30.38) v11(217.34,73.13) v11(217.39,57.27) v11(217.39,56.27) v11(217.43,28.1) v11(217.42,14.81) v11(217.47,49.72) v11(217.53,27.02) v11(217.56,63.28) v11(217.64,12.8) v11(218.09,52.36) v11(218.1,50.66) v11(218.14,12.8) v11(218.4,70.81) v11(218.47,29.12) v11(218.59,25.33) v11(218.56,10.74) v11(218.74,56.23) v11(218.69,54.58) v11(218.8,58.18) v11(218.87,64.57) v11(219.04,48.17) v11(219.08,73.06) v11(219.07,30.36) v11(219.21,26.95) v11(219.37,45.64) v11(219.37,28.13) v11(219.68,14.81) v11(219.74,12.03) v11(219.78,62.1) v11(219.98,71.04) v11(220.05,59.9) v11(220.02,51.07) v11(220.21,56.96) v11(220.21,25.31) v11(220.26,53.76) v11(220.44,64.87) v11(220.44,52.17) v11(220.39,49.48) v11(220.4,46.77) v11(220.63,27.01) v11(220.73,10.73) v11(220.94,54.61) v11(220.89,13.44) v11(220.91,12.05) v11(221.19,63.12) v11(221.41,60.6) v11(221.38,58.65) v11(221.99,15.14) v11(222.12,64.78) v11(222.14,47.05) v11(222.12,22.49) v11(222.24,56.21) v11(222.22,37.63) v11(222.19,25.56) v11(222.32,51.07) v11(222.28,42.91) v11(222.43,39.3) v11(222.55,52.67) v11(222.56,49.6) v11(222.71,68.34) v11(222.71,66.98) v11(222.7,62.65) v11(222.7,59.7) v11(222.73,57.5) v11(222.73,54.43) v11(222.7,35.61) v11(222.8,64.59) v11(222.75,45.07) v11(222.88,32.27) v11(222.94,10.7) v11(222.99,14.01) v11(222.98,12.72) v11(223.12,37.87) v11(223.07,16.33) v11(223.22,23.44) v11(223.17,19.94) v11(223.41,33.91) v11(224.48,28.71) v11(224.71,18.69) v11(224.8,17.21) v11(224.78,14.55) v11(224.81,12.33) v11(224.8,10.68) v11(225.2,27.58) v11(226.22,10.39) v11(226.47,21.5) v11(226.56,12.9) v11(226.66,19.4) v11(226.68,14.97) v11(226.78,17.12) v11(226.88,25.89) v11(226.98,11.1) v11(227.48,8.86) v11(227.96,20.32) v11(228.12,23.32) v11(228.28,24.92) v11(228.56,11.53) v11(228.58,9.26) v11(229.03,12.98) v11(229.64,14.78) v11(230.13,10.46) v11(231.01,11.52) v11(231.35,16.01) v11(231.78,12.93) v11(232.67,14.74) v11(232.76,11.06) v11(233.23,13.36) v11(234.28,16.01) v11(235.06,15.11) v11(235.57,13.96) v11(236.23,20.23) v11(237.17,17.23) v11(238.23,17.11) v11(238.16,10.26) v11(238.28,15.33) v11(239.59,12.94) v11(240.77,17.11) v11(241.51,15.19) v11(242.04,17.11) v11(242.63,9.02) v11(242.91,13.05) v11(243.31,17.11) v11(243.58,8.51) v11(244.02,14.95) v11(244.58,17.11) v11(245.78,14.15) v11(245.85,17.11) v11(247.12,17.11) v11(247.17,14.95) v11(248.39,17.11) v11(248.88,13.99) v11(249.66,17.11) v11(250.43,15.07) v11(250.93,17.11) v11(252.2,17.11) v11(252.46,14.69) v11(253.47,17.11) v11(253.49,13.3) v11(254.41,11.75) v11(255.2,16.17) v11(255.23,12.91) v11(256.01,17.11) v11(256.31,12.04) v11(256.59,14.92) v11(257.28,17.11) v11(258.48,16.98) v11(258.73,10.41) v11(260.08,18.44) v11(261.73,12.91) v11(264.23,21.47) v11(268.97,24.85) v11(271.33,25.35) v11(271.69,27.21) v11(272.94,33.78) v11(272.98,36.61) v11(272.99,25.07) v11(273.07,35.06) v11(273.15,26.77) v11(273.3,41.86) v11(273.26,38.56) v11(273.53,31.44) v11(273.64,28.32) v11(273.82,37.15) v11(274.02,41.86) v11(274.28,33.86) v11(274.5,39) v11(274.78,41.34) v11(274.82,40.59) v11(274.97,31.43) v11(275.24,33.46) v11(275.43,36.87) v11(275.46,35.28) v11(275.5,30.58) v11(275.86,37.25) v11(276.19,40.28) v11(276.36,40.99) v11(276.52,34.52) v11(276.51,33.46) v11(276.73,36.64) v11(276.66,35.51) v11(277.04,40.74) v11(277.02,31.01) v11(276.96,23.76) v11(277.55,29.48) v11(277.64,27.28) v11(277.74,25.67) v11(277.78,33.46) v11(277.93,35.51) v11(278,36.64) v11(278.23,23.76) v11(278.29,31.01) v11(278.51,37.5) v11(278.51,36.93) v11(278.82,29.48) v11(278.91,27.28) v11(279.01,25.67) v11(279.05,33.46) v11(279.2,35.51) v11(279.53,39.83) v11(279.5,23.76) v11(279.56,31.01) v11(279.71,37.06) v11(279.85,40.98) v11(280.09,29.48) v11(280.18,27.28) v11(280.32,33.46) v11(280.28,25.67) v11(280.83,31.01) v11(280.77,23.76) v11(280.89,39) v11(280.98,37.57) v11(281.02,35.75) v11(281.12,39.9) v11(281.36,29.48) v11(281.59,70.15) v11(281.59,33.46) v11(281.66,39) v11(281.66,34.99) v11(282.53,34.69) v11(282.56,40.07) v11(282.93,79.78) v11(282.9,38.44) v11(282.86,33.46) v11(282.95,72.62) v11(283.08,74.97) v11(284.21,80.44) v11(284.31,74.55) v11(284.73,67.36) v11(284.8,73.66) v11(285,76.71) v11(285,75.91) v11(284.96,72.29) v11(285.13,71.31) v11(285.22,74.55) v11(285.43,44.93) v11(285.4,28.55) v11(285.64,76.92) v11(285.55,72.9) v11(285.64,41.16) v11(285.57,39.65) v11(285.72,75.18) v11(285.71,70.67) v11(285.66,38.26) v11(285.82,35.32) v11(285.92,68.57) v11(285.91,42.98) v11(286.29,44.32) v11(286.35,36.68) v11(286.48,35.85) v11(286.48,35.22) v11(286.54,30.33) v11(286.56,79.6) v11(286.61,34.01) v11(286.58,32.45) v11(287.29,42.8) v11(287.35,24.57) v11(287.5,37.76) v11(287.48,29.18) v11(287.59,21.94) v11(287.71,44.3) v11(287.94,67.82) v11(287.94,34.07) v11(287.85,32.45) v11(288.03,30.31) v11(288.13,42.86) v11(288.23,79.14) v11(288.32,37.04) v11(288.75,29.18) v11(288.86,21.94) v11(289.07,44.3) v11(289.12,32.45) v11(289.25,35.42) v11(289.24,34.36) v11(289.28,42.07) v11(289.34,41.06) v11(289.3,30.31) v11(289.34,19.06) v11(289.43,17.11) v11(289.5,39.51) v11(289.52,38.12) v11(289.63,45.46) v11(289.57,15.73) v11(289.83,37.04) v11(290.13,21.94) v11(290.3,43.52) v11(290.44,39.17) v11(290.39,32.45) v11(290.57,30.31) v11(290.61,19.06) v11(290.7,17.11) v11(290.85,41.82) v11(290.84,15.73) v11(290.93,41.06) v11(290.94,32.21) v11(291.15,43.53) v11(291.23,35.36) v11(291.15,34.01) v11(291.35,45.77) v11(291.42,44.69) v11(291.45,37.74) v11(291.52,42.57) v11(291.54,41.21) v11(291.56,36.68) v11(292.35,45.53) v12(9.63,49.21) v12(10.67,49.21) v12(12.35,49.19) v12(13.42,49.19) v12(13.45,62.85) v12(14.16,62.26) v12(63.57,2.63) v12(64.7,2.4) v12(66.11,2.63) v12(67.38,2.63) v12(74.2,62.52) v12(74.2,60.87) v12(74.96,60.87) v12(75.79,60.87) v12(76.68,60.87) v12(77.44,60.87) v12(77.76,61.63) v12(85.63,62.27) v12(85.63,61.63) v12(85.63,61) v12(85.72,62.94) v12(85.82,60.43) v12(86.39,62.97) v12(86.39,60.3) v12(87.03,62.97) v12(87.03,60.3) v12(87.66,62.77) v12(87.73,62.2) v12(87.73,61.63) v12(87.73,61.06) v12(87.66,60.43) v12(89.31,56.68) v12(89.31,56.11) v12(89.31,55.47) v12(89.5,57.31) v12(89.5,54.9) v12(89.63,2.51) v12(90.14,57.44) v12(90.14,54.71) v12(90.71,57.44) v12(90.77,54.71) v12(91.16,2.51) v12(91.35,57.25) v12(91.35,54.84) v12(91.41,56.68) v12(91.41,56.04) v12(91.47,55.47) v12(94.33,57.63) v12(94.33,56.81) v12(94.33,56.04) v12(94.39,65.51) v12(94.39,64.68) v12(94.77,58.46) v12(94.77,55.22) v12(94.9,65.95) v12(95.22,57.63) v12(95.22,56.87) v12(95.22,56.04) v12(95.41,65.51) v12(95.41,64.68) v12(95.54,63.98) v12(102.69,61.06) v12(102.67,60.44) v12(102.66,59.8) v12(103.04,61.83) v12(103.05,59) v12(103.39,61.07) v12(103.4,60.44) v12(103.39,59.79) v12(110.87,67.06) v12(111.22,64.74) v12(111.22,64.17) v12(111.22,62.8) v12(111.22,54.99) v12(111.27,66.11) v12(111.58,67.69) v12(111.58,59.71) v12(111.58,59.4) v12(111.61,58.6) v12(111.56,57.83) v12(111.56,57.45) v12(111.58,56.02) v12(112.02,66.78) v12(112.02,65.4) v12(112.02,64.17) v12(112.02,58.9) v12(112.02,57.67) v12(112.02,56.3) v12(112.47,67.71) v12(112.62,59.6) v12(112.82,66.14) v12(112.82,64.73) v12(112.76,58.9) v12(113.18,67.06) v12(113.16,63.68) v12(113.18,63.24) v12(113.19,57.97) v12(113.19,57.3) v12(113.21,56.01) v12(113.23,55.33) v12(113.51,2.77) v12(113.62,67.35) v12(113.98,68.36) v12(114,63.17) v12(113.98,59.9) v12(115.03,2.77) v12(116.25,63.45) v12(116.26,59.62) v12(116.3,2.77) v12(116.39,68.34) v12(116.44,65.11) v12(116.47,63.82) v12(116.47,55.36) v12(116.59,63.45) v12(116.59,59.62) v12(116.89,58.9) v12(117.2,67.71) v12(117.2,67.06) v12(117.24,64.96) v12(117.18,57.92) v12(117.18,57.35) v12(117.18,56.09) v12(117.28,66.52) v12(117.27,65.84) v12(117.62,63.45) v12(117.62,58.9) v12(117.57,2.77) v12(117.98,57.31) v12(117.98,56.66) v12(118.07,67.71) v12(118.07,67.06) v12(118.07,65.85) v12(118.1,64.92) v12(118.07,63.16) v12(118.22,55.07) v12(118.42,60.27) v12(118.42,58.9) v12(118.42,58.32) v12(118.42,56.95) v12(118.68,63.55) v12(118.78,56.07) v12(122.84,82.84) v12(122.78,82.08) v12(123.18,81.68) v12(123.54,83.09) v12(123.82,82.14) v12(124.61,78.67) v12(124.77,82.22) v12(125.25,77) v12(125.45,77.95) v12(125.45,77.44) v12(125.46,78.33) v12(125.72,67.06) v12(125.74,65.26) v12(125.86,55.73) v12(126.08,82.24) v12(126.08,66.13) v12(126.07,58.89) v12(126.08,55) v12(126.27,82.65) v12(126.33,57.57) v12(126.44,67.64) v12(126.41,63.66) v12(126.44,63.16) v12(126.44,57.96) v12(126.47,59.94) v12(126.75,63.47) v12(126.93,65.4) v12(126.89,58.89) v12(126.88,56.3) v12(127.02,57.64) v12(127.02,43.64) v12(127.22,66.52) v12(127.32,65.11) v12(127.32,57.97) v12(127.32,55.38) v12(127.32,43.89) v12(127.48,58.96) v12(127.62,66.11) v12(127.59,64.16) v12(127.64,60.27) v12(127.62,56.96) v12(127.65,44.56) v12(127.65,43.65) v12(127.65,41.9) v12(127.65,41.12) v12(128.04,67.6) v12(128.04,67.07) v12(128.04,63.16) v12(128.06,56.17) v12(128.34,40.93) v12(128.35,44.74) v12(128.48,60.27) v12(128.52,57.53) v12(128.73,46.66) v12(128.84,63.2) v12(129.15,45.62) v12(129.22,45.29) v12(129.27,41.95) v12(129.39,43.29) v12(129.57,46) v12(130.03,47.75) v12(130.14,46.33) v12(130.14,45.27) v12(130.14,41.95) v12(130.33,43.95) v12(130.31,43.29) v12(130.41,45.62) v12(130.86,45.91) v12(131.11,59.61) v12(131.33,65.78) v12(131.33,65.11) v12(131.33,63.75) v12(131.33,59.28) v12(131.44,59.61) v12(131.68,68.07) v12(131.72,62.79) v12(132.05,67.06) v12(132.02,57.82) v12(132.04,57.3) v12(132.05,43.25) v12(132.11,66.42) v12(132.13,65.75) v12(132.13,44.59) v12(132.21,56.01) v12(132.26,57.59) v12(132.48,64.17) v12(132.48,58.9) v12(132.81,57.17) v12(132.81,56.81) v12(132.89,67.06) v12(132.93,65.75) v12(132.93,65.11) v12(132.93,59.94) v12(132.89,44.55) v12(132.95,62.99) v12(133.09,57.66) v12(133.18,64.16) v12(133.28,56.95) v12(133.41,56.45) v12(133.37,55.61) v12(133.57,67.49) v12(133.64,59.23) v12(133.61,58.75) v12(133.69,65.76) v12(133.8,43.33) v12(133.79,41.95) v12(134.02,47.56) v12(134.73,42.59) v12(135.31,46.32) v12(135.64,42.58) v12(135.68,44.63) v12(135.79,43.28) v12(136.61,46.32) v12(137.41,45.95) v12(137.48,45.27) v12(137.51,41.95) v12(137.62,43.28) v12(138.35,46.35) v12(138.4,45.99) v12(138.37,45.27) v12(138.37,41.95) v12(138.54,43.28) v12(138.59,43.95) v12(139.08,46.32) v12(139.9,45.95) v12(140.22,45.27) v12(140.25,46.42) v12(140.28,41.96) v12(140.37,43.28) v12(140.9,45.99) v12(141.28,45.25) v12(141.28,44.59) v12(141.31,43.94) v12(141.28,43.28) v12(141.42,46.58) v12(141.45,42.15) v12(141.75,45.63) v12(141.98,48) v12(141.97,47.71) v12(142.32,47.32) v12(142.83,65.12) v12(142.84,56.02) v12(142.87,65.76) v12(142.95,45.27) v12(143,41.95) v12(143.23,60.27) v12(143.21,58.9) v12(143.24,58.32) v12(143.23,56.95) v12(143.26,62.8) v12(143.49,64.2) v12(143.58,67.71) v12(143.58,67.04) v12(143.59,63.83) v12(143.58,55.36) v12(143.68,66.52) v12(143.91,65.42) v12(144.03,64.18) v12(144.03,58.9) v12(144.03,56.3) v12(144.14,57.65) v12(144.23,44.89) v12(144.18,44.07) v12(144.2,42.15) v12(144.25,63.37) v12(144.25,45.63) v12(144.43,67.04) v12(144.47,55.35) v12(144.6,67.42) v12(144.76,58.9) v12(144.83,58.32) v12(144.76,56.96) v12(145.04,77.49) v12(145.04,59.62) v12(145.12,65.53) v12(145.07,63.42) v12(145.1,46) v12(145.18,65.11) v12(145.18,63.78) v12(145.18,56.01) v12(145.32,76.44) v12(145.3,46.35) v12(145.37,63.42) v12(145.38,59.62) v12(145.71,47.61) v12(145.65,45.64) v12(145.71,45.27) v12(145.75,41.95) v12(145.87,43.29) v12(146.6,41.95) v12(146.84,43.98) v12(146.77,43.28) v12(146.9,44.69) v12(147.39,77.8) v12(147.67,63.21) v12(147.91,60.25) v12(148.42,43.25) v12(148.47,63.83) v12(148.47,63.14) v12(148.53,59.68) v12(148.47,45.27) v12(148.65,55.7) v12(148.6,44.59) v12(148.7,43.99) v12(148.83,68.07) v12(148.83,66.13) v12(148.77,42.18) v12(148.9,58.9) v12(148.88,56.37) v12(148.98,67.38) v12(149.19,65.18) v12(149.17,58.06) v12(149.18,57.35) v12(149.19,55.35) v12(149.27,62.48) v12(149.36,43.9) v12(149.64,64.17) v12(149.63,58.9) v12(149.66,47.78) v12(149.65,46) v12(149.71,42.28) v12(149.78,77.8) v12(149.98,66.41) v12(149.98,65.92) v12(149.98,57.31) v12(149.98,56.7) v12(150.1,67.58) v12(150.07,67.04) v12(150.08,63.69) v12(150.08,63.35) v12(150.39,66.11) v12(150.43,60.27) v12(150.43,58.9) v12(150.43,56.95) v12(150.41,55) v12(150.78,65.02) v12(150.78,58) v12(150.78,56.03) v12(151.52,45.05) v12(151.54,42.3) v12(151.58,77.74) v12(151.98,46.32) v12(151.98,45.68) v12(152.42,45.95) v12(152.55,79.72) v12(152.79,46.3) v12(153.49,77.75) v12(153.52,76.21) v12(153.93,45.27) v12(153.98,41.95) v12(154.63,76.87) v12(154.6,45.63) v12(154.9,41.95) v12(155.23,44.92) v12(155.35,77.62) v12(155.28,46.33) v12(156.12,76.81) v12(156.42,56.01) v12(156.46,67.63) v12(156.47,63.92) v12(156.5,60.08) v12(156.74,62.8) v12(156.67,45.27) v12(156.69,41.95) v12(156.79,66.7) v12(156.81,66.13) v12(156.83,58.9) v12(156.81,56.95) v12(156.83,55) v12(156.94,78.84) v12(157.02,76.21) v12(157.16,65) v12(157.16,64.58) v12(157.16,57.81) v12(157.39,77.63) v12(157.44,43.28) v12(157.61,66.78) v12(157.59,63.43) v12(157.56,59.61) v12(157.56,45.27) v12(157.7,78.71) v12(157.7,65.4) v12(157.66,55.74) v12(157.8,44.55) v12(157.8,42.63) v12(157.88,80.07) v12(157.99,57.34) v12(158,56.51) v12(158.06,67.69) v12(158.06,55.4) v12(158.34,64.17) v12(158.36,66.11) v12(158.41,64.74) v12(158.36,62.8) v12(158.35,60.27) v12(158.35,58.9) v12(158.44,57.67) v12(158.77,67.02) v12(159.14,59.54) v12(159.09,58.08) v12(159.44,63.43) v12(159.6,76.74) v12(160.45,77.57) v12(161.25,78.36) v12(161.32,60.16) v12(161.67,63.52) v12(162.03,67.74) v12(162.06,63.73) v12(162.15,63.4) v12(162.24,59.6) v12(162.41,66.13) v12(162.38,57.9) v12(162.4,55.65) v12(162.49,58.88) v12(162.52,57.66) v12(162.59,79.46) v12(162.63,73.2) v12(162.71,54.9) v12(162.77,67.05) v12(163.19,64.17) v12(163.32,59.61) v12(163.44,65.48) v12(163.47,77.39) v12(163.49,76) v12(163.55,74.88) v12(163.51,66.62) v12(163.55,56.82) v12(163.65,67.08) v12(163.65,57.96) v12(163.57,57.35) v12(163.66,65.64) v12(163.71,65.33) v12(163.66,63.14) v12(164.01,64.24) v12(163.98,60.27) v12(164.08,58.9) v12(164.35,55.51) v12(164.36,79.6) v12(164.37,67.71) v12(164.37,65.15) v12(164.37,57.29) v12(164.36,55.89) v12(164.59,74.78) v12(164.65,72.95) v12(164.88,79.92) v12(165.45,73.91) v12(165.7,77.51) v12(165.78,74.94) v12(165.91,72.31) v12(166.06,73.16) v12(166.28,71.73) v12(166.78,77.44) v12(166.82,75.92) v12(166.83,74.04) v12(166.9,80.14) v12(166.86,72.48) v12(167.43,73.1) v12(167.7,83.4) v12(167.66,71.69) v12(167.99,55.31) v12(168.05,72.41) v12(168.28,55.59) v12(168.5,83.58) v12(168.64,71.93) v12(169.41,83.54) v12(169.39,71.41) v12(169.63,71.93) v12(169.68,70.86) v12(170.21,70.71) v12(170.34,71.41) v12(170.33,45.85) v12(170.29,45.44) v12(170.38,71.99) v12(170.58,72.79) v12(170.68,43.52) v12(171.03,77.11) v12(170.96,70.38) v12(171.08,75.79) v12(171.05,46.51) v12(171.17,71.41) v12(171.17,70.71) v12(171.63,47.06) v12(171.69,74.71) v12(171.71,73.43) v12(171.71,43.52) v12(171.93,70.71) v12(172.12,47.51) v12(172.24,71.32) v12(172.17,46.39) v12(172.37,45.48) v12(172.37,43.79) v12(172.61,72.49) v12(172.57,70.38) v12(172.79,74.09) v12(173.01,70.71) v12(173.15,46.23) v12(173.3,73.19) v12(173.31,47.85) v12(173.29,46.99) v12(173.26,44.11) v12(173.83,43.47) v12(173.91,72.17) v12(174.02,44.8) v12(174.23,74.04) v12(174.16,70.42) v12(174.37,73.16) v12(174.38,48.47) v12(174.66,71.6) v12(175.24,71.88) v12(175.17,44.8) v12(175.23,43.79) v12(175.36,45.82) v12(175.64,74.14) v12(175.62,71.49) v12(175.83,73.28) v12(175.86,46.9) v12(175.99,44.36) v12(176.08,50.15) v12(176.12,45.38) v12(176.31,71.7) v12(176.56,46.46) v12(176.69,50.71) v12(176.83,71.04) v12(176.82,47.79) v12(176.87,74.12) v12(176.96,73.28) v12(176.97,71.6) v12(177.01,57.44) v12(177.02,56.4) v12(177.07,58.79) v12(177.21,55.42) v12(177.34,54.11) v12(177.36,52.84) v12(177.36,52.06) v12(177.39,47.34) v12(177.53,59.7) v12(177.64,48.61) v12(177.87,62.91) v12(177.92,61.82) v12(178.1,60.2) v12(178.19,64.06) v12(178.21,48.17) v12(178.4,49.38) v12(178.71,60.87) v12(178.8,68.72) v12(178.8,67.45) v12(178.8,66.18) v12(178.8,64.91) v12(179.04,48.93) v12(179.23,62.28) v12(179.17,50.2) v12(179.34,63.63) v12(179.27,61.4) v12(179.29,56.74) v12(179.29,55.28) v12(179.29,54.01) v12(179.29,52.74) v12(179.29,51.47) v12(179.67,57.89) v12(179.88,68.59) v12(179.93,67.26) v12(179.93,49.82) v12(179.99,65.85) v12(179.98,64.58) v12(180.12,56.81) v12(180.12,55.47) v12(180.12,53.88) v12(180.12,52.61) v12(180.12,51.34) v12(180.18,61.71) v12(180.27,56.04) v12(180.5,62.3) v12(180.64,54.23) v12(180.94,54.96) v12(180.97,63.61) v12(180.96,56.55) v12(180.98,55.85) v12(181.29,54.3) v12(181.38,68.31) v12(181.49,66.78) v12(181.5,65.44) v12(181.54,62.51) v12(181.49,57.39) v12(181.57,64.21) v12(181.72,61.75) v12(182.01,57.35) v12(182.07,56.7) v12(182.09,55.88) v12(182.1,55.19) v12(182.54,53.2) v12(182.56,54.29) v12(182.7,56.35) v12(182.71,55.03) v12(183.04,57.43) v12(183.06,55.89) v12(183.09,53.14) v12(183.89,53.3) v12(184.07,56.67) v12(184.07,55.57) v12(184.06,54.58) v12(184.44,56.16) v12(184.47,55.01) v12(184.61,53.12) v12(185.31,53.12) v12(185.43,55.99) v12(185.41,55.31) v12(185.5,56.6) v12(185.45,54.49) v12(185.9,53.49) v12(186.04,56.48) v12(186.06,55.89) v12(186.13,55.21) v12(186.34,54.48) v12(186.48,53.14) v12(187.03,56.63) v12(187,55.94) v12(187.22,53.14) v12(187.26,55.48) v12(187.32,54.62) v12(187.7,53.45) v12(212.5,2.32) v12(213.77,2.32) v12(215.04,2.32) v12(216.44,2.32) v12(217.71,2.32) v12(218.98,2.32) v12(239.94,3.47) v12(240.32,6.77) v12(241.21,3.47) v12(241.59,6.77) v12(242.48,3.47) v12(242.86,6.77) v12(243.75,3.47) v12(244.25,6.77) v12(245.02,3.47) v12(245.52,6.77) v12(246.03,7.78) v12(246.29,3.47) v12(246.79,8.93) v12(246.79,6.77) v12(247.3,7.78) v12(247.56,3.47) v12(247.94,6.77) v12(248.06,8.93) v12(248.57,7.78) v12(248.83,3.47) v12(249.21,6.77) v12(249.33,8.93) v12(250.1,3.47) v12(251.49,3.47) v12(252.76,3.47) v12(254.03,3.47) v12(255.3,3.47) v12(256.57,3.47) v12(257.84,3.47) v12(261.65,3.47) v12(262.41,6.26) v12(262.8,3.47) v12(263.68,6.26) v12(264.07,8.55) v12(264.07,3.47) v12(264.32,7.78) v12(264.83,8.67) v12(264.95,6.26) v12(275.43,71.41) v12(276.26,71.6) v12(276.45,71.16) v12(276.93,71.12) v12(277.36,71.55) v12(277.48,41.17) v12(277.97,70.97) v12(278.15,72.34) v12(278.23,72.93) v12(278.45,69.67) v12(278.61,73.63) v12(278.58,41.16) v12(279.37,74.27) v12(279.37,71.12) v12(279.62,71.66) v12(279.91,73.16) v12(280.45,75.35) v12(280.58,72.62) v12(280.89,75.86) v12(280.92,70.38) v12(281.21,74.46) v12(281.34,76.81) v12(281.4,68.78) v12(281.46,76.36) v12(281.46,67.98) v12(281.46,67.28) v12(281.78,73.95) v12(282.04,75.28) v12(282.76,74) v12(282.8,72.08) v12(283.12,76.72) v13(108.87,65.76) v13(110.1,56.81) v13(110.52,61.12) v13(110.64,64.51) v13(110.76,67.38) v13(110.8,65.51) v13(111.52,68.03) v13(111.54,55.66) v13(111.61,65.56) v13(111.62,64.13) v13(111.62,63.48) v13(111.62,58.93) v13(112.02,67.4) v13(112.02,54.27) v13(112.06,61.36) v13(112.17,62.3) v13(112.23,51.59) v13(112.44,65.56) v13(112.43,64.08) v13(112.36,58.93) v13(112.49,66.65) v13(112.45,56.39) v13(112.72,68.13) v13(112.81,52.66) v13(113.22,59.58) v13(113.22,57.63) v13(113.23,55.68) v13(113.26,67.39) v13(113.26,65.69) v13(113.61,61.35) v13(113.8,66.25) v13(114.17,58.44) v13(114.33,62.56) v13(115.32,60.98) v13(115.37,68.68) v13(115.37,65.58) v13(115.79,56.36) v13(116.2,61) v13(116.4,67.99) v13(116.42,67.38) v13(116.42,65.44) v13(116.36,64.17) v13(117.14,60.96) v13(117.22,66.17) v13(117.22,58.93) v13(118.02,67.38) v13(117.97,65.51) v13(118.02,64.13) v13(118.03,63.5) v13(117.96,62.66) v13(118.02,59.58) v13(118.02,58.93) v13(118.6,60.84) v13(118.81,58.9) v13(118.78,57.63) v13(118.78,57) v13(118.84,55.73) v13(118.94,62.6) v13(124.34,60.03) v13(125.09,64.83) v13(125.13,62.84) v13(125.11,61.12) v13(125.19,63.31) v13(125.27,55.65) v13(125.37,59.93) v13(125.62,67.49) v13(125.61,66.66) v13(125.62,65.59) v13(125.62,57.63) v13(125.64,56.48) v13(126.21,61.78) v13(126.46,66.65) v13(126.48,59.58) v13(126.51,55.36) v13(126.7,62.87) v13(126.98,61.29) v13(127.25,64.04) v13(127.29,65.58) v13(127.29,60.55) v13(127.38,57.63) v13(127.38,55.05) v13(127.6,68.15) v13(128.04,63.52) v13(127.96,54.65) v13(128.11,65.63) v13(128.09,59.42) v13(128.07,55.83) v13(128.27,45.12) v13(128.26,43.79) v13(128.33,40.59) v13(128.42,46.31) v13(128.51,61.44) v13(128.47,57.19) v13(128.68,41.35) v13(128.82,66.95) v13(128.76,61.04) v13(128.78,43.14) v13(128.94,52.42) v13(129,63.56) v13(129.18,64.63) v13(129.38,52.42) v13(129.64,69.14) v13(129.63,65.48) v13(129.74,64.61) v13(129.69,43.14) v13(129.69,41.85) v13(129.76,61.04) v13(130.45,63.84) v13(130.39,59.73) v13(130.45,57.15) v13(130.61,44.45) v13(130.61,43.71) v13(130.61,43.14) v13(130.61,41.85) v13(130.99,54.31) v13(131.04,45.39) v13(131.28,67.38) v13(131.28,65.45) v13(131.28,63.39) v13(131.33,60.74) v13(131.6,43.85) v13(131.69,61.4) v13(132.05,50.72) v13(132.08,66.08) v13(132.09,63.99) v13(132.06,62.9) v13(132.08,58.92) v13(132.42,44.42) v13(132.44,43.86) v13(132.44,43.24) v13(132.44,42.63) v13(132.49,69.14) v13(132.49,61.31) v13(132.65,60.21) v13(132.85,64.04) v13(132.87,67.4) v13(132.94,58.33) v13(132.96,58.95) v13(133.04,56.42) v13(133.32,60.58) v13(133.32,42.6) v13(133.36,45.01) v13(133.36,44.5) v13(133.35,43.86) v13(133.48,46.65) v13(133.61,62.36) v13(133.58,59.6) v13(133.58,57.62) v13(133.67,56.23) v13(133.84,64.15) v13(133.88,63.44) v13(134.18,43.33) v13(134.39,44.86) v13(134.94,61.9) v13(134.93,59.99) v13(135.21,42.58) v13(135.33,44.87) v13(135.38,69.41) v13(135.77,67.39) v13(135.77,57.43) v13(136.15,65.91) v13(136.1,44.43) v13(136.1,43.86) v13(136.11,43.22) v13(136.1,42.59) v13(136.51,64.6) v13(136.49,45.65) v13(136.63,63.55) v13(136.63,62.11) v13(136.63,60.68) v13(136.68,56.3) v13(137.01,44.23) v13(137.01,43.14) v13(137,41.15) v13(137.38,67.73) v13(137.52,41.51) v13(137.93,44.25) v13(137.93,43.14) v13(138.15,55.41) v13(138.37,41.53) v13(138.84,44.45) v13(138.84,43.71) v13(138.84,43.14) v13(138.88,67.69) v13(139.21,41.56) v13(139.3,65.45) v13(139.38,63.26) v13(139.38,61.7) v13(139.4,60.86) v13(139.43,59.17) v13(139.43,58.32) v13(139.75,44.22) v13(139.76,43.14) v13(140.04,67.13) v13(139.99,55.66) v13(140.06,55.15) v13(140.22,41.55) v13(140.67,44.22) v13(140.67,43.14) v13(141.12,41.83) v13(141.59,44.45) v13(141.59,43.71) v13(141.59,43.14) v13(141.9,41.56) v13(142.03,65.76) v13(142.15,58.2) v13(142.16,60.93) v13(142.5,43.14) v13(142.76,67.37) v13(142.77,57.63) v13(142.83,55.68) v13(142.91,68.78) v13(142.9,60.38) v13(143.42,43.14) v13(143.42,41.85) v13(143.48,62.14) v13(143.61,65.56) v13(143.62,63.48) v13(143.62,59.58) v13(143.62,58.93) v13(143.63,57.53) v13(143.98,41.82) v13(144.33,44.45) v13(144.33,43.71) v13(144.33,43.14) v13(144.43,66.27) v13(144.42,64.13) v13(144.42,58.93) v13(144.52,65.43) v13(144.46,57.54) v13(144.66,41.79) v13(144.94,61.05) v13(145.25,43.14) v13(145.23,41.53) v13(145.32,66.72) v13(145.27,62.11) v13(145.26,57.39) v13(145.31,55.55) v13(145.56,65.42) v13(145.71,58.01) v13(145.93,62.1) v13(145.94,58.75) v13(146.15,45.69) v13(146.16,43.14) v13(146.16,41.85) v13(146.83,62.05) v13(147.08,44.32) v13(147.08,43.71) v13(147.08,43.16) v13(147.07,42.14) v13(147.21,64.06) v13(147.4,48.28) v13(147.5,60.59) v13(147.48,58.77) v13(147.94,66.66) v13(147.99,64.79) v13(147.98,44.26) v13(147.97,43.04) v13(147.99,41.82) v13(148.2,57.61) v13(148.42,63.48) v13(148.41,61.71) v13(148.46,66) v13(148.49,45.71) v13(148.57,41.74) v13(149,43.83) v13(148.97,43.23) v13(149.13,41.76) v13(149.23,58.94) v13(149.21,56.35) v13(149.28,67.24) v13(149.26,65.51) v13(149.28,64.1) v13(149.64,61.44) v13(149.81,45.06) v13(149.82,43.92) v13(149.83,43.25) v13(149.8,42.63) v13(149.79,41.53) v13(149.93,64.97) v13(149.93,56.35) v13(150.03,64.12) v13(150.02,59.58) v13(150.02,58.93) v13(149.97,54.89) v13(150.25,47.92) v13(150.27,41.87) v13(150.75,42.58) v13(150.78,65.38) v13(150.78,57.63) v13(150.79,56.98) v13(151,61.96) v13(151.16,67.65) v13(151.53,43.28) v13(151.53,42.66) v13(151.61,45.45) v13(151.61,44.59) v13(152.54,65.74) v13(152.57,44.45) v13(152.57,43.71) v13(153.45,42.65) v13(153.5,41.63) v13(153.77,67.06) v13(153.89,64.43) v13(153.89,59.35) v13(153.96,62.14) v13(154.4,43.14) v13(154.43,41.46) v13(154.72,67.07) v13(154.9,65.66) v13(155.25,47.67) v13(155.31,44.32) v13(155.31,43.71) v13(155.31,43.14) v13(155.65,41.92) v13(155.87,68.07) v13(156.01,55.42) v13(156.23,43.14) v13(156.37,67.3) v13(156.37,66.71) v13(156.36,65.43) v13(156.42,59.05) v13(156.37,57.5) v13(156.52,55.69) v13(156.6,41.43) v13(156.78,61.24) v13(157.13,66.69) v13(157.1,63.48) v13(157.12,56.79) v13(157.11,45.08) v13(157.13,43.14) v13(157.18,59.6) v13(157.35,58.91) v13(157.43,62.26) v13(157.5,69.37) v13(157.87,64.16) v13(158.03,65.53) v13(158.01,62.9) v13(158.02,60.15) v13(158.11,68.03) v13(158.09,55.06) v13(158.21,61.1) v13(158.33,56.68) v13(158.71,67.37) v13(158.85,65.66) v13(158.81,63.6) v13(158.77,62.25) v13(158.81,59.65) v13(158.85,55.55) v13(158.88,57.39) v13(159.49,59.57) v13(159.66,54.47) v13(159.76,63.33) v13(159.93,61.35) v13(160.18,69.7) v13(160.29,65.76) v13(160.95,63.98) v13(161.06,49.42) v13(161.23,60.78) v13(161.25,59.16) v13(161.61,61.69) v13(162.01,67.38) v13(161.96,65.8) v13(162.01,54.49) v13(162.81,64.06) v13(162.81,59.01) v13(162.82,57.48) v13(162.77,55.69) v13(163.11,61.84) v13(163.35,62.85) v13(163.4,60.2) v13(163.73,63.49) v13(163.72,59.59) v13(163.8,61.32) v13(163.93,58.6) v13(164.41,57.63) v13(164.66,69.44) v13(164.85,61.52) v13(164.96,62.85) v13(165,60.19) v13(165.74,61.23) v13(166.42,58.66) v13(167.59,67.41) v13(168.5,63.13) v13(168.54,58.46) v13(277.13,63.47) v13(278.61,63.47) v13(278.75,70.51) v13(278.75,70.01) v13(278.87,66.91) v13(279.92,66.91) v13(291.95,61.89) v13(292.04,61.16) v14(11.59,60.55) v14(11.59,59.09) v14(12.61,65.31) v14(12.61,63.92) v14(13.37,59.22) v14(13.62,63.92) v14(73.88,61.63) v14(74.2,62.52) v14(74.2,60.81) v14(74.96,60.81) v14(75.85,63.6) v14(75.85,62.52) v14(75.85,60.81) v14(76.74,63.6) v14(76.74,62.52) v14(76.74,60.81) v14(77.44,60.81) v14(77.76,61.63) v14(101.04,22.67) v14(101.06,21.5) v14(101.86,21.36) v14(102.01,23.15) v14(102.27,20.93) v14(102.38,20.34) v14(102.98,20.27) v14(103.09,23.47) v14(103.51,20.23) v14(104.11,23.28) v14(104.19,22.76) v14(104.22,20.95) v14(104.26,22.08) v14(104.3,21.5) v14(104.3,20.42) v14(105.44,54.27) v14(105.51,55.09) v14(105.57,53.38) v14(106.2,55.35) v14(106.27,53.25) v14(106.9,55.35) v14(106.97,53.25) v14(121.29,72.78) v14(121.71,78.71) v14(121.74,77.52) v14(122.14,79.53) v14(122.18,73.32) v14(122.47,78.41) v14(122.47,77.34) v14(122.78,82.52) v14(122.84,81.95) v14(122.91,83.09) v14(123.03,74.1) v14(123.54,83.16) v14(123.54,81.7) v14(123.69,74.75) v14(123.84,78.36) v14(123.84,77.57) v14(124.05,82.21) v14(123.97,79.5) v14(124.3,82.97) v14(124.77,82.22) v14(125.19,79.73) v14(126.02,82.24) v14(126.16,79.73) v14(126.46,82.33) v14(127.17,79.73) v14(127.99,83.34) v14(128.95,83.03) v14(130.07,83.64) v14(130.55,83.08) v14(131.36,82.83) v14(132.48,81.66) v14(132.76,80.85) v14(132.76,79.96) v14(133.34,79.3) v14(134.08,79.28) v14(135.53,79.3) v14(136.8,79.3) v14(138.07,79.3) v14(139.34,79.3) v14(140.61,79.3) v14(141.88,79.3) v14(167.85,83.04) v14(168.1,83.5) v14(168.31,82.59) v14(168.68,83.5) v14(168.88,82.59) v14(169.45,83.48) v14(169.45,82.59) v14(169.64,83.03) v14(179.04,2.51) v14(180.31,2.51) v14(181.58,2.51) v14(182.85,2.51) v14(184.12,2.51) v14(185.39,2.51) v14(186.66,2.51) v14(187.93,2.51) v14(189.2,2.51) v14(190.47,2.51) v14(191.74,2.51) v14(193.01,2.51) v14(194.28,2.51) v14(195.55,2.51) v14(196.82,2.51) v14(198.09,2.51) v14(199.36,2.51) v14(200.63,2.51) v14(200.76,4.93) v14(201.9,2.51) v14(202.03,4.93) v14(203.17,2.51) v14(203.3,4.93) v14(204.44,2.51) v14(205.71,2.51) v14(206.98,2.51) v14(208.25,2.51) v14(209.52,2.51) v14(210.79,2.51) v14(212.06,2.51) v14(213.33,2.51) v14(214.6,2.51) v14(215.87,2.51) v14(216.63,4.04) v14(217.14,2.51) v14(217.65,5.31) v14(217.9,4.04) v14(218.41,2.51) v14(218.92,5.31) v14(219.17,4.04) v14(219.68,2.51) v14(241.02,7.59) v14(242.29,7.59) v14(243.56,7.59) v14(244.83,7.59) v14(246.1,7.59) v14(247.37,7.59) v14(248.64,7.59) v14(249.91,7.59) v14(251.18,7.59) v14(252.45,7.59) v14(253.72,7.59) v14(256.26,7.59) v14(257.53,7.59) v14(258.8,7.59) v14(261.34,7.59) v14(262.61,7.59) v14(263.88,7.59) v14(265.15,7.59) v14(266.54,7.59) v14(274.8,70.46) v14(275.62,71.28) v14(282.48,67.6) v15(97.72,77.93) v15(97.72,77.48) v15(97.71,76.94) v15(98.37,76.94) v15(98.95,76.94) v15(98.95,76.3) v15(99.56,76.3) v15(100.15,76.3) v15(100.79,76.29) v15(101.43,76.29) v15(102.06,76.29) v15(102.7,76.29) v15(103.33,76.29) v15(103.97,76.29) v15(104.6,76.29) v15(105.24,76.29) v15(105.87,76.29) v15(106.34,75.97) v15(106.75,75.56) v15(107.13,75.17) v15(107.54,74.76) v15(108.06,74.25) v15(108.73,74.24) v15(109.57,74.25) v15(177.39,74.27) v15(178.66,74.27) v15(179.93,74.27) v15(181.2,74.27) v15(182.47,74.27) v15(183.74,74.27) v15(185.01,74.27) v15(186.28,74.27) v15(187.55,74.27) v15(188.82,74.27) v15(190.09,74.27) v15(191.36,74.27) v15(192.5,75.16) v15(193.39,76.05) v15(194.48,77.11) v15(195.56,77.44) v15(196.32,77.44) v15(197.09,77.44) v15(197.91,77.46) v15(198.67,77.46) v15(199.44,77.46) v15(200.18,77.63) v15(200.35,78.6) v16(108.87,65.76) v16(110.1,56.81) v16(110.52,61.12) v16(110.64,64.51) v16(110.76,67.38) v16(110.8,65.51) v16(111.52,68.03) v16(111.54,55.66) v16(111.61,65.56) v16(111.62,64.13) v16(111.62,63.48) v16(111.62,58.93) v16(112.02,67.4) v16(112.02,54.27) v16(112.06,61.36) v16(112.17,62.3) v16(112.23,51.59) v16(112.44,65.56) v16(112.43,64.08) v16(112.36,58.93) v16(112.49,66.65) v16(112.45,56.39) v16(112.72,68.13) v16(112.81,52.66) v16(113.22,59.58) v16(113.22,57.63) v16(113.23,55.68) v16(113.26,67.39) v16(113.26,65.69) v16(113.61,61.35) v16(113.8,66.25) v16(114.17,58.44) v16(114.33,62.56) v16(115.32,60.98) v16(115.37,68.68) v16(115.37,65.58) v16(115.79,56.36) v16(116.2,61) v16(116.4,67.99) v16(116.42,67.38) v16(116.42,65.44) v16(116.36,64.17) v16(117.14,60.96) v16(117.22,66.17) v16(117.22,58.93) v16(118.02,67.38) v16(117.97,65.51) v16(118.02,64.13) v16(118.03,63.5) v16(117.96,62.66) v16(118.02,59.58) v16(118.02,58.93) v16(118.6,60.84) v16(118.81,58.9) v16(118.78,57.63) v16(118.78,57) v16(118.84,55.73) v16(118.94,62.6) v16(124.34,60.03) v16(125.09,64.83) v16(125.13,62.84) v16(125.11,61.12) v16(125.19,63.31) v16(125.27,55.65) v16(125.37,59.93) v16(125.62,67.49) v16(125.61,66.66) v16(125.62,65.59) v16(125.62,57.63) v16(125.64,56.48) v16(126.21,61.78) v16(126.46,66.65) v16(126.48,59.58) v16(126.51,55.36) v16(126.7,62.87) v16(126.98,61.29) v16(127.25,64.04) v16(127.29,65.58) v16(127.29,60.55) v16(127.38,57.63) v16(127.38,55.05) v16(127.6,68.15) v16(128.04,63.52) v16(127.96,54.65) v16(128.11,65.63) v16(128.09,59.42) v16(128.07,55.83) v16(128.27,45.12) v16(128.26,43.79) v16(128.33,40.59) v16(128.42,46.31) v16(128.51,61.44) v16(128.47,57.19) v16(128.68,41.35) v16(128.82,66.95) v16(128.76,61.04) v16(128.78,43.14) v16(128.94,52.42) v16(129,63.56) v16(129.18,64.63) v16(129.38,52.42) v16(129.64,69.14) v16(129.63,65.48) v16(129.74,64.61) v16(129.69,43.14) v16(129.69,41.85) v16(129.76,61.04) v16(130.45,63.84) v16(130.39,59.73) v16(130.45,57.15) v16(130.61,44.45) v16(130.61,43.71) v16(130.61,43.14) v16(130.61,41.85) v16(130.99,54.31) v16(131.04,45.39) v16(131.28,67.38) v16(131.28,65.45) v16(131.28,63.39) v16(131.33,60.74) v16(131.6,43.85) v16(131.69,61.4) v16(132.05,50.72) v16(132.08,66.08) v16(132.09,63.99) v16(132.06,62.9) v16(132.08,58.92) v16(132.42,44.42) v16(132.44,43.86) v16(132.44,43.24) v16(132.44,42.63) v16(132.49,69.14) v16(132.49,61.31) v16(132.65,60.21) v16(132.85,64.04) v16(132.87,67.4) v16(132.94,58.33) v16(132.96,58.95) v16(133.04,56.42) v16(133.32,60.58) v16(133.32,42.6) v16(133.36,45.01) v16(133.36,44.5) v16(133.35,43.86) v16(133.48,46.65) v16(133.61,62.36) v16(133.58,59.6) v16(133.58,57.62) v16(133.67,56.23) v16(133.84,64.15) v16(133.88,63.44) v16(134.18,43.33) v16(134.39,44.86) v16(134.94,61.9) v16(134.93,59.99) v16(135.21,42.58) v16(135.33,44.87) v16(135.38,69.41) v16(135.77,67.39) v16(135.77,57.43) v16(136.15,65.91) v16(136.1,44.43) v16(136.1,43.86) v16(136.11,43.22) v16(136.1,42.59) v16(136.51,64.6) v16(136.49,45.65) v16(136.63,63.55) v16(136.63,62.11) v16(136.63,60.68) v16(136.68,56.3) v16(137.01,44.23) v16(137.01,43.14) v16(137,41.15) v16(137.38,67.73) v16(137.52,41.51) v16(137.93,44.25) v16(137.93,43.14) v16(138.15,55.41) v16(138.37,41.53) v16(138.84,44.45) v16(138.84,43.71) v16(138.84,43.14) v16(138.88,67.69) v16(139.21,41.56) v16(139.3,65.45) v16(139.38,63.26) v16(139.38,61.7) v16(139.4,60.86) v16(139.43,59.17) v16(139.43,58.32) v16(139.75,44.22) v16(139.76,43.14) v16(140.04,67.13) v16(139.99,55.66) v16(140.06,55.15) v16(140.22,41.55) v16(140.67,44.22) v16(140.67,43.14) v16(141.12,41.83) v16(141.59,44.45) v16(141.59,43.71) v16(141.59,43.14) v16(141.9,41.56) v16(142.03,65.76) v16(142.15,58.2) v16(142.16,60.93) v16(142.5,43.14) v16(142.76,67.37) v16(142.77,57.63) v16(142.83,55.68) v16(142.91,68.78) v16(142.9,60.38) v16(143.42,43.14) v16(143.42,41.85) v16(143.48,62.14) v16(143.61,65.56) v16(143.62,63.48) v16(143.62,59.58) v16(143.62,58.93) v16(143.63,57.53) v16(143.98,41.82) v16(144.33,44.45) v16(144.33,43.71) v16(144.33,43.14) v16(144.43,66.27) v16(144.42,64.13) v16(144.42,58.93) v16(144.52,65.43) v16(144.46,57.54) v16(144.66,41.79) v16(144.94,61.05) v16(145.25,43.14) v16(145.23,41.53) v16(145.32,66.72) v16(145.27,62.11) v16(145.26,57.39) v16(145.31,55.55) v16(145.56,65.42) v16(145.71,58.01) v16(145.93,62.1) v16(145.94,58.75) v16(146.15,45.69) v16(146.16,43.14) v16(146.16,41.85) v16(146.83,62.05) v16(147.08,44.32) v16(147.08,43.71) v16(147.08,43.16) v16(147.07,42.14) v16(147.21,64.06) v16(147.4,48.28) v16(147.5,60.59) v16(147.48,58.77) v16(147.94,66.66) v16(147.99,64.79) v16(147.98,44.26) v16(147.97,43.04) v16(147.99,41.82) v16(148.2,57.61) v16(148.42,63.48) v16(148.41,61.71) v16(148.46,66) v16(148.49,45.71) v16(148.57,41.74) v16(149,43.83) v16(148.97,43.23) v16(149.13,41.76) v16(149.23,58.94) v16(149.21,56.35) v16(149.28,67.24) v16(149.26,65.51) v16(149.28,64.1) v16(149.64,61.44) v16(149.81,45.06) v16(149.82,43.92) v16(149.83,43.25) v16(149.8,42.63) v16(149.79,41.53) v16(149.93,64.97) v16(149.93,56.35) v16(150.03,64.12) v16(150.02,59.58) v16(150.02,58.93) v16(149.97,54.89) v16(150.25,47.92) v16(150.27,41.87) v16(150.75,42.58) v16(150.78,65.38) v16(150.78,57.63) v16(150.79,56.98) v16(151,61.96) v16(151.16,67.65) v16(151.53,43.28) v16(151.53,42.66) v16(151.61,45.45) v16(151.61,44.59) v16(152.54,65.74) v16(152.57,44.45) v16(152.57,43.71) v16(153.45,42.65) v16(153.5,41.63) v16(153.77,67.06) v16(153.89,64.43) v16(153.89,59.35) v16(153.96,62.14) v16(154.4,43.14) v16(154.43,41.46) v16(154.72,67.07) v16(154.9,65.66) v16(155.25,47.67) v16(155.31,44.32) v16(155.31,43.71) v16(155.31,43.14) v16(155.65,41.92) v16(155.87,68.07) v16(156.01,55.42) v16(156.23,43.14) v16(156.37,67.3) v16(156.37,66.71) v16(156.36,65.43) v16(156.42,59.05) v16(156.37,57.5) v16(156.52,55.69) v16(156.6,41.43) v16(156.78,61.24) v16(157.13,66.69) v16(157.1,63.48) v16(157.12,56.79) v16(157.11,45.08) v16(157.13,43.14) v16(157.18,59.6) v16(157.35,58.91) v16(157.43,62.26) v16(157.5,69.37) v16(157.87,64.16) v16(158.03,65.53) v16(158.01,62.9) v16(158.02,60.15) v16(158.11,68.03) v16(158.09,55.06) v16(158.21,61.1) v16(158.33,56.68) v16(158.71,67.37) v16(158.85,65.66) v16(158.81,63.6) v16(158.77,62.25) v16(158.81,59.65) v16(158.85,55.55) v16(158.88,57.39) v16(159.49,59.57) v16(159.66,54.47) v16(159.76,63.33) v16(159.93,61.35) v16(160.18,69.7) v16(160.29,65.76) v16(160.95,63.98) v16(161.06,49.42) v16(161.23,60.78) v16(161.25,59.16) v16(161.61,61.69) v16(162.01,67.38) v16(161.96,65.8) v16(162.01,54.49) v16(162.81,64.06) v16(162.81,59.01) v16(162.82,57.48) v16(162.77,55.69) v16(163.11,61.84) v16(163.35,62.85) v16(163.4,60.2) v16(163.73,63.49) v16(163.72,59.59) v16(163.8,61.32) v16(163.93,58.6) v16(164.41,57.63) v16(164.66,69.44) v16(164.85,61.52) v16(164.96,62.85) v16(165,60.19) v16(165.74,61.23) v16(166.42,58.66) v16(167.59,67.41) v16(168.5,63.13) v16(168.54,58.46) v16(275.18,55.45) v16(275.37,56.97) v16(277.13,63.47) v16(278.61,63.47) v16(278.75,70.51) v16(278.75,70.01) v16(291.95,61.89) v16(292.04,61.16)

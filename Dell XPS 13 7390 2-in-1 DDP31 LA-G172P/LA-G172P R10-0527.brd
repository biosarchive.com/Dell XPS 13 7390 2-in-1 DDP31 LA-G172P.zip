# Allegro board LA-G172P R10-0527.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 212.49,20.39 212.44,20.34 212.44,19.81 212.52,19.73 213.96,19.73 214.04,19.81 214.04,20.34 213.99,20.39
GND on TOP: 149.01,58.81 148.73,58.87 148.64,58.88 148.59,58.96 148.59,58.99 148.62,59.04 148.67,59.03 148.95,59.01 149.1,59.24 149.1,59.29 149.35,59.29 149.35,59.24 149.63,58.99 149.9,59.24 149.9,59.29 150.15,59.29 150.15,59.24 150.36,58.99 150.66,59.11 150.73,59.16 150.81,59.13 150.94,59 151.14,59 151.23,58.99 151.31,59 152.89,59 153.14,59.25 153.14,59.85 153.56,59.85 153.59,59.82 153.59,58.74 153.05,58.74 153.05,58.6 152.59,58.6 152.42,58.43 150.81,58.43 150.69,58.54 150.7,58.57 150.41,58.88 150.16,58.54 150.14,58.45 150.06,58.41 149.19,58.41 149.11,58.45 149.09,58.54
GND on TOP: 129.06,50.46 129.03,50.49 123.44,50.49 122.91,51.03 122.91,52.04 123.1,52.23 128.62,52.23 129,51.85 130.72,51.85 131.52,52.66 133.27,52.66 133.4,52.53 133.4,51.62 133,51.22 133,50.52 132.94,50.46
GND on TOP: 78.76,6.55 79.57,6.55 79.85,6.27 80.64,6.27 80.84,6.07 80.84,5.03 80.74,4.93 78.77,4.93 78.61,5.09 78.61,6.4
GND on TOP: 149.64,74.22 145.97,74.22 145.73,74.45 143,74.45 142.82,74.27 120.66,74.27 119.93,75 119.93,78.17 119.6,78.5 119.6,81.49 119.8,81.49 120.3,81.69 120.5,82.19 120.5,84.35 120.88,85.27 121.8,85.65 144.9,85.65 145.46,85.41 145.7,84.85 145.7,84.25 146.05,83.4 146.9,83.05 149.9,83.05 150.75,83.4 151.1,84.25 151.1,84.85 151.34,85.41 151.9,85.65 171,85.65 171.35,85.6 171.67,85.46 171.67,80.29 171.31,79.93 171.31,75.74 169.77,74.2 149.65,74.2
GND on TOP: 135.35,11.5 139.54,11.5 139.91,11.14 141.75,11.14 141.83,11.21 141.83,11.43 141.7,11.56 141.19,11.56 141.07,11.68 140.71,11.68 140.57,11.81 140.57,12.12 140.31,12.39 139.89,12.39 139.75,12.53 139.65,12.53 139.19,12.99 138.67,12.99 138.54,13.12 138.54,13.59 138.37,13.75 137.25,13.75 136.94,13.44 135.42,13.44 135.15,13.17 135.15,11.71
GND on TOP: 201.1,11.44 201.16,11.38 201.16,9.83 201.1,9.76 198.43,9.76 197.8,9.13 196.6,9.13 196.43,9.31 196.43,12.18 196.58,12.33 197.31,12.33 197.47,12.18 197.47,11.64 197.67,11.44
GND on TOP: 163.47,13.36 154.15,13.36 154.07,13.28 154.07,11.45 154.22,11.3 163.44,11.3 163.62,11.12 163.62,10.54 163.67,10.49 164.38,10.49 164.46,10.56 164.46,15.5 164.44,15.52 163.71,15.52 163.6,15.41 163.6,13.49
GND on TOP: 216.92,23.57 216.92,28.42 217.61,29.11 218.96,29.11 219.18,29.34 219.92,29.34 220.1,29.16 220.1,28.37 220.28,28.19 220.28,26.11 218.7,24.53 218.7,23.38 218.56,23.24 217.25,23.24
GND on TOP: 81.12,68.98 85.62,68.98 85.85,69.21 85.85,70.64 85.74,70.74 81.22,70.74 81.02,70.53 81.02,69.09
GND on TOP: 11.15,7.34 10.95,7.53 10.95,8.1 11.08,8.23 14.51,8.23 14.64,8.1 14.64,7.47 14.51,7.34
GND on TOP: 79.57,28.47 79.57,30.22 80.08,30.73 82.27,30.73 82.44,30.91 82.44,37.67 82.72,37.95 86.56,37.95 86.89,38.28 86.89,41.22 86.74,41.38 82.7,41.38 82.29,40.97 79.73,40.97 79.55,40.79 79.55,33.83 79.57,33.81 78.4,32.64 73.96,32.64 73.48,32.15 73.48,28.42 73.58,28.32 79.39,28.32 79.55,28.47
GND on TOP: 73.65,54.61 74.16,54.61 74.26,54.71 74.26,58.09 74.19,58.16 73.63,58.16 73.58,58.11 73.58,54.68
GND on TOP: 121.27,25.33 121.32,25.28 122.16,25.28 122.16,25.28 122.52,24.92 122.64,24.92 123.01,25.28 123.13,25.28 124.3,26.45 124.3,26.71 124.18,26.83 123.6,26.83 123.29,26.52 121.36,26.52 121.27,26.43
GND on TOP: outline of 128 points within 280.15,8.68 286.39,18.43
GND on TOP: 105.32,55.98 105.38,56.04 105.38,58.65 105.25,58.77 104.49,58.77 104.3,58.58 104.3,56.27 104.59,55.98
GND on TOP: 25.94,5.56 27.46,5.56 27.59,5.43 27.59,4.93 27.46,4.8 25.94,4.8 25.81,4.93 25.81,5.43
GND on TOP: 96.06,61.49 95.97,61.58 95.97,63.13 96.28,63.44 96.28,67.4 96.5,67.62 97.89,67.62 98.44,67.07 98.44,66.42 98.43,66.41 98.43,66.22 98.56,66.09 99.55,66.09 99.68,65.96 99.68,65.08 99.59,65 98.59,65 98.4,64.81 98.4,64.38 98.41,64.37 98.41,62.5 97.4,61.49
GND on TOP: 210,21.82 211.2,21.82 212.08,22.71 214.6,22.71 214.66,22.77 214.66,23.72 214.6,23.79 214.28,23.79 213.59,24.48 213.39,24.48 213.38,24.48 211.2,24.48 210.78,24.06 210,24.06 209.87,23.94 209.87,21.94
GND on TOP: 28.16,1.43 28.42,1.69 30.32,1.69 30.77,2.13 30.77,4.99 30.89,5.12 32.2,5.12 33.01,5.93 33.65,5.93 33.97,6.25 33.97,6.67 34.18,6.88 34.18,7.27 35.42,8.51 40.81,8.51 41.23,8.09 41.23,3.75 42.1,2.88 42.1,2.87 42.14,2.83 42.14,1.77 42.08,1.7 33.97,1.7 33.47,1.5 33.18,0.79 32.97,0.7 28.24,0.7 28.16,0.78
GND on TOP: 261.67,2.54 261.49,2.36 260.07,2.36 259.94,2.49 259.94,5.32 260.13,5.51 261.49,5.51 261.67,5.33
GND on TOP: 286.31,21.26 291.14,21.26 291.46,20.94 291.46,19.85 291.18,19.57 286.65,19.57 286.09,20.13 286.09,21.03
GND on TOP: 74.16,70.29 74.52,70.65 75.34,70.65 75.47,70.78 75.47,71.41 75.36,71.52 73.38,71.52 73.17,71.32 73.17,65.84 73.3,65.72 74.03,65.72 74.16,65.85
GND on TOP: 153.97,6.5 172.84,6.5 173.1,6.25 173.1,4.6 172.38,3.88 154.05,3.88 153.64,4.29 153.64,6.17
GND on TOP: 198.43,37.68 203.02,37.68 203.09,37.61 203.09,36.99 203.01,36.91 201.86,36.91 201.46,36.51 201.46,34.63 201.42,34.59 200.09,34.59 199.97,34.71 199.97,36.74 199.8,36.91 198.48,36.91 198.36,37.02 198.36,37.61
GND on TOP: 267.23,8.15 265.68,8.15 265.6,8.08 265.6,7.49 265.7,7.39 267.2,7.39 267.33,7.52 267.33,8.05
GND on TOP: 166.19,22.29 166.73,22.29 166.76,22.27 166.76,19.31 166.72,19.27 166.22,19.27 166.18,19.32 166.18,22.28
GND on TOP: 153.97,22.33 154.31,22.33 154.35,22.28 154.35,20.55 154.21,20.41 152.13,20.41 151.62,19.9 150.8,19.9 150.79,19.88 150.79,19.53 150.55,19.3 149.93,19.3 149.89,19.34 149.89,20.93 149.97,21.02 151.6,21.02 151.94,21.35 153.57,21.35 153.81,21.59 153.81,22.16
GND on TOP: 122.28,36.13 122.26,36.1 122.26,35.44 122.31,35.39 123.15,35.39 123.27,35.27 125.51,35.27 125.62,35.38 125.62,35.63 124.82,36.43 123.57,36.43 123.26,36.13
GND on TOP: 283.95,2.77 283.83,2.89 280.4,2.89 280.3,2.79 280.3,2.2 280.32,2.17 280.32,2.13 280.45,2.01 286.16,2.01 286.42,2.26 286.42,2.64 286.29,2.77
GND on BOTTOM: 199.3,37.63 203.36,37.63 203.42,37.69 203.42,38.49 203.34,38.57 199.32,38.57 199.25,38.5 199.25,37.67
GND on BOTTOM: 113.02,73.65 113.02,81.49 119.8,81.49 120.3,81.69 120.5,82.19 120.5,84.35 120.88,85.27 121.8,85.65 144.9,85.65 145.46,85.41 145.7,84.85 145.7,84.25 146.05,83.4 146.9,83.05 149.9,83.05 150.75,83.4 151.1,84.25 151.1,84.85 151.34,85.41 151.9,85.65 170.29,85.65 170.29,73.89 170.05,73.65 ; 2 cut-outs
GND on BOTTOM: outline of 120 points within 187.82,9.98 223.7,30.58
GND on BOTTOM: 182.2,57.37 181.38,57.37 178.33,54.32 178.33,54.3 177.13,53.1 173.29,53.1 172.37,52.18 168.85,52.18 168.45,52.59 168.45,54.54 168.54,54.63 170.08,54.63 170.71,55.26 170.71,55.46 172.97,57.72 175.11,57.72 175.14,57.8 175.15,57.88 175.15,57.93 177.98,57.93 178.03,57.99 178.16,57.99 178.18,57.93 178.16,57.9 178.27,57.54 178.57,57.76 178.57,57.79 178.77,57.99 178.99,57.99 178.99,58.76 179.61,58.76 180.45,57.92 181.28,57.92 181.91,58.07 181.28,58.21 180.57,58.21 179.73,59.04 178.99,59.04 178.99,59.18 177.82,59.18 177.82,58.22 174.98,58.22 174.94,58.18 174.91,58.18 174.63,58.1 174.55,57.82 174.49,57.82 174.45,57.85 174.32,57.98 174.32,64.41 174.49,64.58 175.97,64.58 176.35,64.21 176.35,63.09 176.51,62.92 176.51,62.56 176.88,62.2 177.06,62.38 177.06,62.41 176.85,62.63 176.85,62.8 176.99,62.94 177.63,62.94 177.63,62.02 179.3,60.35 181.88,60.35 182.2,60.03
GND on BOTTOM: 123.91,7.45 125.32,7.45 125.51,7.27 125.51,4.79 125.39,4.67 125.05,4.67 124.71,5.01 124.01,5.01 123.84,5.19 123.84,7.38
GND on BOTTOM: 209.48,25.49 209.79,25.82 209.79,25.87 211.96,25.87 212.05,25.8 212.03,25.69 211.94,25.32 212.26,25.11 212.26,22.84 211.47,22.06 211.47,18 211.28,17.8 202.13,17.8 198.97,20.97 198.97,27.32 199.59,27.94 205.29,27.94 205.68,28.33 205.68,28.98 205.74,29.07 205.85,29.06 207.11,29.06 207.22,28.95 207.22,27.39 207.45,27.15 208.26,27.15 208.58,26.84 208.58,26.53 207.58,25.54 207.55,25.56 207.45,25.6 207.34,25.59 207.26,25.59 207.21,25.66 207.06,25.88 206.81,25.96 206.13,25.96 205.95,25.92 205.81,25.81 205.77,25.79 205.73,25.81 205.7,25.85 205.68,25.91 205.7,25.98 205.69,26.43 205.24,26.45 205.17,26.42 205.1,26.45 204.65,26.43 204.64,25.98 204.66,25.91 204.64,25.85 204.65,25.39 205.1,25.38 205.17,25.4 205.24,25.38 205.44,25.3 205.65,25.36 205.72,25.37 205.79,25.33 205.81,25.3 205.84,25.27 205.86,25.16 205.77,25.09 203.89,25.09 203.68,25.3 203.68,25.32 203.11,25.54 203.34,24.98 203.36,24.98 203.7,24.64 207.77,24.64 208.96,25.83 209.06,25.85 209.13,25.77
GND on BOTTOM: 14.38,25.31 14.64,25.31 16.92,23.02 16.92,22.2 14.57,19.85 13.75,19.85 11.4,22.2 11.4,22.33
GND on BOTTOM: 53.47,1 53.47,4 66.54,4 66.54,1 55.28,1 55.13,1.06 54.97,1 54.02,1 53.85,1.07 53.69,1
GND on GND1: 91.33,57.89 90.77,58.45 90.77,64.06 91.08,64.36 95.04,64.36 95.22,64.18 95.22,58.32 94.79,57.89
GND on GND1: outline of 292 points within 0.2,0.2 293,85.65 ; 3 cut-outs
GND on IN1: 142.84,0.7 142.84,1.69 143.1,1.94 149.77,1.94 150.02,1.69 150.02,0.86 149.86,0.7
GND on IN1: 90.94,68.82 87.04,72.72 75.34,72.72 75.24,72.82 75.24,73.09 76.61,74.46 107.17,74.46 108.25,73.38 112.72,73.38 113.08,73.73 127.87,73.73 128.24,73.37 135.03,73.37 135.9,74.23 138.44,74.23 139.29,75.08 139.8,75.08 139.96,74.92 140.79,74.92 140.9,75.03 140.9,76.3 140.61,76.59 140.61,76.8 140.69,76.87 142.39,76.87 143.71,78.19 158.31,78.19 160.95,80.83 166.65,80.83 167.45,80.03 167.45,72.95 167.6,72.81 167.69,72.81 169.01,71.48 165.86,71.48 164.33,73 162.4,73 161.73,73.67 154.04,73.67 153.49,73.11 143.75,73.11 143.57,73.29 135.59,73.29 135.15,72.86 123.87,72.86 123.72,72.7 108.1,72.7 107.14,73.66 97.59,73.66 92.75,68.82
GND on IN1: outline of 119 points within 107.67,38.99 170.9,71.23 ; 6 cut-outs
GND on IN1: outline of 141 points within 69.04,67.23 223.16,85.65
GND on IN1: outline of 243 points within 169.67,43.26 195.93,74.42 ; 6 cut-outs
GND on IN1: 39.78,16.86 39.09,17.56 39.09,20.37 49.1,19.74 58.46,23.34 59.19,23.68 60,23.8 61.12,23.8 61.54,23.87 61.9,24.09 65.49,27.94 68.19,32.45 68.27,33.24 67.84,33.91 67.56,34.32 67.58,34.81 68.68,38.83 69.04,42.97 69.04,77.32 73.25,77.32 73.5,77.06 73.5,73.89 70.14,70.52 70.14,19.79 69.57,19.21 66.01,19.21 65.5,18.71 51.47,18.71 50.58,17.82 46.32,17.82 45.37,16.86
GND on IN1: 88.23,1.43 89.63,2.83 91.16,2.83 92.11,1.88 108.87,1.88 109.32,1.43 111.73,1.43 113.51,3.21 117.76,3.21 119.35,1.62 139.8,1.62 140.24,1.18 140.24,0.74 140.21,0.7 75.07,0.7 74.64,0.63 74.02,0.26 73.74,0.2 72.41,0.2 72.3,0.31 72.3,0.62 73.12,1.43
GND on IN1: 88.54,58.32 91.97,58.32 92.36,57.92 92.36,54.32 91.99,53.95 88.54,53.95 88.04,54.44 88.04,57.82
GND on IN1: 219.06,0.2 218.78,0.25 218.16,0.63 217.73,0.7 152.72,0.7 152.5,0.93 152.5,1.69 152.75,1.94 158.59,1.94 159.04,1.5 210.98,1.5 212.31,2.83 219.11,2.83 219.65,2.29 219.65,0.26 219.59,0.2
GND on IN1: 83.81,59.26 83.46,59.61 83.46,63.53 83.76,63.83 88.08,63.83 88.37,63.54 88.37,59.48 88.15,59.26
GND on IN1: 66.66,0.2 66.38,0.25 65.76,0.63 65.33,0.7 52.97,0.7 52.76,0.79 52.47,1.5 51.97,1.7 47.94,1.7 47.94,6.18 48.75,6.98 53.68,6.98 57.01,3.66 61.37,3.66 62.07,4.35 66.39,4.35 67.72,3.02 67.72,0.99 68.17,0.54 68.17,0.23 67.53,0.23 67.51,0.25 67.47,0.2
GND on GND2: outline of 285 points within 0.2,0.2 293,85.65 ; 2 cut-outs
GND on VCC: 283.81,64.59 281.91,66.5 281.91,69.97 282.4,70.46 285.93,70.46 285.93,69.13 286.15,68.67 286.65,68.54 286.89,68.64 287.07,68.85 287.09,68.89 287.1,68.93 292.6,68.93 292.6,67.9 292.36,67.34 291.8,67.1 291.7,67.1 291.2,66.9 291,66.4 291,63.4 291,63.37 291.21,62.89 291.7,62.7 292.2,62.7 292.76,62.46 293,61.9 293,60.6 290,60.6 290,60.8 288.55,60.8 288.55,60.6 283.81,60.6
GND on VCC: 69.04,74.52 69.04,78.74 71.79,81.49 119.8,81.49 120.21,81.62 120.47,81.96 120.5,81.96 120.5,84.35 120.88,85.27 121.8,85.65 144.9,85.65 145.46,85.41 145.7,84.85 145.7,84.25 146.05,83.4 146.9,83.05 149.9,83.05 150.75,83.4 151.1,84.25 151.1,84.85 151.34,85.41 151.9,85.65 171,85.65 171.92,85.27 172.3,84.35 172.3,82.19 172.5,81.69 173,81.49 179.94,81.49 179.94,78.08 192.71,78.08 192.71,81.19 195.22,81.19 195.22,78.74 211.09,78.74 211.09,78.08 216.6,78.08 216.6,78.74 221,78.74 221,78.08 223.79,78.08 223.79,74.52
GND on VCC: 4.03,43.45 3.69,43.64 3.3,43.7 2.2,43.7 2.2,49.85 2,50.35 1.5,50.55 0.65,50.55 0.65,51.75 0.53,52.15 0.2,52.41 0.2,57.63 5.7,57.63 5.89,57.36 6.19,57.23 6.19,49.23 4.03,47.07 4.03,44.54
GND on VCC: 101.93,21.44 101.44,21.92 101.44,25.65 101.8,26.01 105.48,26.01 105.89,26.41 105.89,32.03 105.99,32.3 105.89,32.57 105.89,36.27 105.1,37.06 101.8,37.06 101.32,37.54 101.32,40.97 100.66,41.63 93.04,41.63 92.55,42.12 92.55,42.14 91.54,43.15 91.54,45.19 91.79,45.44 108.33,45.44 108.59,45.33 108.85,45.44 126.56,45.44 126.56,45.43 126.56,45.06 126.51,45.01 122.95,45.01 120.21,42.26 111.38,42.26 110.46,41.35 110.46,21.92 109.97,21.44
GND on VCC: 278.23,0.7 278.23,15.36 279.28,16.42 292.6,16.42 292.6,14.6 291.4,14.6 290.55,14.25 290.2,13.4 290.2,10.4 290.55,9.55 291.4,9.2 292.6,9.2 292.6,1.5 292.36,0.94 291.8,0.7
GND on VCC: outline of 81 points within 0.2,52.77 28.7,77
GND on VCC: 279.89,76.8 279.9,76.91 279.9,77.01 279.9,79.19 279.96,79.49 280.14,79.75 280.75,80.36 281.01,80.75 281.1,81.21 281.1,81.8 281.1,81.85 281.35,82.38 281.9,82.6 283.4,82.6 284.25,82.95 284.6,83.8 284.6,85 284.63,85.07 284.7,85.1 287.6,85.1 290.3,84.31 292.14,82.18 292.48,81.17 292.6,80.1 292.6,78.77 287.1,78.77 286.43,79.16 285.93,78.57 285.93,76.8
GND on IN2: outline of 154 points within 211.04,18.64 293,85.1 ; 2 cut-outs
GND on IN2: outline of 115 points within 39.09,16.93 223.16,85.65
GND on IN2: 99.02,74.23 91.13,74.23 89.03,72.13 89.03,70.14 89.48,69.7 95,69.7 99.13,73.82 99.13,74.12
GND on IN2: 192.74,74.33 220.54,74.33 222.32,72.55 222.32,66.44 221.97,66.09 218.73,66.09 218.18,65.54 217.14,65.54 215.05,67.63 215.05,72.29 213.89,73.45 210.53,73.45 209.48,72.4 209.48,71.49 208.34,70.35 208.34,69.56 208.04,69.26 205.5,69.26 204.95,68.71 201.22,68.71 200.34,69.59 198.42,69.59 197.74,68.92 196.6,68.92 196.42,68.74 194.53,68.74 194.27,69 193.09,69 192.89,69.19 192.89,73.09 192.22,73.76 192.22,74.42 192.65,74.42
GND on IN2: 183.2,70.32 189.31,70.32 189.47,70.17 189.47,69.29 189.38,69.2 183.17,69.2 183.06,69.3 183.06,70.18
GND on IN2: 142.46,0.7 142.46,1.24 143.29,2.07 149.51,2.07 149.83,1.75 149.83,0.7
GND on IN2: 219.06,0.2 218.78,0.25 218.16,0.63 217.73,0.7 152.53,0.7 152.5,0.74 152.5,0.99 152.88,1.37 178.15,1.37 181.58,4.8 184.12,4.8 186.91,2.01 216.95,2.01 218.47,3.53 219.51,3.53 219.59,3.45 219.59,0.24 219.55,0.2
GND on IN2: 77.47,2.74 77.76,3.02 78.58,3.02 80.11,1.5 93.06,1.5 94.01,2.45 94.84,2.45 95.73,1.56 129.57,1.56 130.14,2.13 139.1,2.13 139.42,1.81 139.42,0.7 77.85,0.7 77.47,1.08
GND on IN2: 128.07,80.01 130.81,80.01 133.44,77.38 139.86,77.38 143.59,73.65 143.59,72.5 143.49,72.4 123.12,72.4 122.91,72.62 122.91,73.87 127.88,78.85 127.88,79.82
GND on IN2: 88.06,70.64 73.73,70.64 71.65,68.55 71.65,24.9 71.7,24.85 71.7,23.37 66.81,18.48 66.81,17.54 67.42,16.93 78.89,16.93 79.74,16.08 84.3,16.08 84.7,16.48 84.7,20.6 84.78,20.67 86.63,20.67 88.46,22.5 88.46,48.69 90.62,50.85 94.94,50.85 95.09,51 95.09,54.6 95.11,54.62 95.11,54.78 95.99,55.66 95.99,63.03 97.37,64.41 98.27,64.41 98.68,64.82 98.68,66.19 98.68,66.19 98.68,66.22 102.29,69.83 102.29,71.16 101.68,71.77 100.17,71.77 98.99,70.59 98.99,70.52 97.82,69.35 89.34,69.35 ; 1 cut-out
GND on GND3: outline of 290 points within 0.2,0.2 293,85.65 ; 1 cut-out
GND on IN3: 190.29,64.25 173.55,64.25 173.49,64.2 173.49,63.79 173.81,63.48 173.81,61.49 176.09,59.21 179.24,59.21 179.9,58.56 179.9,58 180.28,57.62 181,57.62 181.06,57.56 190.28,57.56 190.7,57.98 190.7,61.17 190.75,61.22 190.75,63.8
GND on IN3: 87.7,67.23 87.09,67.84 73.87,67.84 73.4,67.37 73.4,60.84 75.34,58.9 85.33,58.9 89.61,54.62 98.3,54.62 99.76,53.16 101.73,53.16 103.84,55.27 103.84,62.79 103.54,63.09 96.7,63.09 96.37,63.42 96.37,67.03 96.17,67.23
GND on IN3: 138.46,0.7 138.46,1.43 138.97,1.94 139.86,1.94 139.96,1.84 139.96,1.38 140.19,1.15 140.4,1.15 140.4,0.7
GND on IN3: 166.86,83.98 169.37,83.98 170.28,83.07 170.28,79.92 170.2,79.84 169.66,79.84 168,81.5 168,82.62 166.81,83.81 166.81,83.92
GND on IN3: 73.12,0.2 73.12,2.77 73.5,3.15 87.79,3.15 89.31,1.62 97.25,1.62 97.48,1.4 97.48,0.7 75.07,0.7 74.64,0.63 74.02,0.26 73.74,0.2
GND on IN3: 105.02,53.01 105.02,55.58 105.28,55.84 107.17,55.84 107.47,55.54 107.47,53.17 107.14,52.84 105.19,52.84
GND on IN3: outline of 132 points within 69.67,68.74 223.16,85.65 ; 1 cut-out
GND on IN3: outline of 178 points within 211.04,18.64 292.6,85.1 ; 2 cut-outs
GND on IN3: 183.01,66.51 189.07,66.51 189.19,66.39 189.19,66.04 189.08,65.93 183.01,65.93 182.96,65.97 182.96,66.46
GND on IN3: outline of 105 points within 104.5,40.36 169.39,74.67
GND on IN3: 283.05,10.83 281.4,10.83 281.21,11.02 281.21,16.04 281.46,16.29 283.5,16.29 284.51,15.28 284.51,12.29
GND on IN3: 39.09,17.78 39.09,20.37 49.1,19.74 58.46,23.34 59.19,23.68 60,23.8 61.12,23.8 61.54,23.87 61.9,24.09 65.49,27.94 68.19,32.45 68.27,33.24 67.84,33.91 67.56,34.32 67.58,34.81 68.68,38.83 69.04,42.97 69.04,77.32 73.25,77.32 73.5,77.06 73.5,73.89 69.95,70.33 69.95,27.85 66.92,27.85 61.94,22.86 59.8,22.86 57.75,20.81 57.75,17.65 56.97,16.86 51.73,16.86 51.2,17.39 39.47,17.39
GND on IN3: 140.79,76.8 144.83,72.75 144.83,71.82 144.61,71.6 139.22,71.6 137.85,72.98 126.4,72.98 126.29,73.09 126.29,74.38 129.47,77.55 132.54,77.55 132.74,77.35 132.74,76.87 132.82,76.8
GND on IN3: 66.66,0.2 66.38,0.25 65.76,0.63 65.33,0.7 52.97,0.7 52.76,0.79 52.47,1.5 51.97,1.7 49.91,1.7 49.85,1.76 49.85,2.98 50.01,3.14 53.32,3.14 53.48,2.99 56.49,2.99 57.46,3.96 61.36,3.96 61.88,4.48 66.9,4.48 67.22,4.16 67.22,0.2
GND on IN3: 219.06,0.2 218.78,0.25 218.53,0.4 218.16,0.63 217.73,0.7 152.69,0.7 152.69,1.24 153.32,1.88 177.77,1.88 179.61,3.72 196.37,3.72 198.28,5.62 203.74,5.62 205.71,3.66 215.49,3.66 217.39,5.56 219.23,5.56 219.93,4.86 219.93,1.06 219.62,0.75 219.62,0.34 219.49,0.2
GND on IN3: 142.46,0.8 142.46,1.62 142.84,2.01 149.64,2.01 149.69,1.95 149.69,0.7 142.56,0.7
GND on GND4: outline of 283 points within 0.2,0.2 293,85.65 ; 1 cut-out
VIN_AUX on TOP (solid shape): 135.02,12.22 135.02,11.56 135.22,11.35 139.49,11.35 139.82,11.02 141.64,11.02 141.76,10.9 141.76,9.69 141.64,9.56 140.05,9.56 139.16,8.67 136.3,8.67 135.86,8.23 135.86,7.91 135.67,7.72 130.75,7.72 130.4,8.08 130.4,12.55 130.65,12.8 134.44,12.8
VIN_AUX on IN1 (solid shape): 139.92,11.02 141.64,11.02 141.76,10.9 141.76,9.69 141.64,9.56 140.18,9.56 139.29,8.67 136.75,8.67 135.54,7.47 130.91,7.47 130.72,7.66 130.72,9.12 131.29,9.69 134.4,9.69 136.24,11.53 139.42,11.53
VIN_AUX on IN2 (solid shape): 141.89,10.77 141.89,9.05 141.51,8.67 137.51,8.67 137.26,8.93 137.26,10.77 137.51,11.02 141.64,11.02
+BATT on TOP (solid shape): 52.8,7.61 52.8,5.43 53.06,5.18 54.2,5.18 54.45,4.93 54.45,3.36 53.98,2.89 45,2.89 44.85,3.04 44.85,4.74 44.91,4.79 44.91,5.68 49.33,5.68 49.34,5.6 49.35,5.52 49.37,5.44 49.4,5.37 49.44,5.3 49.48,5.23 49.53,5.17 49.59,5.11 49.65,5.06 49.71,5.02 49.78,4.98 49.86,4.95 49.93,4.92 50.01,4.91 50.09,4.9 50.17,4.9 50.25,4.91 50.33,4.92 50.4,4.95 50.48,4.98 50.55,5.02 50.61,5.06 50.67,5.11 50.73,5.17 50.78,5.23 50.82,5.3 50.86,5.37 50.89,5.44 50.91,5.52 50.92,5.6 50.93,5.68 50.93,5.76 50.92,5.84 50.9,5.92 50.88,5.99 50.84,6.07 50.8,6.13 50.76,6.2 50.7,6.26 50.64,6.31 50.58,6.36 50.51,6.4 50.44,6.44 50.37,6.47 50.29,6.48 50.21,6.5 50.13,6.5 50.05,6.5 49.97,6.48 49.89,6.47 49.82,6.44 49.75,6.4 49.68,6.36 49.62,6.31 49.56,6.26 49.5,6.2 49.46,6.13 49.42,6.07 49.38,5.99 49.36,5.92 49.34,5.84 49.33,5.76 49.33,5.68 44.91,5.68 44.91,8.38 45.2,8.67 51.74,8.67
+BATT on BOTTOM (solid shape): 101.7,7.61 86.7,7.61 86.7,17.61 101.7,17.61
+BATT on TOP: 105.89,22.15 104.41,22.15 103.98,22.58 103.98,23.47 103.86,23.6 101.06,23.6 100.87,23.4 100.87,21.5 101.16,21.21 101.16,16.25 101.19,16.23 101.19,14.32 101.44,14.07 106.27,14.07 107.26,15.06 107.26,20.78
+BATT on BOTTOM: 75.05,2.23 72.01,5.28 67.25,5.28 66.26,4.29 53.48,4.29 52.54,3.35 46.27,3.35 45.5,4.12 45.5,13.69 47.28,15.47 56,15.47 56.51,15.98 58.16,15.98 59.06,16.87 85.32,16.87 89.73,21.28 93.25,21.28 95.57,23.6 103.92,23.6 104.24,23.28 104.24,19.98 103.6,19.34 103.6,4.16 101.67,2.23
+CAM_PWR on TOP (solid shape): 170.91,72.55 170.91,71.28 171.23,70.97 171.23,70.33 169.77,70.33 169.39,70.71 169.39,72.43 169.58,72.62 170.85,72.62
+CAM_PWR on TOP (solid shape): 168.59,84.19 168.59,83.48 168.66,83.41 168.95,83.41 169.12,83.24 169.12,82.91 169.02,82.81 167.72,82.81 166.99,83.54 166.99,84.2 167.07,84.27 168.51,84.27
+CAM_PWR on BOTTOM (solid shape): 169.58,83.29 169.58,81.06 169.34,80.82 166.85,80.82 166.82,80.85 166.82,81.27 167.03,81.48 167.38,81.48 167.65,81.75 167.65,83.07 168.05,83.48 169.39,83.48
+CAM_PWR on IN1: 170.21,72.17 170.34,72.3 170.34,74.2 169.45,75.09 169.45,83.16 169.26,83.35 167.99,83.35 167.67,83.03 167.67,79.61 167.4,79.34 167.4,79.15 167.67,78.87 167.67,73.13 168.63,72.17
+CAM_PWR_R on TOP (solid shape): 169.7,70.2 170.17,70.2 170.25,70.13 170.25,69.62 170.28,69.58 171.25,69.58 171.29,69.54 171.29,68.93 171.23,68.87 169.26,68.87 169.01,69.12 169.01,70.2 169.13,70.33 169.58,70.33
+CHG_SRC_20V on TOP: 79.95,24.26 80.28,24.59 81.91,24.59 82.32,24.99 82.32,29.28 82.06,29.54 81.58,29.54 81.2,29.16 81.2,28.8 81.22,28.78 81.1,28.65 80.31,28.65 79.9,28.24 73.48,28.24 72.49,27.25 72.49,25.3 73.5,24.28 73.5,24.26
+CHG_VIN_20V on TOP (solid shape): 13.41,17.06 13.41,17 12.76,16.35 12.76,16.08 13.18,15.66 13.18,15.22 11.6,13.63 11.34,13.63 10.46,14.52 10.46,15.02 10.59,15.15 10.59,15.15 10.81,15.38 12.92,17.49 12.98,17.49
+CHG_VIN_20V on TOP (solid shape): 277.58,12.28 278.78,12.28 278.85,12.22 278.85,11.71 278.78,11.65 277.9,11.65 277.07,10.82 274.4,10.82 274.34,10.89 274.34,12.09 274.53,12.28 276.56,12.28 276.69,12.41 276.69,12.54 276.82,12.66 277.2,12.66
+CHG_VIN_20V on IN1 (solid shape): 277.71,12.16 277.71,11.34 277.39,11.02 276.77,11.02 276.51,10.77 276.32,10.77 276.26,10.83 275.8,10.83 275.36,11.28 275.36,12.02 276,12.66 277.2,12.66
+CHG_VIN_20V on IN1 (solid shape): 10.64,15.15 11.4,15.15 12.35,14.19 12.35,12.74 11.82,12.21 10.62,12.21 9.91,12.91 9.91,13.82 10.32,14.22 10.32,14.85 10.63,15.16
+CHG_VIN_20V on TOP: 72.38,8.39 72.38,17.6 72.51,17.73 73.07,17.73 73.27,17.93 73.27,18.24 73.43,18.39 75.99,18.39 76.14,18.24 76.14,13.9 77.06,12.99 77.06,6.96 76.49,6.39 74.39,6.39
+CHG_VIN_20V on BOTTOM: 129.79,6.09 129,5.31 129,2.64 129.79,1.85 198.7,1.85 199.11,2.26 199.11,4.74 198.53,5.31 184.95,5.31 184.16,6.09
+CHG_VIN_20V on VCC: 66.72,1.17 66.07,1.54 65.33,1.67 57.67,1.67 57.67,1.67 53.5,1.67 52.88,2.4 51.97,2.67 33.97,2.67 33.06,2.4 32.44,1.67 30.54,1.67 30.54,1.67 10.76,1.67 10.76,8.97 9.62,10.11 9.62,14.79 10.17,15.34 12.14,15.34 13.92,17.12 18.41,17.12 18.89,16.63 18.89,14.16 20.06,12.99 30.13,12.99 30.13,7.17 30.92,6.39 39.81,6.39 39.89,6.47 39.91,6.47 41.49,8.05 82.34,8.05 84.32,6.07 212.04,6.07 218.01,12.04 224.91,12.04 230.62,6.32 270.33,6.32 270.86,6.85 270.86,14.35 271.22,14.71 277.61,14.71 277.72,14.6 277.72,1.67 265.39,1.67 265.39,1.67 260.58,1.67 259.96,2.4 259.05,2.67 243.25,2.67 242.34,2.4 241.72,1.67 240.13,1.67 240.13,1.67 227.47,1.67 226.73,1.54 226.08,1.17 219.12,1.17 218.47,1.54 217.73,1.67 75.07,1.67 74.33,1.54 73.68,1.17
+CHG_VIN_20V on IN2: 66.72,1.17 66.07,1.54 65.33,1.67 53.68,1.67 52.67,2.68 32.38,2.68 31.72,3.34 31.72,6.39 32.04,6.7 33.75,6.7 34.89,7.85 54.13,7.85 55.02,8.74 76.42,8.74 77.06,8.1 77.06,2.39 76.34,1.67 75.07,1.67 74.33,1.54 73.68,1.17
+INV_PWR_SRC on TOP (solid shape): 126.2,84.24 126.2,82.13 125.9,81.82 124.61,81.82 124.48,81.95 124.48,84.05 124.73,84.3 126.14,84.3
+INV_PWR_SRC on TOP (solid shape): 99.85,71.41 99.85,69.63 99.68,69.45 98.59,69.45 98.17,69.87 97.58,69.87 97.25,70.2 97.25,71.16 97.57,71.47 99.79,71.47
+INV_PWR_SRC on BOTTOM (solid shape): 125.96,83.02 125.96,82.9 126.65,82.22 126.65,82.07 126.65,82.06 126.65,81.69 126.88,81.46 126.88,79.98 126.76,79.86 126.46,79.86 126.46,79.86 125.95,79.86 125.65,80.15 125.65,80.49 124.81,81.33 124.81,81.85 124.21,82.45 124.21,82.86 124.58,83.22 125.76,83.22
+INV_PWR_SRC on IN2 (solid shape): 98.97,71.6 98.97,70.46 98.71,70.2 97.38,70.2 97.25,70.33 97.25,71.47 97.95,72.17 98.39,72.17
+INV_PWR_SRC on IN2 (solid shape): 126.18,82.87 126.18,81.26 124.98,80.07 124.53,80.07 124.21,80.38 124.21,82.55 124.85,83.19 125.86,83.19
+INV_PWR_SRC on TOP: 90.01,68.05 89.88,67.93 89.88,66.43 89.98,66.34 91.71,66.34 91.82,66.45 91.82,67.87 91.64,68.05
+INV_PWR_SRC on IN1: 103.12,68.84 102.19,69.77 102.19,71.22 102.34,71.36 103.48,71.36 103.73,71.11 103.73,70.66 104.52,69.88 104.52,69.46 103.9,68.84
+INV_PWR_SRC on IN1: 95.87,69.7 96.84,69.7 97.08,69.45 97.33,69.45 97.81,68.97 98.23,68.97 98.47,68.74 98.47,68.2 99.02,67.65 101.62,67.65 101.81,67.46 101.81,66.22 101.71,66.11 99.23,66.11 98.88,66.46 98.88,66.75 97.57,68.06 96.06,68.06 94.98,66.98 94.98,66.98 94.03,66.03 94.02,66.03 93.69,65.7 90.21,65.7 89.97,65.95 89.97,67.12 90.11,67.26 93.43,67.26
+INV_PWR_SRC on IN2: 101.52,73.57 103.95,73.57 104.78,72.74 104.78,72.01 103.25,70.48 102.52,70.48 102.4,70.6 102.4,71.27 101.27,72.41 101.27,73.32
+INV_PWR_SRC_R on TOP: 100.65,72.42 102.17,72.42 102.31,72.28 102.31,70.69 103.03,69.96 103.03,66.43 102.63,66.03 101.43,66.03 101.12,66.33 101.12,69.77 100.4,70.5 100.4,72.17
+LCDVDD on TOP (solid shape): 106.97,71.98 106.97,71.47 107.09,71.35 107.09,70.46 107.03,70.39 105.51,70.39 105.38,70.52 105.38,71.41 105.44,71.47 105.89,71.47 106.46,72.05 106.9,72.05
+LCDVDD on BOTTOM (solid shape): 129.9,84.06 129.9,83.31 129.39,82.8 128.44,82.8 128.03,82.4 126.7,82.4 126.13,82.97 126.13,83.57 126.16,83.6 128.28,83.6 128.51,83.83 128.94,83.83 129.21,84.11 129.85,84.11
+LCDVDD on IN2 (solid shape): 107.73,71.98 107.73,71.73 107.12,71.12 106.32,71.12 106.2,71.23 106.2,71.98 106.71,72.49 107.22,72.49
+LCDVDD on IN2 (solid shape): 127.73,82.8 127.73,79.03 124.76,76.06 124.57,76.06 124.11,76.51 124.11,77.52 126.42,79.83 126.42,82.62 126.7,82.9 127.63,82.9
+LCDVDD on TOP: 126.79,82.33 127.57,82.33 127.8,82.57 127.8,84.21 127.73,84.29 126.85,84.29 126.78,84.22 126.78,83.09 126.65,82.95 126.65,82.48
+LCDVDD_R on TOP: 103.79,71.5 105.01,71.5 105.09,71.42 105.09,69.26 105.01,69.18 103.49,69.18 103.35,69.32 103.35,70.02 103.76,70.43 103.76,71.47
+RTC_CELL_VBAT on BOTTOM (solid shape): 208.49,67.03 208.49,66.55 207.93,65.99 207.93,65.76 207.86,65.68 207.4,65.68 207.28,65.8 207.28,65.98 207.23,66.02 206.68,66.02 206.61,66.1 206.61,66.58 207.26,67.23 208.29,67.23
+RTCBATT on TOP (solid shape): 56.99,12.67 56.99,11.09 56.36,10.45 52.88,10.45 52.81,10.53 52.75,10.53 52.75,10.79 51.91,10.79 51.53,11.17 51.53,12.15 51.78,12.4 51.83,12.4 51.98,12.55 53.52,12.55 53.61,12.64 54.06,12.64 54.14,12.55 54.14,12.17 54.17,12.14 54.74,12.14 54.78,11.86 55.06,11.83 55.07,11.83 55.4,12.16 55.4,12.84 55.5,12.93 56.74,12.93
+RTCVCC_R on TOP (solid shape): 210.55,69.94 210.75,69.94 210.87,69.83 210.87,69.63 210.79,69.44 210.87,69.26 210.87,68.49 210.85,68.47 209.19,68.47 209.15,68.5 209.15,69.61 209.49,69.94 209.92,69.94 210.01,70.03 210.46,70.03
+RTCVCC_R on TOP: 175.94,5.54 175.8,5.68 175.8,9.92 175.36,10.37 175.36,11.38 175.1,11.63 171.84,11.63 171.46,12.01 171.46,13.02 171.73,13.29 178.21,13.29 178.45,13.05 178.45,10.66 177.65,9.87 177.65,5.75 177.44,5.54
+SD_VDD1 on TOP (solid shape): 275.5,53.69 277.07,53.69 277.14,53.62 277.14,53.26 277,53.12 276.16,53.12 276.06,53.02 275,53.02 274.97,52.98 274.97,52.88 275,52.84 275.91,52.84 275.98,52.77 275.98,51.84 275.97,51.83 275.97,50.97 275.75,50.75 274.15,50.75 274.01,50.88 274.01,53.8 274.04,53.82 275.37,53.82
+SD_VDD1 on BOTTOM (solid shape): 283.66,25.96 283.66,24.76 283.44,24.54 282.79,24.54 282.49,24.84 282.49,25.96 282.55,26.01 283.62,26.01
+SD_VDD1 on BOTTOM (solid shape): 284.86,44.68 284.86,43.65 284.68,43.47 283.86,43.47 283.81,43.52 283.81,44.79 283.99,44.97 284.56,44.97
+SD_VDD1 on IN1 (solid shape): 280.05,23.79 280.05,23.25 280.12,23.17 282.67,23.17 283.07,23.57 283.55,23.57 283.62,23.5 283.62,21.96 283.51,21.86 280.34,21.86 279.5,22.71 279.5,23.85 279.62,23.98 279.86,23.98
+SD_VDD1 on IN2 (solid shape): 284.82,44.41 284.82,43.76 284.61,43.55 282.61,43.55 282.61,44.21 282.96,44.56 284.67,44.56
+SD_VDD1 on IN2 (solid shape): 275.11,51.61 275.11,49.62 275.05,49.55 274.17,49.55 274.02,49.7 274.02,51.81 274.18,51.97 274.75,51.97
+SD_VDD1 on IN3: 284.2,22.59 284.12,22.51 282.71,22.51 282.64,22.57 282.64,23.21 283.21,23.78 283.21,24.37 283.07,24.51 282.86,24.51 282.84,24.53 282.84,25.03 282.92,25.11 283.96,25.11 284.2,24.87
+SD_VDD2 on TOP (solid shape): 290.27,45.9 290.27,44.18 290.17,44.08 289.34,44.08 289.31,44.11 289.31,45.89 289.38,45.96 289.92,45.96 289.92,45.96 290.2,45.96
+SD_VDD2 on BOTTOM (solid shape): 283.37,24.29 283.37,23.66 283.27,23.56 282.33,23.56 281.97,23.91 281.97,24.36 282.04,24.42 283.24,24.42
+SD_VDD2 on BOTTOM (solid shape): 287.63,36.96 287.63,36.58 287.55,36.5 286.99,36.5 285.93,37.57 285.93,37.93 286.04,38.04 286.55,38.04
+SD_VDD2 on IN1 (solid shape): 283.1,24.24 283.1,23.77 282.61,23.28 280.27,23.28 280.15,23.4 280.15,24.11 280.22,24.18 281.83,24.18 281.98,24.32 283.02,24.32
+SD_VDD2 on IN1 (solid shape): 290.73,44.65 290.73,43.84 291.02,43.55 291.02,42.08 290.77,41.83 290.33,41.83 290.12,42.04 290.12,42.28 289.55,42.85 289.55,44.33 290,44.79 290.59,44.79
+SD_VDD2 on IN1 (solid shape): 288.82,41.82 288.82,41.58 288.87,41.52 288.87,41.5 289.34,41.04 289.34,39.74 289.26,39.66 288.68,39.66 288.49,39.84 288.49,40.69 288.42,40.77 288.36,40.82 288.07,41.11 288.07,41.5 287.72,41.84 287.08,41.84 287.07,41.85 286.99,41.86 286.91,41.85 286.9,41.84 285.81,41.84 285.8,41.85 285.53,41.76 285.55,41.48 285.55,41.11 285.34,40.9 284.91,40.9 284.9,40.94 284.82,41.09 284.69,41.18 284.65,41.19 284.65,42.02 285.31,42.68 287.96,42.68
+SD_VDD2 on IN3 (solid shape): 285.91,41.44 285.91,40.44 285.73,40.25 285.17,40.25 285.04,40.38 285.04,40.89 284.64,41.29 284.64,41.51 284.77,41.63 285.72,41.63
+SD_VDD2 on IN3 (solid shape): 286.71,37.99 286.71,37.83 286.63,37.68 286.61,37.52 286.53,37.43 286.08,37.43 285.07,38.44 285.07,38.61 285.36,38.9 285.8,38.9
+SD_VDD2 on TOP: 290.44,42.56 289.79,42.56 289.59,42.35 289.59,40.63 289.44,40.47 288.78,40.47 288.71,40.4 288.71,39.82 288.86,39.66 290.3,39.66 290.49,39.85 290.49,42.51
+SSD_PWR2 on TOP (solid shape): 187.23,13.37 187.99,13.37 188.06,13.31 188.06,11.47 187.93,11.34 187.17,11.34 186.47,10.64 185.26,10.64 185.26,11.21 183.23,11.21 183.23,10.64 182.53,10.64 182.21,10.96 182.21,12.86 182.53,13.18 184.18,13.18 184.75,13.75 186.85,13.75
+SSD_PWR2P on TOP (solid shape): 187.37,10.45 187.45,10.41 187.46,10.32 187.78,9.88 188.09,10.32 188.1,10.41 188.18,10.45 189.15,10.45 189.5,10.1 190.43,10.1 190.66,9.87 190.66,7.09 190.47,6.89 188.44,6.89 187.99,7.34 182.27,7.34 182.07,7.54 182.07,9.99 182.53,10.45
+SSD_PWR3 on TOP (solid shape): 216.19,43.53 216.19,42.65 216.44,42.39 218.28,42.39 218.41,42.26 218.41,40.42 218.28,40.3 217.77,40.3 217.77,40.87 215.74,40.87 215.74,40.3 214.12,40.3 213.49,40.93 213.49,43.4 213.68,43.59 214.34,43.59 214.35,43.6 216.12,43.6
+SSD_PWR3P on TOP: 218.53,34.4 218.78,34.64 218.78,35.86 218.41,36.23 218.41,39.98 218.28,40.11 215.23,40.11 215.17,40.04 215.17,39.28 215.42,39.03 215.42,34.52 215.55,34.4
+SSD_PWR_3 on TOP (solid shape): 199.8,43.41 199.8,41.18 199.72,41.1 198.87,41.1 198.39,40.61 198.09,40.61 197.96,40.74 197.96,43.34 198.15,43.53 199.68,43.53
+SSD_PWR_3 on TOP: 209.9,44.36 210.28,43.98 213.2,43.98 213.52,44.3 213.52,45.76 213.39,45.88 211.36,45.88 211.3,45.95 211.3,46.14 211.17,46.26 210.15,46.26 209.9,46.01
+SSD_PWR_3 on TOP: 203.42,43.53 201.84,43.53 201.65,43.34 201.65,40.99 202.03,40.61 203.23,40.61 203.61,40.99 203.61,43.34
+SSD_PWR_3 on BOTTOM: 205.89,29.16 207.15,29.16 207.32,28.99 207.32,27.43 207.49,27.25 212.25,27.25 213.81,28.81 213.81,47.61 213.65,47.77 209.81,47.77 209.57,47.53 209.57,31.27 208.33,30.03 205.93,30.03 205.75,29.85 205.75,29.3
+SSD_PWR_3 on BOTTOM: 199.74,43.98 197.77,43.98 197.39,43.6 197.39,40.87 197.71,40.55 203.55,40.55 203.99,40.99 203.99,43.66 203.68,43.98 201.9,43.98 201.84,43.92 201.84,43.72 201.65,43.53 199.87,43.53 199.8,43.6 199.8,43.92
+SSD_PWR_3 on IN2: 201.77,43.66 198.15,43.66 197.84,43.34 197.84,40.8 198.22,40.42 204.95,40.42 207.36,42.84 210.73,42.84 211.3,43.41 211.3,46.14 210.85,46.58 210.85,48.12 210.74,48.23 206.34,48.23
+SSD_PWR_3_R on TOP: 216.06,44.99 215.49,44.99 215.17,44.68 214.22,44.68 214.15,44.74 214.15,45.99 214.83,46.67 215.87,46.67 216.12,46.41 216.12,45.06
+TBT_L_SVR_IND on TOP (solid shape): 18.83,43.79 18.83,42.45 18.64,42.26 13.75,42.26 13.71,42.3 13.71,42.34 13.77,42.57 13.68,42.8 13.68,43.26 13.72,43.3 16.3,43.3 16.89,43.88 18.74,43.88
+TBT_R_SVR_IND on TOP (solid shape): 283.53,34.05 284.61,34.05 284.74,33.92 284.74,33.12 284.69,33.07 282.32,33.07 282.21,33.18 282.21,34.11 281.98,34.34 281.98,34.36 281.59,34.75 281.59,35.29 281.64,35.34 282.24,35.34
+TBT_VBUS_L on TOP (solid shape): 9.56,55.09 9.56,52.74 9.36,52.54 8.54,52.54 8.35,52.73 8.35,55.15 8.48,55.28 9.37,55.28
+TBT_VBUS_L on TOP (solid shape): 8.86,61.38 10.03,61.38 10.07,61.42 10.88,61.42 10.99,61.3 10.99,61.07 10.88,60.96 8.77,60.96 8.66,61.07 8.35,61.07 8.17,61.25 7.4,61.25 7.27,61.38 7.27,61.57 7.34,61.63 8.61,61.63
+TBT_VBUS_L on TOP (solid shape): 5.68,17.31 5.68,16.23 5.87,16.04 6.57,16.04 6.83,15.78 6.83,15.21 7.27,14.77 7.27,14.51 7.14,14.39 6.32,14.39 6.31,14.39 3.84,14.39 3.65,14.59 3.65,15.34 2.96,16.04 2.96,16.04 2.51,16.49 2.51,16.48 2.32,16.48 2.26,16.55 2.26,17.31 2.32,17.37 5.62,17.37
+TBT_VBUS_L on TOP (solid shape): 11.08,64.04 11.08,63.85 10.7,63.47 8.48,63.47 8.35,63.61 8.33,63.63 8.31,63.65 8.18,63.78 7.35,63.78 7.27,63.85 7.27,63.99 7.37,64.1 8.59,64.1 8.85,63.84 9.98,63.84 10.09,63.96 10.48,63.96 10.7,64.17 10.95,64.17
+TBT_VBUS_L on BOTTOM (solid shape): 11.08,64.04 11.08,63.35 10.83,63.09 10.32,63.09 10.3,63.12 9.47,63.12 9.43,63.16 9.43,64.04 9.49,64.1 11.03,64.1
+TBT_VBUS_L on BOTTOM (solid shape): 9.88,61.9 9.88,61.63 10,61.5 10.89,61.5 11.02,61.38 11.02,61.06 10.97,61.01 9.88,61.01 9.48,61.01 9.43,61.06 9.43,61.95 9.49,62.01 9.76,62.01
+TBT_VBUS_L on BOTTOM (solid shape): 4.69,16.76 7.08,16.76 7.21,16.63 7.21,15.98 6.83,15.59 6.83,15.28 7.34,14.77 7.34,14.45 7.21,14.32 6.7,14.32 6,13.63 5.68,13.63 5.49,13.82 5.49,14.79 3.55,16.74 3.55,17.03 3.72,17.2 4.24,17.2
+TBT_VBUS_L on VCC: 6.04,14.13 5.56,14.62 5.56,21.18 6.79,21.94 7.27,23.3 7.27,37.5 6.76,38.9 5.47,39.64 5.47,42.5 5.22,43.5 4.54,44.28 4.54,46.86 6.7,49.02 6.7,56.32 7.52,56.89 7.83,57.83 7.83,65.38 14.09,65.38 18.89,60.57 18.89,54.18 18.13,53.42 18.13,39.19 17.37,38.43 17.37,25.78 18.89,24.25 18.89,18.11 18.41,17.63 13.71,17.63 11.93,15.85 9.96,15.85 9.11,15 9.11,14.13
+TBT_VBUS_L_PD on TOP (solid shape): 14.96,15.5 14.96,14.83 14.26,14.13 14.26,13.82 13.88,13.44 13.75,13.44 13.3,13.88 13.3,14.01 13.69,14.39 13.69,14.71 13.43,14.96 13.43,15.59 12.88,16.15 12.88,16.24 13.5,16.86 13.59,16.86
+TBT_VBUS_L_PD on TOP (solid shape): 9.33,19.06 10.05,19.06 10.68,19.69 10.77,19.69 11.12,19.33 11.12,19.24 9.87,17.99 8.41,17.99 7.48,17.05 6,17.05 5.81,17.25 5.81,17.56 5.68,17.69 2.53,17.69 2.38,17.84 2.38,19.02 2.38,19.02 4.35,19.02 4.6,19.28 6.76,19.28 7.02,19.53 7.84,19.53 8.22,19.91 8.48,19.91
+TBT_VBUS_L_PD on BOTTOM (solid shape): 10.95,17.94 10.95,17.88 10.64,17.56 10.13,17.56 9.18,16.61 8.68,16.61 6.8,18.49 6.8,18.92 6.8,18.93 8.29,20.42 8.48,20.42
+TBT_VBUS_L_PD on IN1: 14.96,15.34 14.96,14.57 14.08,13.69 13.81,13.69 11.17,16.33 9.73,16.33 9.72,16.33 4.69,16.33 4.29,16.74 4.29,18.96 4.48,19.15 4.6,19.15 4.86,19.4 10.89,19.4
+TBT_VBUS_R on TOP (solid shape): 284.07,65.31 284.07,62.14 283.88,61.95 281.34,61.95 281.02,62.27 281.02,63.16 283.24,65.38 284,65.38
+TBT_VBUS_R on TOP (solid shape): 267.3,16.99 267.3,16.31 267.23,16.23 267.23,14.9 267.65,14.48 267.76,14.48 268,14.23 271.45,14.23 271.93,13.75 272.7,13.75 272.88,13.57 272.88,12.16 272.69,11.97 264.66,11.97 264.42,12.21 264.4,12.21 263.81,12.8 263.81,17.16 264.17,17.52 266.78,17.52
+TBT_VBUS_R on TOP (solid shape): 284.64,72.62 285.5,72.62 285.55,72.57 285.55,72.37 285.47,72.29 284.19,72.29 283.92,72.55 282.17,72.55 282.16,72.56 282.11,72.52 282.07,72.48 281.26,71.67 281.2,71.67 280.97,71.89 280.97,71.93 281.93,72.88 284.37,72.88
+TBT_VBUS_R on TOP (solid shape): 284.11,75.32 284.45,75.32 284.64,75.13 285.51,75.13 285.54,75.1 285.54,74.88 285.48,74.83 284.08,74.83 283.85,75.06 282.77,75.06 282.25,74.55 281.93,74.55 281.28,73.89 281.19,73.89 280.97,74.12 280.97,74.15 282.2,75.39 284.04,75.39
+TBT_VBUS_R on IN1 (solid shape): 267.3,16.42 267.3,15.15 268.32,14.13 271.18,14.13 271.43,13.88 271.43,13.31 271.29,13.17 266.36,13.17 264.92,14.61 264.92,14.86 264.91,14.88 264.91,16.57 265.15,16.8 266.92,16.8
+TBT_VBUS_R on VCC: 264.76,15.21 264.76,17.01 268.68,20.93 269.44,21.69 273.68,21.69 274.76,20.61 275.66,20.61 276.58,21.52 276.58,33.23 271.34,38.46 271.65,40.7 271.76,42.97 271.76,49.48 271.51,50.71 270.81,51.75 265.35,57.08 265.07,57.75 265.35,58.42 270.81,63.75 271.51,64.79 271.76,66.02 271.76,71.68 275.54,71.68 276.75,71.92 277.78,72.61 279.94,74.77 280.47,75.47 280.79,76.3 284.97,76.3 284.97,70.97 284.51,70.97 284.34,71.02 284.17,70.97 282.18,70.97 281.4,70.18 281.4,66.29 283.31,64.38 283.31,61.57 279.19,61.57 277.37,61.94 276.33,60.4 276.33,46.4 277.37,44.86 279.19,45.23 287.58,45.23 287.58,45.03 287.59,45.01 290.97,45.01 290.97,45.23 292.03,45.23 292.03,43.7 291.63,42.9 291.63,41.18 291.63,41.18 291.63,16.93 279.07,16.93 277.72,15.57 277.72,15.32 277.61,15.21 ; 1 cut-out
+TBT_VBUS_R_PD on TOP (solid shape): 278.85,11.39 278.85,10.12 278.67,9.94 276.77,9.94 276.64,10.07 276.64,10.64 276.7,10.7 277.15,10.7 277.15,10.71 277.9,11.46 278.78,11.46
+TBT_VBUS_R_PD on TOP (solid shape): 268.59,16.79 269.1,16.79 269.1,16.8 269.22,16.8 269.22,16.79 269.73,16.79 269.73,16.8 269.86,16.8 269.86,16.79 270.37,16.79 270.37,16.8 272.46,16.8 272.46,16.72 273.17,16.72 273.17,16.8 274.07,16.8 274.07,16.78 274.82,16.78 275.13,16.47 275.13,16.44 275.16,16.44 275.19,16.41 276.57,16.41 276.58,16.4 277.1,16.4 277.23,16.27 277.23,16.06 277.83,15.46 278.78,15.46 278.85,15.39 278.85,14.89 278.78,14.82 276.94,14.82 276.63,15.14 276.16,15.14 275.85,15.45 274.96,15.45 274.52,15.01 272.95,15.01 272.52,14.58 267.69,14.58 267.33,14.94 267.33,16.19 267.93,16.79 268.46,16.79 268.46,16.8 268.59,16.8
+TBT_VBUS_R_PD on IN1 (solid shape): 276.87,16.55 277.4,16.02 278.86,14.56 278.86,10.51 279.05,10.32 279.05,9.24 278.8,8.99 277.72,8.99 277.21,9.5 277.21,9.63 276.84,10 276.84,10.58 276.89,10.63 277.46,10.63 278.03,11.21 278.03,12.35 277.96,12.42 277.96,12.51 277.87,12.61 277.86,12.62 277.8,12.71 277.71,12.77 277.69,12.78 277.64,12.83 277.32,12.83 277.06,13.09 277.06,14.02 276.19,14.89 275.06,14.89 274.42,15.53 272,15.53 271.43,14.96 268.7,14.96 268.45,15.21 268.45,16.1 268.91,16.57 276.86,16.57
+TBT_VBUS_R_PD on IN3 (solid shape): 278.86,14.56 278.86,10.51 279.05,10.32 279.05,9.67 278.63,9.24 277.56,9.24 277.33,9.47 277.33,10.26 277.96,10.89 278.03,10.96 278.03,12.35 277.96,12.42 277.96,12.51 277.87,12.61 277.86,12.62 277.8,12.71 277.71,12.77 277.69,12.78 277.64,12.83 277.32,12.83 276.76,13.39 276.76,13.75 275.86,14.65 275.86,14.96 276.84,15.94 277.49,15.94
+TBT_VBUS_R_PD on IN2: 277.36,16.06 278.86,14.56 278.86,10.51 279.05,10.32 279.05,9.24 278.8,8.99 276.19,8.99 275.31,9.88 275.31,13.31 275.62,13.63 275.62,15.35 276.33,16.06
B+ on TOP (solid shape): 262.54,9.05 262.54,6.07 262.16,5.69 260.13,5.69 259.9,5.92 259.9,6.89 259.43,7.36 259.43,8.91 259.66,9.14 262.45,9.14
B+ on TOP (solid shape): 218.71,22.92 218.71,19.96 218.54,19.79 216.25,19.79 215.87,20.17 215.87,21.18 215.93,21.25 216.57,21.25 217.01,21.69 217.01,22.77 217.33,23.09 218.54,23.09
B+ on TOP (solid shape): 33.88,8.42 33.88,6.26 33.69,6.07 32.99,6.07 32.17,5.24 30.45,5.24 30.26,5.43 30.26,8.23 30.58,8.55 33.75,8.55
B+ on TOP (solid shape): 203.49,7.72 203.49,6.51 203.31,6.33 201.16,6.33 201.05,6.44 201.05,7.14 201.22,7.3 202.23,7.3 202.42,7.5 202.42,7.76 202.57,7.91 203.3,7.91
B+ on TOP (solid shape): 86.67,65.79 86.67,63.75 87.09,63.33 88.12,63.33 90.94,60.52 90.94,58.71 92.91,56.74 92.91,49.35 92.43,48.87 92.43,44.85 92.12,44.55 92.12,26.12 93.54,24.7 93.54,22.49 93.39,22.28 93.33,22.22 92.44,22.22 92.44,22.91 92.22,23.13 91.88,23.13 91.65,22.9 91.65,22.22 90.11,22.22 88.17,24.16 88.17,27.72 88.18,32.47 88.18,40.41 88.17,40.42 88.17,40.55 87.22,41.5 82.67,41.5 82.34,41.83 82.34,42.49 81.86,42.98 81.2,42.98 81.07,42.85 81.07,42.29 80.82,42.04 80,42.04 79.73,42.31 79.73,46.4 79.93,46.61 82.52,46.61 82.8,46.33 87.78,46.33 88.31,46.86 88.31,54.56 87.6,55.27 87.6,56.59 87.62,56.61 87.74,56.78 87.68,56.99 87.65,57.05 87.6,57.11 87.6,59.05 86.94,59.71 86.28,59.71 85.84,60.14 84.47,60.14 84.07,60.54 84.07,63.73 84.07,63.73 84.07,63.96 85.09,64.98 85.09,65.73 85.31,65.94 86.52,65.94
B+ on BOTTOM (solid shape): 138.34,7.59 130.34,7.59 130.34,15.59 138.34,15.59
B+ on TOP: 126.13,5.18 126.14,5.18 126.78,4.55 130.02,4.55 130.22,4.75 130.22,12.53 130.02,12.74 126.78,12.74 126.13,12.09
B+ on TOP: 99.99,68.69 100.85,67.83 100.85,66.06 100.74,65.95 99.94,65.95 99.85,66.03 99.85,67.03 99.85,67.03 99.85,67.14 99.26,67.74 96.86,67.74 96.69,67.9 96.69,68.58 96.79,68.69
B+ on BOTTOM: 174.98,6.25 139.39,6.25 139.31,6.29 139.29,6.37 139.14,6.73 138.75,6.7 138.72,6.67 138.7,6.64 138.62,6.6 138.54,6.64 138.27,6.78 138,6.64 137.92,6.6 137.84,6.64 137.57,6.78 137.31,6.64 137.22,6.6 137.14,6.64 136.88,6.78 136.61,6.64 136.53,6.6 136.44,6.64 136.28,6.77 136.07,6.76 135.97,6.78 135.93,6.87 135.93,6.93 135.92,6.99 135.77,7.37 135.36,7.31 135.29,7.28 134.97,7.42 134.65,7.28 134.34,7.42 134.02,7.28 133.7,7.42 133.38,7.28 133.31,7.31 132.9,7.37 132.75,6.99 132.9,6.61 133.31,6.67 133.38,6.7 133.7,6.56 134.02,6.7 134.34,6.56 134.65,6.7 134.97,6.56 135.29,6.7 135.36,6.67 135.52,6.57 135.71,6.58 135.81,6.57 135.85,6.48 135.85,6.42 135.85,6.37 135.84,6.29 135.76,6.25 128.7,6.25 127.99,6.96 127.99,13.75 131,16.77 135.11,16.77 137.17,18.83 149,18.83 149.77,18.07 150.78,18.07 152.18,19.47 174.21,19.47 175.29,18.39 175.29,6.56
B+ on IN1: 98.82,69 100.51,69 100.64,68.87 100.64,68.21 100.51,68.09 98.73,68.09 98.63,68.19 98.63,68.81
B+ on VCC: 173.43,6.58 173.07,6.94 173.07,9.73 170.53,12.27 170.53,19.04 170.89,19.4 210.64,19.4 214.2,22.96 218.68,22.96 220.21,21.44 225.29,21.44 232.02,14.71 269.99,14.71 270.35,14.35 270.35,7.06 270.12,6.83 230.83,6.83 225.12,12.55 217.8,12.55 211.83,6.58
B+ on VCC: 84.53,6.58 82.55,8.56 41.26,8.56 39.6,6.89 31.13,6.89 30.64,7.38 30.64,13.14 31.82,14.32 39.8,14.32 40.33,14.86 40.84,14.86 42.47,16.48 50.35,16.48 50.36,16.48 55.44,16.48 56.89,17.93 66.16,17.93 73.02,24.79 73.02,58.52 74.88,60.37 77.56,60.37 78.12,60.93 78.12,61.79 79.42,63.09 91.68,63.09 92.04,62.73 92.04,47.26 91.03,46.24 91.03,42.92 92.04,41.9 92.04,21.61 92.72,20.93 156.45,20.93 156.81,20.57 156.81,16.08 156.33,15.59 151.5,15.59 150.34,14.43 150.34,7.19 149.72,6.58
B+ on IN2: 87.78,64.9 87.78,60.18 87.59,59.99 85.91,59.99 85.55,60.35 85.55,65.48 88.88,68.81 98.08,68.81 100.46,71.19 101.21,71.19 101.59,70.81 101.59,69.76 98.99,67.16 90.04,67.16
BST1_AUX on TOP: 142.89,11.1 144.06,11.1 144.24,11.28 144.24,13.82 144.11,13.94 143.25,13.94 143.17,13.87 143.17,11.66 143.02,11.5 142.87,11.5 142.79,11.43 142.79,11.2
BST1_VCCIN on TOP: 104.19,35.99 104.39,35.79 104.39,35.41 104.62,35.18 104.62,34.42 104.81,34.22 104.81,33.31 104.75,33.25 104.12,33.25 104.05,33.32 104.05,34.58 103.45,35.18 103.45,35.99
BST2_AUX on TOP: 143.96,9.45 142.87,9.45 142.79,9.37 142.79,9.17 142.92,9.04 143.05,9.04 143.19,8.9 143.19,6.77 143.3,6.65 144.19,6.65 144.27,6.73 144.27,9.14
BST2_VCCIN on TOP: 104.15,26.82 104.59,26.38 104.59,25.4 104.64,25.35 105.22,25.35 105.28,25.3 105.28,24.46 105.23,24.41 104.21,24.41 103.78,24.84 103.78,25.65 103.42,26.01 103.42,26.82
BST_0.6V on TOP: 80.8,68.3 80.04,68.3 79.6,67.85 79.6,66.46 79.34,66.2 79.34,65.31 79.41,65.25 80.04,65.25 80.23,65.44 80.23,67.66 80.55,67.98 80.8,67.98 80.87,68.05 80.87,68.24
BST_1.8V on TOP: 208.97,21.21 209.7,21.21 209.8,21.11 209.8,20.9 209.7,20.81 209.6,20.81 209.06,20.27 209.06,20.09 208.25,19.28 207.42,19.28 207.3,19.4 207.3,19.98 207.36,20.04 207.8,20.04
BST_3V on TOP: 81.93,56.28 81.93,55.14 81.96,55.14 82.53,54.57 82.53,53.86 82.72,53.67 83.41,53.67 83.46,53.72 83.46,55.19 82.95,55.7 82.7,55.7 82.44,55.95 82.44,56.18 82.34,56.28
BST_5V on TOP (solid shape): 22.37,6.87 22.45,6.79 22.45,6.41 22.36,6.33 22.04,6.33 21.81,6.1 21.81,4.67 21.86,4.63 21.86,4.6 21.94,4.51 21.94,3.91 21.91,3.88 20.95,3.88 20.92,3.91 20.92,6.43 21.36,6.87 22.37,6.87
BST_5VB on TOP (solid shape): 272.16,8.57 272.16,5.94 271.93,5.71 270.78,5.71 270.71,5.79 270.71,6.07 270.78,6.15 271.14,6.15 271.37,6.37 271.37,7.54 271.16,7.75 271.16,8.58 271.24,8.66 272.07,8.66
BST_PWR2 on TOP: 195.59,6.54 195.79,6.74 195.79,7.76 196.1,8.06 196.27,8.06 196.35,8.14 196.35,8.37 196.27,8.44 195.51,8.44 195.23,8.16 195.23,7.55 194.9,7.22 194.9,6.36 194.71,6.17 194.71,5.28 194.73,5.26 194.77,5.22 195.41,5.22 195.59,5.4
BST_PWR3 on TOP (solid shape): 216.25,30.14 216.25,29.12 216.19,29.06 215.93,29.06 215.87,29.12 215.87,29.63 214.79,30.71 213.9,30.71 213.84,30.77 213.84,31.41 213.9,31.47 214.92,31.47
CHG_BST1 on TOP: 78.39,17.88 78.39,18.2 78.33,18.26 77.38,18.26 77.32,18.21 77.32,18.18 77.32,17.55 77.38,17.5 77.7,17.5 78.27,16.93 79.58,16.93 79.99,17.34 80.11,17.34 80.11,17.34 80.67,17.34 80.74,17.42 80.74,17.52 80.69,17.58 79.91,17.58 79.84,17.51 78.76,17.51
CHG_BST2 on TOP: 83.34,20.36 83.34,21.94 83.22,22.07 82.27,22.07 82.2,22.01 82.2,21.37 82.33,21.25 82.65,21.25 82.77,21.12 82.77,20.36 82.46,20.04 82.46,18.96 82.5,18.92 82.5,18.91 82.69,18.91 82.75,18.97 82.75,19.76
CHG_DCIN on TOP: 81.08,14.15 80.99,14.07 80.99,12.12 81.12,12 81.12,12 81.21,11.91 82.7,11.91 82.83,11.78 82.83,11.28 82.74,11.19 79.72,11.19 79.23,11.67 79.23,14.07 80.06,14.9 80.06,15.38 80.19,15.51 80.2,15.51 80.36,15.67 81.01,15.67 81.08,15.61
CHG_LG1 on IN1 (solid shape): 87.22,29.75 87.22,28.93 87.09,28.8 86.01,28.8 85.82,28.99 85.82,29.75 85.95,29.88 87.09,29.88
CHG_LG1 on TOP: 79.78,18.65 79.78,19.66 79.9,19.79 80.23,19.79 80.76,19.26 80.76,18.66 80.61,18.51 79.91,18.51
CHG_LG1 on TOP: 85.85,29.95 85.85,28.8 85.95,28.7 87.22,28.7 87.35,28.83 87.35,29.89 87.19,30.05 85.95,30.05
CHG_LG1 on IN1: 78.9,20.67 78.9,20.29 79.15,20.04 79.15,19.72 80.11,18.77 80.36,18.77 80.55,18.96 80.55,19.59 80.17,19.98 80.17,20.55 79.79,20.93 79.15,20.93
CHG_LG2 on TOP (solid shape): 81.48,20.14 81.48,18.96 81.43,18.91 81.31,18.91 81.31,18.92 81.28,18.92 81.23,18.96 81.23,19.68 80.49,20.42 80.49,20.62 80.61,20.75 80.87,20.75
CHG_LG2 on IN3 (solid shape): 76.3,41.88 76.3,40.49 76.28,40.47 75.29,40.47 75.15,40.61 75.15,41.88 75.28,42.01 76.17,42.01
CHG_LG2 on IN3 (solid shape): 81.38,20.29 81.38,19.91 81.25,19.79 80.87,19.79 80.36,20.29 79.85,20.29 79.47,20.67 79.47,21.06 79.85,21.44 80.23,21.44
CHG_LG2 on TOP: 76.35,41.57 76.35,42.59 76.14,42.8 75.62,42.8 75.15,42.33 75.15,41.57 75.34,41.38 76.16,41.38
CHG_LX1 on BOTTOM (solid shape): 85.06,33.37 85.06,30.45 85,30.39 84.04,30.39 83.85,30.58 83.85,33.44 83.92,33.5 84.93,33.5
CHG_LX1 on IN1 (solid shape): 85,31.41 85,30.33 84.23,29.56 83.73,29.56 83.34,29.95 83.34,30.14 83.98,30.77 83.98,31.34 84.17,31.53 84.87,31.53
CHG_LX1 on TOP: 82.82,25.09 85.47,25.09 85.64,25.27 85.64,30.26 87.7,32.32 87.7,37.39 87.61,37.49 82.82,37.49 82.65,37.31 82.65,25.27
CHG_LX1 on TOP: 79.65,18.57 79.85,18.36 80.71,18.36 80.75,18.32 80.75,18.18 80.69,18.13 79.4,18.13 79.13,18.4 79.13,18.41 78.71,18.83 78.71,19.7 78.52,19.89 77.91,19.89 77.83,19.96 77.83,20.79 77.9,20.85 78.48,20.85 79.65,19.68
CHG_LX1 on IN1: 79.53,18.52 79.03,18.52 78.58,18.96 78.39,18.96 77.5,19.85 77.5,20.23 77.63,20.36 78.52,20.36 78.77,20.1 78.77,19.85 79.66,18.96 79.66,18.64
CHG_LX2 on IN3 (solid shape): 82.27,22.07 82.27,21.5 81.93,21.17 81.93,20.47 81.8,20.33 81.59,20.33 81,20.93 81,21.82 81.38,22.2 82.14,22.2
CHG_LX2 on IN3 (solid shape): 79.28,41.25 79.28,40.99 79.03,40.74 79.03,40.11 78.96,40.04 78.07,40.04 78.01,40.11 78.01,41.5 78.33,41.82 78.71,41.82
CHG_LX2 on TOP: 76.65,46.38 79.32,46.38 79.42,46.28 79.42,33.98 78.3,32.87 74.42,32.87 74.09,33.2 74.09,37.82 73.31,38.59 73.31,39.98 73.44,40.11 75.53,40.11 76.55,41.12 76.55,46.28
CHG_LX2 on TOP: 81.96,19.82 81.96,20.8 82.06,20.9 82.06,21.89 81.96,21.99 81.07,21.99 81,21.92 81,20.9 81.66,20.24 81.66,18.96 81.7,18.92 81.83,18.92 81.89,18.98 81.89,19.75
CHG_UG1 on IN1 (solid shape): 81,30.01 81,28.93 80.87,28.8 80.04,28.8 79.92,28.93 79.92,29.95 80.04,30.07 80.93,30.07
CHG_UG1 on TOP: 80.31,28.75 80.79,28.75 81.07,29.03 81.07,30.1 81.02,30.15 79.98,30.15 79.88,30.05 79.88,29.18
CHG_UG1 on TOP: 78.94,18.46 78.58,18.46 78.51,18.39 78.51,17.91 78.79,17.63 79.76,17.63 79.89,17.76 80.73,17.76 80.77,17.8 80.77,17.9 80.69,17.97 79.43,17.97
CHG_UG1 on IN1: 77.63,17.63 78.65,17.63 78.96,17.94 78.96,18.2 78.58,18.58 77.76,18.58 77.31,18.13 77.31,17.94
CHG_UG2 on TOP (solid shape): 82.7,21.06 82.7,20.42 82.33,20.06 82.33,19.01 82.23,18.91 82.09,18.91 82.04,18.96 82.04,19.74 82.08,19.78 82.08,20.69 82.19,20.8 82.19,21.13 82.24,21.18 82.57,21.18
CHG_UG2 on IN3 (solid shape): 82.27,41.88 82.27,40.61 82.01,40.36 81.5,40.36 81.12,40.74 81.12,41.88 81.25,42.01 82.14,42.01
CHG_UG2 on IN3 (solid shape): 83.73,21.69 83.73,21.31 82.58,20.17 82.14,20.17 82.07,20.23 82.07,21.12 82.77,21.82 83.6,21.82
CHG_UG2 on TOP: 81.43,42.75 81.81,42.75 82.19,42.37 82.19,41.5 82.1,41.41 81.19,41.41 81.07,41.53 81.07,42.16 81.2,42.29 81.2,42.52
CHG_VIN_20V on TOP: 76.19,19.99 76.19,21.82 75.46,22.55 75.46,23.32 75.38,23.39 71.41,23.39 71.19,23.16 71.19,19.93 71.32,19.79 72.16,19.79 72.27,19.9 72.27,21.44 72.45,21.61 73.12,21.61 73.32,21.41 73.32,20.01 73.43,19.91 76.12,19.91

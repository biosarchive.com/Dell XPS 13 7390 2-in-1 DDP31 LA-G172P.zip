# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_2_TTX_C_DRX_P1: length 41.4
  TOP w0.091: v4(278.07,42.68) 278.17,42.59 arc(278.21,42.53) 278.22,42.46 arc(278.23,42.44) 278.23,42.43 278.23,42.4 arc(278.19,42.33) 278.12,42.29 CT40.2 ; JUSBC2.B2 284.96,75.98 arc(284.79,75.99) 284.62,76.04 arc(284.57,76.06) 284.53,76.08 arc(284.4,76.16) v5(284.28,76.26)
  BOTTOM w0.091: v5(284.28,76.26) 282.93,76.26 arc(282.15,76.11) 281.5,75.67 277.57,71.74 arc(277.36,71.6) 277.11,71.55 276.96,71.55 arc(276.73,71.51) 276.52,71.4 arc(276.51,71.39) 276.5,71.38 arc(276.47,71.36) 276.45,71.34 276.39,71.28 arc(276.27,71.2) 276.12,71.17 D84.2 arc(276.06,70.97) 275.95,70.81 275.95,70.81 arc(275.93,70.79) 275.92,70.78 arc(275.31,69.85) 275.09,68.75 275.09,67.91 arc(275.12,67.75) 275.21,67.61 275.21,67.61 arc(275.31,67.46) 275.34,67.29 275.34,54.11 arc(275.43,53.67) 275.69,53.29 arc(275.86,53.03) 275.91,52.74 275.91,47.23 arc(276.23,45.65) 277.12,44.32 278.03,43.41 arc(278.15,43.22) 278.2,43.01 278.2,42.98 arc(278.16,42.82) v4(278.07,42.68)
TBT_2_TTX_C_RD_DRX_N0: length 2.7
  TOP w0.076: 280.67,34.42 280.67,34.73 arc(280.65,34.82) 280.6,34.9 arc(280.56,34.96) 280.54,35.03 280.54,35.3 arc(280.56,35.4) 280.62,35.49 280.76,35.63 URT2.J2
  TOP w0.091: 280.67,34.42 280.67,34.41 280.67,34.35 281.24,33.79 281.24,33.63 CT10.2
TBT_2_TTX_C_RD_DRX_N1: length 2.6
  TOP w0.076: 278.12,34.42 278.12,34.74 arc(278.13,34.82) 278.18,34.89 278.19,34.9 arc(278.23,34.96) 278.24,35.03 278.24,35.3 arc(278.22,35.4) 278.16,35.49 278.02,35.63 URT2.C2
  TOP w0.091: CT14.2 277.72,33.54 arc(277.65,33.64) 277.63,33.76 arc(277.65,33.85) 277.7,33.93 278.12,34.34 278.12,34.42
TBT_2_TTX_C_RD_DRX_P0: length 2.6
  TOP w0.076: 280.9,34.42 280.88,34.44 280.88,34.75 arc(280.89,34.82) 280.93,34.88 280.94,34.9 arc(280.99,34.96) 281,35.04 281,35.25 arc(280.89,35.37) 280.77,35.25 URT2.J1
  TOP w0.091: 280.9,34.42 281.44,33.87 281.44,33.63 CT9.2
TBT_2_TTX_C_RD_DRX_P1: length 2.6
  TOP w0.076: 277.9,34.42 277.91,34.42 277.91,34.46 277.93,34.47 277.93,34.74 277.91,34.75 arc(277.89,34.83) 277.85,34.89 277.84,34.9 arc(277.8,34.96) 277.78,35.04 277.78,35.26 arc(277.9,35.37) 278.01,35.26 URT2.C1
  TOP w0.091: 277.9,34.42 277.56,34.07 arc(277.46,33.93) 277.43,33.76 arc(277.4,33.64) 277.34,33.54 CT13.2
TBT_2_TTX_CD_DRX_N0: length 2.2
  TOP w0.066: 279.68,40.48 279.69,40.49
  TOP w0.076: 279.74,40.65 279.74,40.64 279.75,40.64 279.75,40.63 arc(279.73,40.56) 279.69,40.49 ; URT2.G11 279.83,39.76 279.73,39.86 arc(279.65,39.98) 279.63,40.11 arc(279.62,40.14) 279.62,40.16 279.62,40.35 arc(279.64,40.42) 279.68,40.48
  TOP w0.091: CT39.1 279.95,41.64 arc(279.99,41.59) 280.02,41.53 280.05,41.4 arc(280.04,41.35) 280.04,41.3 arc(280.03,41.28) 280.03,41.26 279.98,41.2 279.86,41.07 arc(279.77,40.94) 279.74,40.8 279.74,40.65
TBT_2_TTX_CD_DRX_N1: length 2.5
  TOP w0.076: 279.05,40.86 279.05,40.63 arc(279.06,40.55) 279.11,40.48 arc(279.15,40.42) 279.16,40.35 279.16,40.09 arc(279.16,40.03) 279.13,39.97 279.08,39.85 arc(279.02,39.79) URT2.E11
  TOP w0.091: CT41.1 278.49,41.58 arc(278.43,41.5) 278.42,41.4 arc(278.42,41.36) 278.44,41.33 278.45,41.33 arc(278.5,41.3) 278.56,41.29 278.59,41.29 arc(278.66,41.28) 278.73,41.25 arc(278.79,41.22) 278.83,41.18 278.88,41.14 278.93,41.09 arc(278.95,41.06) 278.97,41.04 arc(279.03,40.96) 279.05,40.86
TBT_2_TTX_CD_DRX_P0: length 2.3
  TOP w0.076: URT2.G12 279.85,40.13 arc(279.85,40.12) 279.85,40.12 arc(279.97,40.01) 280.08,40.13 280.08,40.38 arc(280.06,40.46) 280.01,40.54 279.98,40.57 arc(279.96,40.61) 279.95,40.65
  TOP w0.091: 279.95,40.65 279.95,40.8 arc(279.96,40.87) 280,40.93 280.14,41.07 280.19,41.14 arc(280.19,41.14) 280.19,41.14 280.2,41.15 arc(280.2,41.16) 280.21,41.18 arc(280.21,41.18) 280.21,41.18 arc(280.23,41.23) 280.24,41.28 arc(280.25,41.34) 280.25,41.4 arc(280.25,41.41) 280.25,41.42 280.25,41.42 arc(280.27,41.5) 280.31,41.58 CT38.1
TBT_2_TTX_CD_DRX_P1: length 2.5
  TOP w0.076: URT2.E12 278.93,40.13 arc(278.82,40.01) 278.7,40.13 278.7,40.35 arc(278.72,40.42) 278.76,40.49 278.78,40.5 arc(278.83,40.58) 278.85,40.68 278.85,40.84 278.84,40.84 278.84,40.86
  TOP w0.091: CT40.1 278.15,41.61 arc(278.19,41.56) 278.21,41.49 278.21,41.4 arc(278.24,41.28) 278.3,41.19 278.3,41.18 arc(278.42,41.11) 278.56,41.08 278.59,41.08 arc(278.62,41.08) 278.65,41.07 arc(278.67,41.06) 278.69,41.04 278.79,40.94 arc(278.81,40.92) 278.82,40.9 arc(278.82,40.9) 278.83,40.9 arc(278.84,40.88) 278.84,40.86
TBT_2_TTX_DRX_N0: length 159.1
  TOP w0.091: CT10.1 281.15,32.7 arc(281.21,32.6) 281.24,32.49 arc(281.21,32.35) 281.13,32.23 v5(281.05,32.14)
  IN1 w0.081: v2(148.05,27.02) 148.19,26.88 v1(148.44,26.88)
  IN3 w0.081: v2(148.05,27.02) 148.29,26.79 148.78,26.79 149.51,26.05 149.51,25.55 149.78,25.29 149.78,22.52 149.89,22.41 149.89,21.52 156.51,14.9 158.31,14.9 160.01,14.59 163.82,15.26 165.82,14.9 167.46,14.9 170.74,11.63 173.11,11.63 175.98,11.12 180.83,11.98 185.49,11.16 190.27,12 195.05,11.16 199.83,12 205.06,11.07 209.84,11.92 214.16,11.16 218.87,11.99 223.65,11.14 228.49,12 233.27,11.16 238.05,12 242.82,11.16 247.6,12 252.38,11.16 257.16,12 261.94,11.15 266.71,12 268.36,11.71 270.88,11.71 280.28,21.11 281.04,25.4 280.75,27.03 280.75,29.71 arc(280.82,30.05) 281.01,30.34 281.13,30.45 arc(281.21,30.58) 281.24,30.73 281.24,31.67 arc(281.19,31.93) v5(281.05,32.14)
TBT_2_TTX_DRX_N1: length 152.3
  TOP w0.091: CT14.1 277.72,32.7 arc(277.65,32.6) 277.63,32.49 arc(277.65,32.37) 277.72,32.27 v5(277.82,32.17)
  IN1 w0.081: v1(150.27,26.23) 150.37,26.23 150.72,25.88 v2(150.72,25.79)
  IN3 w0.081: v2(150.72,25.79) 150.94,26.02 151.57,26.02 152.63,24.96 152.63,21.53 157.39,16.77 158.57,16.77 160.02,16.5 160.11,16.51 160.13,16.52 163.79,17.16 166.01,16.77 168.23,16.77 171.51,13.49 173.41,13.49 175.94,13.04 180.72,13.89 185.49,13.04 190.27,13.89 195.05,13.04 199.83,13.89 205.05,12.96 209.83,13.81 214.16,13.04 218.94,13.89 223.71,13.04 228.49,13.89 233.27,13.04 238.05,13.89 242.83,13.04 247.6,13.89 252.38,13.04 257.16,13.89 261.94,13.04 266.71,13.89 268.5,13.57 270.11,13.57 278.55,22.01 279.15,25.4 278.77,27.54 278.77,28.5 arc(278.71,28.83) 278.52,29.1 278.14,29.48 arc(278.02,29.67) 277.97,29.9 277.97,30.91 arc(277.94,31.07) 277.85,31.22 277.72,31.34 arc(277.68,31.4) 277.67,31.46 277.67,31.81 arc(277.71,32) v5(277.82,32.17)
TBT_2_TTX_DRX_P0: length 159.4
  TOP w0.091: CT9.1 281.53,32.7 arc(281.46,32.6) 281.44,32.49 arc(281.47,32.35) 281.55,32.23 v5(281.63,32.14)
  IN1 w0.081: v1(148.44,26.23) 148.19,26.23 v2(148.05,26.37)
  IN3 w0.081: v2(148.05,26.37) 148.08,26.4 arc(148.28,26.54) 148.53,26.59 148.7,26.59 149.32,25.97 149.32,25.47 149.58,25.21 149.58,22.44 149.69,22.33 149.69,21.44 156.43,14.71 158.29,14.71 160.01,14.39 163.82,15.05 165.8,14.71 167.38,14.71 170.65,11.43 173.1,11.43 175.98,10.92 180.83,11.78 183.13,11.37 183.13,11.37 185.49,10.95 190.27,11.8 195.05,10.95 199.83,11.8 205.06,10.87 209.84,11.72 214.16,10.95 218.87,11.79 223.65,10.94 228.49,11.8 233.27,10.95 238.05,11.8 240.4,11.38 242.82,10.95 247.6,11.8 252.38,10.95 257.16,11.8 261.94,10.95 266.71,11.8 268.35,11.51 270.96,11.51 280.47,21.01 281.24,25.4 280.95,27.05 280.95,29.71 arc(281,29.97) 281.15,30.2 281.27,30.31 arc(281.4,30.51) 281.44,30.73 281.44,31.69 arc(281.49,31.94) v5(281.63,32.14)
TBT_2_TTX_DRX_P1: length 152
  TOP w0.091: CT13.1 277.34,32.7 arc(277.4,32.6) 277.43,32.49 arc(277.4,32.37) 277.34,32.27 v5(277.24,32.17)
  IN1 w0.081: v1(150.27,26.88) 150.71,26.44 v2(150.72,26.44)
  IN3 w0.081: v5(277.24,32.17) 277.42,31.99 arc(277.45,31.94) 277.46,31.89 277.47,31.85 277.47,31.46 arc(277.5,31.32) 277.58,31.2 277.7,31.08 arc(277.76,31) 277.77,30.91 277.77,29.9 arc(277.83,29.6) 278,29.34 278.38,28.96 arc(278.53,28.75) 278.57,28.5 278.57,27.52 278.95,25.4 278.37,22.11 270.03,13.77 268.52,13.77 266.71,14.09 261.94,13.25 257.16,14.09 252.38,13.25 247.6,14.09 242.83,13.25 238.05,14.09 233.27,13.25 228.49,14.09 223.71,13.25 218.94,14.09 214.16,13.25 209.83,14.01 205.05,13.17 199.83,14.09 195.05,13.25 190.27,14.09 185.49,13.25 180.72,14.09 175.94,13.25 173.43,13.69 171.59,13.69 168.31,16.97 166.03,16.97 163.83,17.35 163.79,17.36 160.09,16.71 160.07,16.71 160.02,16.7 158.59,16.97 157.47,16.97 152.83,21.61 152.83,25.04 151.66,26.21 150.94,26.21 v2(150.72,26.44)
TBT_3_LSX_RX: length 16.4
  IN1 w0.064: v1(170.68,39.63) 170.25,39.2 v2(170.25,39.19)
  IN2 w0.051: v2(170.25,39.19) 170.25,39.5 171.11,40.36 171.99,40.36 172.35,40 174.71,40 175.33,40.62 176.66,40.62 176.86,40.41 179.92,40.41 180.22,40.11 182.04,40.11 v2(182.39,39.76)
  IN3 w0.064: v2(182.39,39.76) 182.39,40.64 v4(182.42,40.66)
  BOTTOM w0.081: v4(182.42,40.66) 182.49,40.74 R6175.2 RC694.2
TBT_CIO_PLUG_EVENT#: length 3
  TOP w0.081: UC1.CC49 156.79,48.77 155.54,50.01 TP53.1
TBT_I2C_INT#: length 495.2
  TOP w0.081: RPD112.2 20.66,22.08 20.25,22.49 v1(20.25,22.55) ; RPD113.2 v3(288.63,12.66) 288.77,12.8 288.77,15.51 288.95,15.69 288.95,16.86 288.45,17.35 288.45,17.75 287.88,18.32 287.12,18.32 286.86,18.07 v1(286.86,18.01) ; v1(273.91,41.12) 274.42,41.63 RT199.2
  IN1 w0.064: v2(256.95,7.21) 256.95,6.82 256.34,6.21 251.35,6.21 250.1,4.96 240.39,4.96 239.17,6.18 237.09,6.18 233.42,2.51 226.43,2.51 223.61,5.34 221.36,5.34 219.62,3.61 215.08,3.61 213.68,5 212.28,5 211.96,5.32 211.96,11.07 212.54,11.64 212.54,13.02 214.55,15.04 214.55,16.76 214.12,17.19 211.81,17.19 210.57,18.43 199.46,18.43 198.16,19.72 198.16,30.33 198.34,30.51 198.34,36.94 197.62,37.66 197.62,43.38 198.76,44.52 198.76,46.34 200.15,47.73 201.74,47.73 201.9,47.89 204.53,47.89 206.79,50.14 206.79,50.45 206.79,52.06 207.38,52.65 207.38,53.74 207.92,54.28 207.92,57.53 207.71,57.74 207.71,58.49 207.03,59.17 207.03,60.51 v2(207.02,60.52) ; v1(273.91,41.12) 274.29,40.74 274.92,40.74 276.7,38.96 276.7,38.29 276.3,37.89 276.3,36.37 274.34,34.41 274.34,32.8 273.31,31.77 273.31,27.37 273.27,27.34 273.27,27.33 270.65,24.7 270.65,23.39 272.47,21.56 273.21,21.56 273.65,21.12 v2(274.16,21.12) 274.33,20.95 282.2,20.95 282.44,20.72 282.44,20.25 282.29,20.1 282.29,19.53 283.05,18.77 285.15,18.77 285.34,18.96 285.85,18.96 286.8,18.01 v1(286.86,18.01) ; v1(18.09,46.14) 18.09,45.22 17.9,45.03 17.9,44.13 17.37,43.6 17.37,40.42 16.35,39.41 16.35,37.12 15.78,36.55 15.78,34.45 16.6,33.63 16.6,30.45 17.28,29.77 17.28,28.07 20.11,25.23 20.11,23.26 20.25,23.13 v1(20.25,22.55) 20.15,22.45 20.15,18.72 20.56,18.32 20.56,16.39 25.09,11.85 28.48,11.85 29.25,11.08 30.17,11.08 30.64,10.61 36.13,10.61 36.29,10.45 36.61,10.45 36.83,10.67 36.83,11.11 37.12,11.4 39.4,11.4 39.72,11.08 41.04,11.08 42.25,12.28 59.28,12.28 60.76,10.8 66.16,10.8 66.42,11.07 68.1,11.07 70.09,9.07 72.02,9.07 75.66,5.43 80.5,5.43 80.61,5.54 87.36,5.54 90.81,8.99 90.81,9.4 v2(91.29,9.89)
  IN2 w0.051: v2(160.89,43.37) 160.79,43.47 160.79,43.97 160.38,44.37 160.38,45.09 159.87,45.6 159.87,46.15 159.3,46.72 159.08,46.72 158.33,47.47 158.04,47.47 156.92,48.59 152.22,48.59 151.89,48.92 147.3,48.92 146.65,48.27 144.02,48.27 143.61,48.67 126.42,48.67 125.35,47.6 122.33,47.6 119.3,44.56 115.59,44.56 112.49,47.66 104.15,47.66 103.24,46.75 101.94,46.75 100.13,44.95 95.56,44.95 93.78,43.17 93.78,22.11 93.99,21.91 93.99,12.66 91.51,10.19 91.51,10.11 v2(91.29,9.89) ; v2(256.95,7.21) 257.02,7.15 262.03,7.15 262.8,7.91 262.8,9.94 265.06,12.2 268.49,12.2 270.35,14.07 270.35,15.59 272.96,18.2 272.96,19.98 274.1,21.12 v2(274.16,21.12) ; v2(207.02,60.52) 206.97,60.57 205.7,60.57 205.17,60.04 203.06,60.04 202.38,59.36 201.79,59.36 201.32,59.83 197.55,59.83 196.76,60.63 192.81,60.63 192.71,60.52 191.42,60.52 190.63,61.31 189.58,61.31 189.48,61.21 178.21,61.21 177.74,61.68 172.21,61.68 171.39,60.87 170.72,60.87 169.46,59.61 v2(168.97,59.61)
  IN3 w0.064: v2(160.89,43.37) 160.68,43.57 v4(160.62,43.57) 160.52,43.57 159.98,43.03 159.74,43.03 159.53,43.23 159.53,44.96 159.4,45.08 159.4,45.39 159.66,45.64 159.7,45.64 160.24,46.18 160.24,47.21 160.43,47.41 160.69,47.41 161.37,48.08 161.37,49.02 161.37,49.02 161.37,49.3 162.96,50.89 165.06,50.89 167.05,52.87 168.05,52.87 168.33,53.15 168.33,54.63 168.9,55.21 168.9,59.51 168.97,59.57 v2(168.97,59.61)
  BOTTOM w0.081: v4(160.62,43.57) RC687.1
TBT_L_CC1: length 64.1
  TOP w0.203: v1(18.24,17.25) 17.81,17.67 17.81,18.28 UPD1.24
  TOP w0.279: JUSBC1.A5 10.78,63.17 11.27,63.66 12.35,63.66 v1(12.35,63.66)
  TOP w0.381: v5(21.3,58.38) 20.53,59.15 20.53,61.23 18.29,63.47 15.22,63.47 v1(15.15,63.54)
  IN1 w0.381: v1(15.15,63.54) 14.75,63.54 14.29,64.01 14.12,64.01 13.82,64.31 13.3,64.31 12.65,63.66 v1(12.35,63.66) ; v1(18.24,17.25) 18.24,17.54 19.44,18.75 19.44,19.65 18.78,20.31 18.78,21.09 19.45,21.75 v2(19.46,21.75)
  IN2 w0.381: v2(18,29.44) 18.26,29.44 19.08,30.26 19.08,36.93 19.61,37.46 19.61,52.86 21.47,54.72 21.47,58.21 v5(21.3,58.38)
  IN3 w0.381: v2(19.46,21.75) 19.46,21.89 18.43,22.92 18.43,23.87 17.56,24.75 v4(17.56,27.91) 17.56,29.06 17.94,29.44 v2(18,29.44)
  BOTTOM w0.102: v4(17.56,27.91) v6(16.29,27.91)
TBT_L_CC2: length 62.7
  TOP w0.203: v1(19.51,20.56) 19.51,20.15 19.39,20.02 19.39,19.51 19.67,19.23 CPD2.1 19.64,18.65 18.58,18.65 UPD1.26
  TOP w0.381: v5(20.87,57.83) 19.87,58.82 19.87,61 18.04,62.83 v1(15.03,62.83)
  IN1 w0.381: v1(15.03,62.83) 14.57,62.83 14.03,63.37 13.86,63.37 v1(13.56,63.67) 11.72,61.83 7.79,61.83 v1(7.69,61.92) ; v2(19.51,21.12) v1(19.51,20.56)
  IN2 w0.381: v2(17.94,30.14) 18.45,30.64 18.45,37.23 18.98,37.76 18.98,53.13 20.84,54.99 20.84,57.8 v5(20.87,57.83)
  IN3 w0.381: v2(19.51,21.12) 19.44,21.18 19.27,21.18 17.8,22.66 17.8,23.61 16.92,24.49 v4(16.92,26.91) 16.92,29.44 17.62,30.14 v2(17.94,30.14)
  BOTTOM w0.102: v4(16.92,26.91) v6(17.66,26.91)
TBT_L_FLASH_BUSY#: length 6
  TOP w0.076: URT1.A9 9.16,46.77 8.88,47.04 v1(8.74,47.04)
  TOP w0.081: RT9.1 v1(4.63,48.46)
  IN1 w0.064: v1(4.63,48.46) 5.18,48.46 5.46,48.18 6.45,48.18 6.65,47.98 7.6,47.98 8.35,47.23 8.55,47.23 v1(8.74,47.04)
TBT_L_FLASH_MSTR_SLV: length 7.3
  TOP w0.076: 8.44,44.64 8.73,44.93 URT1.A5
  TOP w0.081: v1(5.96,43.75) 5.24,43.75 v3(4.97,44.02) 4.35,44.64 3.8,44.64 3.45,44.98 RT16.1 ; 8.44,44.64 v1(8.22,44.42)
  IN1 w0.064: v1(5.96,43.75) 7.14,43.75 7.81,44.42 v1(8.22,44.42)
TBT_L_FLASH_SHARE_EN: length 6.2
  TOP w0.076: URT1.A4 8.86,44.47 v1(8.81,44.42)
  TOP w0.081: RT14.1 v1(4.63,45.54)
  IN1 w0.064: v1(8.81,44.42) 8.73,44.42 8.32,44.83 7.67,44.83 7.26,44.42 6.63,44.42 6.42,44.63 5.39,44.63 4.95,45.06 4.95,45.22 v1(4.63,45.54)
TBT_L_GPIO_5: length 9.9
  TOP w0.081: RT10.1 v1(4.63,44.96)
  IN1 w0.064: v1(9.68,46.77) 8.58,46.77 7.61,47.74 6.66,47.74 6.38,48.02 5.11,48.02 4.95,48.18 4.44,48.18 4.34,48.08 4.34,45.41 4.63,45.12 v1(4.63,44.96)
TBT_L_GPIO_6: length 6
  TOP w0.076: v1(8.83,46.46) 8.98,46.31 URT1.A8
  TOP w0.081: RT11.1 v1(4.63,47.88)
  IN1 w0.064: v1(8.83,46.46) 8.66,46.46 7.54,47.57 4.93,47.57 v1(4.63,47.88)
TBT_L_GPIO_12: length 5.8
  TOP w0.076: v1(8.87,45.17) 9.09,45.39 URT1.A6
  TOP w0.081: RT17.1 v1(4.63,46.12)
  IN1 w0.064: v1(8.87,45.17) 8.68,45.36 7.45,45.36 7.3,45.52 5.92,45.52 5.42,46.01 4.74,46.01 v1(4.63,46.12)
TBT_L_JTAG_TCK: length 8.8
  IN1 w0.064: v2(7.09,45.01) 7.24,45.16 8.45,45.16 8.77,44.84 9.6,44.84 v1(9.68,44.93)
  IN3 w0.064: v4(7.25,44.46) 7.09,44.61 v2(7.09,45.01)
  BOTTOM w0.081: v4(7.25,44.46) 7.21,44.42 7.21,43.91 7.46,43.66 7.72,43.66 7.89,43.83 8.71,43.83 RT218.1 9.14,44.11 TP46.1 9.16,43.09 RT64.1
TBT_L_JTAG_TDI: length 5.7
  TOP w0.076: URT1.A3 8.82,44.01 8.68,43.86 8.68,43.8 8.59,43.72 v1(8.59,43.52)
  IN1 w0.064: v2(8.45,43) 8.45,43.38 v1(8.59,43.52)
  IN3 w0.064: v4(7.85,42.71) 7.85,42.72 8.13,43 v2(8.45,43)
  BOTTOM w0.081: v4(7.85,42.71) 7.85,42.63 9.36,41.12 10.09,41.12 RT63.1
TBT_L_JTAG_TDO: length 7.3
  TOP w0.076: URT1.C5 10.37,44.88 v1(10.37,44.67)
  IN1 w0.064: v1(10.37,44.67) 10.12,44.42 10.12,44.04 9.83,43.75 9.28,43.75 9.21,43.82 v2(7.99,43.82)
  IN3 w0.064: v4(7.99,43.41) v2(7.99,43.82)
  BOTTOM w0.081: RT97.1 9.89,42.05 9.6,41.76 TP48.1 9.2,41.76 8.52,42.44 8.52,42.89 v4(7.99,43.41)
TBT_L_JTAG_TMS: length 6.5
  TOP w0.076: v1(10.38,44.02) 10.38,44.25 URT1.C3
  IN1 w0.064: v1(10.38,44.02) 10.34,44.02 9.85,43.53 9.56,43.53 8.7,42.67 v2(8.7,42.54)
  IN3 w0.064: v2(8.7,42.54) 8.19,42.04 v4(8.19,41.42)
  BOTTOM w0.081: RT65.1 9.35,40.87 8.8,41.42 v4(8.19,41.42)
TBT_L_PERST#: length 7.7
  TOP w0.081: RT59.1 v1(4.63,49.05)
  IN1 w0.064: v1(9.68,46.31) 9.98,46.6 9.98,46.94 9.75,47.17 9.16,47.17 8.92,47.41 8.4,47.41 7.67,48.14 6.72,48.14 6.12,48.74 4.93,48.74 v1(4.63,49.05)
TBT_L_RBIAS: length 0.8
  IN1 w0.064: v1(13.82,44.47) 14.13,44.16 14.13,44.11 v2(14.14,44.11)
  IN3 w0.064: v2(14.14,44.11) 14.13,44.11 14,44.11 13.99,44.09 v4(13.81,44.09)
TBT_L_RESET#: length 30.5
  TOP w0.081: v1(9.88,36.53) 9.82,36.53 9.66,36.69 RT174.1 ; v1(11.32,35.99) 11.61,35.99 12.26,35.35 19.24,35.35 19.51,35.62 v1(19.51,37.18)
  IN1 w0.064: v1(11.32,35.99) 10.89,36.42 9.98,36.42 v1(9.88,36.53) ; v1(19.51,37.18) 19.51,47.55 19.23,47.83 16.82,47.83 16.02,47.03 15.11,47.03 14.85,46.77 13.85,46.77 13.47,47.15 13.47,47.33 v1(13.82,47.69)
TBT_L_ROM_CLK: length 25.1
  TOP w0.076: URT1.C7 v1(10.14,46.27)
  IN1 w0.064: v1(15.68,30.2) 14.76,31.12 14.76,35.09 11.78,38.07 11.78,38.81 10.95,39.64 10.95,40.17 9.2,41.92 9.2,42.69 9.58,43.08 10.05,43.08 10.84,43.87 10.84,45.3 10.14,45.99 v1(10.14,46.27) 9.74,45.86 7.66,45.86 7.33,46.19 7.09,46.19 v2(6.83,46.46)
  IN3 w0.064: v4(6.6,46.2) 6.6,46.23 v2(6.83,46.46)
  BOTTOM w0.081: JDB3.2 6.71,46.09 v4(6.6,46.2)
TBT_L_ROM_CS#: length 29.4
  TOP w0.081: UTS1.1 v1(9.04,32.74)
  IN1 w0.064: v2(6.32,45.86) 7.19,45.86 7.52,45.53 9.54,45.53 v1(9.68,45.39) ; v1(9.04,32.74) 9.11,32.74 9.49,32.35 9.49,31.24 v2(9.28,31.03)
  IN2 w0.051: v2(9.28,31.03) 9.28,31.31 11.67,33.7 11.67,38.78 10.74,39.71 10.74,40.32 9.1,41.96 9.1,42.95 8.71,43.34 7.2,43.34 6.98,43.56 6.98,44.4 7.42,44.85 7.42,45.36 6.93,45.86 v2(6.32,45.86)
  IN3 w0.064: v2(9.28,31.03) 9.02,30.77 v4(9.02,30.71) ; v2(6.32,45.86) 6.28,45.86 5.89,46.25 5.89,47.06 6.41,47.59 v4(6.58,47.59)
  BOTTOM w0.081: JDB3.5 v4(6.58,47.59)
TBT_L_ROM_DI: length 26.9
  TOP w0.076: URT1.C6 v1(10.08,45.62)
  TOP w0.081: UTS1.5 15.15,28.93 14.68,29.4 v1(14.68,30.29)
  IN1 w0.064: v1(14.68,30.29) 14.6,30.36 14.6,35.02 11.61,38 11.61,38.74 10.78,39.57 10.78,40.11 9.03,41.86 9.03,42.77 9.63,43.37 9.92,43.37 10.31,43.76 10.49,43.76 10.68,43.94 10.68,45.23 10.47,45.44 10.26,45.44 v1(10.08,45.62) 10,45.69 7.59,45.69 7.26,46.02 6.67,46.02 v2(6.24,46.46)
  IN3 w0.064: v4(6.52,46.79) 6.24,46.51 v2(6.24,46.46)
  BOTTOM w0.081: v4(6.52,46.79) 6.57,46.79 6.77,46.59 JDB3.3
TBT_L_ROM_DO: length 29.4
  TOP w0.081: UTS1.2 v1(9.04,31.47)
  IN1 w0.064: v1(9.68,44.47) 9.59,44.47 9.38,44.68 8.7,44.68 8.38,44.99 7.6,44.99 7.28,44.68 6.89,44.68 v2(6.59,44.97) ; v2(9,29.75) 8.78,29.97 8.78,30.35 8.91,30.48 8.91,31.33 v1(9.04,31.47)
  IN2 w0.051: v2(6.59,44.97) 6.59,44.72 6.83,44.48 6.83,43.5 7.14,43.18 7.59,43.18 10.59,40.18 10.59,39.65 11.52,38.71 11.52,33.77 8.92,31.18 8.92,29.83 v2(9,29.75)
  IN3 w0.064: v4(9.43,30.01) 9.25,30.01 v2(9,29.75) ; v2(6.59,44.97) 6.59,45.05 7.18,45.64 7.18,46.68 6.73,47.14 6.65,47.14 v4(6.57,47.22)
  BOTTOM w0.081: JDB3.4 6.65,47.09 6.57,47.17 v4(6.57,47.22) ; v4(9.43,30.01) 9.37,30.07 RT21.1
TBT_L_ROM_HOLD#: length 3.2
  TOP w0.081: UTS1.7 17.53,31.47 17.61,31.38 v3(17.89,31.38) RT23.1
TBT_L_ROM_WP#: length 4.4
  TOP w0.081: UTS1.3 v1(9.04,30.2)
  IN1 w0.064: v1(9.04,30.2) 9.53,29.71 v2(9.53,29.57)
  IN3 w0.064: v2(9.53,29.57) 9.53,29.6 9.75,29.82 v4(9.75,30.2)
  BOTTOM w0.081: v4(9.75,30.2) 9.88,30.33 10.19,30.33 10.55,30.68 RT22.1 11.08,30.71 v3(11.46,31.09)
TBT_L_RSENSE: length 0.8
  IN1 w0.064: v2(13.49,45.19) 13.75,44.93 v1(13.82,44.93)
  IN3 w0.064: v4(13.81,45.01) 13.63,45.19 v2(13.49,45.19)
TBT_L_SMBCLK: length 6
  TOP w0.076: 8.44,46.4 8.52,46.4 8.59,46.32 8.59,46.32 8.65,46.26 8.65,46.26 9.09,45.82 9.2,45.82 URT1.A7
  TOP w0.081: RT193.1 v1(4.63,47.29) ; 8.44,46.4 8.32,46.4 v1(8.14,46.57)
  IN1 w0.064: v1(4.63,47.29) 4.83,47.1 7.21,47.1 7.84,46.47 8.04,46.47 v1(8.14,46.57)
TBT_L_SMBDAT: length 6.5
  TOP w0.076: URT1.B7 9.63,45.85 9.4,45.62 9,45.62 8.44,46.18
  TOP w0.081: v1(8.14,46.19) 8.43,46.19 8.44,46.18 ; RT194.1 v1(4.63,46.71)
  IN1 w0.064: v1(4.63,46.71) 4.83,46.91 7.13,46.91 7.76,46.28 8.05,46.28 v1(8.14,46.19)
TBT_L_TEST_PWR_GOOD: length 5
  IN1 w0.064: v1(9.68,44.01) 9.68,44.01 9.53,44.16 7.78,44.16 7.63,44 7.63,43.32 8.21,42.73 8.21,41.72 v1(8.4,41.53)
TBT_L_THERMDA: length 2.1
  TOP w0.076: URT1.M11 14.37,47.69 14.67,47.99
  TOP w0.081: 14.67,47.99 14.96,48.27 TP6A4.1
TBT_L_XTAL_25_IN: length 2.3
  TOP w0.076: 15.05,47 14.06,47 URT1.L9
  TOP w0.081: RT53.1 15.29,47.23 15.05,47
TBT_L_XTAL_25_IN_R: length 1.7
  TOP w0.081: RT53.2 CT42.1 16.5,47.79 16.12,48.17 YT1.1
TBT_L_XTAL_25_OUT: length 3.7
  TOP w0.076: 16.02,46.88 15.16,46.88 15.08,46.81 14.33,46.81 URT1.M9
  TOP w0.081: 16.02,46.88 17.44,46.88 17.72,47.17 RT54.1
TBT_L_XTAL_25_OUT_R: length 3
  TOP w0.081: RT54.2 CT43.1 17.14,47.89 16.86,48.17 16.86,49.15 YT1.3
TBT_R_CC1: length 87.2
  TOP w0.203: v5(282.66,8.92) 282.83,9.09 UPD2.24
  TOP w0.254: v1(273.2,69.12) 273.2,68.53 v5(273.15,68.48)
  TOP w0.279: JUSBC2.A5 v1(282.8,73.23)
  TOP w0.381: CPD12.1 282.47,8.73 v5(282.66,8.92)
  IN1 w0.381: v1(282.8,73.23) v2(282.44,73.23) ; v5(273.15,68.48) 273.15,67.54 272.73,67.12 272.73,65.31 273.06,64.98 v2(273.06,43.45) ; v2(273.21,69.51) 273.21,69.14 v1(273.2,69.12)
  IN2 w0.381: v2(276.96,24.67) 277.15,24.67 277.34,24.87 283.23,24.87 284.02,24.08 v2(284.02,22.18) ; v2(282.44,73.23) 281.5,73.23 281.01,72.74 280.03,72.74 276.8,69.51 v2(273.21,69.51)
  IN3 w0.381: v2(273.06,43.45) v4(273.06,43.1) ; v5(282.66,8.92) 283.05,9.31 283.05,10.13 283.5,10.58 284,10.58 285.08,11.66 285.08,16.96 283.5,18.54 283.5,21.66 v2(284.02,22.18) ; v2(276.96,24.67) v4(276.96,25.06)
  BOTTOM w0.381: v4(273.06,43.1) 273.06,42.62 272.77,42.33 272.77,40.17 272.49,39.89 v6(272.49,34.85) 272.49,33.4 272.89,32.99 272.89,30.45 273.53,29.82 275.7,29.82 276.64,28.87 276.64,27.09 276.45,26.9 276.45,26.45 277.03,25.87 277.03,25.13 v4(276.96,25.06)
TBT_R_CC2: length 90.5
  TOP w0.203: CPD13.1 283.99,8.79 v5(283.74,9.04) 283.63,9.15 UPD2.26
  TOP w0.254: v1(272.5,69.12) 272.5,68.49 v5(272.51,68.48)
  IN1 w0.254: v1(285.07,74.48) 285.02,74.52 v2(283.88,74.52)
  IN1 w0.381: v2(272.42,43.46) 272.42,64.62 272.07,64.97 272.07,67.51 272.51,67.96 v5(272.51,68.48) ; v1(272.5,69.12) v2(272.5,69.5)
  IN2 w0.381: v2(283.88,74.52) 283.31,74.52 282.8,74.01 280.19,74.01 276.38,70.2 273.02,70.2 272.5,69.69 v2(272.5,69.5) ; v2(284.51,21.75) 284.51,21.78 284.7,21.97 284.7,24.29 283.5,25.5 277.08,25.5 v2(276.89,25.69)
  IN3 w0.381: v5(283.74,9.04) 283.74,9.68 283.94,9.88 284.32,9.88 285.78,11.34 285.78,17.25 284.2,18.83 284.2,21.37 284.51,21.69 v2(284.51,21.75) ; v4(272.42,43.08) v2(272.42,43.46) ; v4(276.32,25.56) 276.57,25.56 276.69,25.69 v2(276.89,25.69)
  BOTTOM w0.381: v4(272.42,43.08) 272.42,42.9 272.13,42.61 272.13,40.43 271.85,40.15 v6(271.85,33.14) 272.26,32.73 272.26,30.14 273.21,29.18 275.43,29.18 276,28.61 276,27.4 275.81,27.21 275.81,26.07 v4(276.32,25.56)
TBT_R_FLASH_BUSY#: length 3.6
  TOP w0.081: RT190.1 RT189.1 275.32,40.49 275.93,39.87 275.93,39.35 276.44,38.84 URT2.A9
TBT_R_FLASH_MSTR_SLV: length 4.6
  TOP w0.081: URT2.A5 276.7,37 275.93,36.24 275.93,34.56 275.55,34.17 RT39.1 RT38.1
TBT_R_FLASH_SHARE_EN: length 5.4
  TOP w0.081: URT2.A4 276.5,36.54 276.12,36.16 276.12,34.06 275.88,33.83 275.88,33.37 275.55,33.03 RT37.1 RT36.1
TBT_R_GPIO_5: length 3.4
  TOP w0.076: URT2.B9 277.32,38.61 276.8,38.61
  TOP w0.081: 276.8,38.61 276.4,38.61 275.67,39.34 RT33.1 RT173.1
TBT_R_GPIO_6: length 2.7
  TOP w0.081: RT35.1 RT34.1 275.83,38.77 276.22,38.38 URT2.A8
TBT_R_GPIO_12: length 3.9
  TOP w0.081: RT40.1 RT41.1 275.55,35.32 275.75,35.52 275.75,36.31 276.14,36.7 276.14,36.87 276.73,37.46 URT2.A6
TBT_R_JTAG_TCK: length 9.3
  TOP w0.081: v1(275.22,31.88) 274.79,31.46 274.29,31.46 TP51.1 274.48,30.59 274.48,30.13 274.42,30.06 RT98.1
  IN1 w0.064: v1(275.22,31.88) 275.61,32.28 275.61,34.42 277.24,36.05 277.24,36.69 v1(277.55,37)
TBT_R_JTAG_TDI: length 7.3
  TOP w0.076: 276.39,34.42 276.39,35.58 276.59,35.78 276.64,35.78 276.94,36.08 URT2.A3
  TOP w0.081: RT71.1 275.05,30.5 TP49.1 275.58,31.03 275.58,32.7 276.13,33.24 276.13,33.66 276.39,33.93 276.39,34.42
TBT_R_JTAG_TDO: length 8.9
  TOP w0.076: URT2.C5 v1(278.04,36.74)
  TOP w0.081: v1(276.06,31.81) 276.16,31.71 276.16,30.14 RT73.1
  IN1 w0.064: v1(278.04,36.74) 278.04,36.61 277.86,36.44 277.86,35.92 277.66,35.72 277.14,35.72 275.77,34.35 275.77,32.12 276.05,31.85 276.05,31.82 v1(276.06,31.81)
TBT_R_JTAG_TMS: length 8.4
  TOP w0.076: URT2.C3 v1(278.1,36.17)
  TOP w0.081: RT72.1 276.83,29.98 TP50.1 276.83,31.33 276.7,31.45 276.7,32 276.04,32.67 v1(276.04,32.71)
  IN1 w0.064: v1(278.1,36.17) 278.1,35.96 277.72,35.58 277.23,35.58 275.94,34.28 275.94,32.8 v1(276.04,32.71)
TBT_R_PERST#: length 3.7
  TOP w0.076: URT2.B8 277.32,38.15 276.8,38.15
  TOP w0.081: 276.8,38.15 276.01,38.15 v5(275.86,38)
  BOTTOM w0.081: v3(276.19,37.5) 276.19,37.67 v5(275.86,38) 275.66,38.2 RT62.1 RT163.1
TBT_R_RBIAS: length 1.5
  TOP w0.076: v1(281.34,36.45) 281.52,36.45 281.62,36.54 URT2.L4
  IN1 w0.064: v2(281.85,36.1) 281.5,36.45 v1(281.34,36.45)
  IN3 w0.064: v2(281.85,36.1) 281.96,36.22 v4(282.29,36.22)
TBT_R_RESET#: length 29.3
  TOP w0.081: RT175.1 287.74,24.5 RT224.1 286.99,23.96 v1(286.98,23.97)
  IN1 w0.064: v1(281.69,39.76) 281.52,39.76 281.31,39.56 281.31,39.32 281.72,38.91 283.12,38.91 284.08,37.95 v2(285.07,37.95) ; v2(286.18,22.52) 286.98,23.32 v1(286.98,23.97)
  IN2 w0.051: v2(285.07,37.95) 286.13,37.95 286.86,37.21 287.66,37.21 288.13,36.74 288.13,36.05 287.87,35.79 285.97,35.79 285.53,35.34 285.53,34.08 286.52,33.09 286.52,26.87 286.86,26.52 286.86,24.36 286.18,23.67 v2(286.18,22.52)
TBT_R_ROM_CLK: length 57.7
  TOP w0.081: v1(258.03,15.09) UTS2.6
  TOP w0.093: URT2.C7 278.06,38.07 v5(277.98,38.07)
  IN1 w0.064: v2(263.24,19.61) 262.87,19.24 262.87,18.18 261.29,16.6 259.61,16.6 259.05,16.04 259.05,14.51 258.92,14.38 258.74,14.38 v1(258.03,15.09)
  IN2 w0.051: v5(286.47,26.29) 286.16,26.29 285.48,26.97 285.48,33.35 284.04,34.78 282.18,34.78 281.43,35.53 278.86,35.53 278.35,36.04 278.35,37.69 277.98,38.06 v5(277.98,38.07)
  IN3 w0.064: v2(263.24,19.61) 263.35,19.72 v4(264.8,19.72)
  BOTTOM w0.081: v4(264.8,19.72) 264.8,20.01 265.91,21.12 267.19,21.12 269.08,23.01 273.27,23.01 273.6,22.68 284.25,22.68 285.51,23.93 285.51,25.33 v3(285.63,25.46) v5(286.47,26.29) 286.74,26.57 JDB4.2
TBT_R_ROM_CS#: length 68.4
  TOP w0.081: UTS2.1 v1(247.4,17.63)
  IN1 w0.064: v2(277.25,37.31) 277.4,37.46 v1(277.55,37.46) ; v1(247.4,17.63) 247.49,17.71 255.33,17.71 255.68,17.37 256.69,17.37 257.07,17.75 257.07,18.39 258.36,19.68 259.18,19.68 259.35,19.85 v2(259.92,19.85)
  IN2 w0.051: v5(286.44,24.62) 285.81,25.25 285.81,25.54 285.02,26.33 285.02,33.16 283.85,34.33 281.99,34.33 281.16,35.15 278.18,35.15 277.25,36.09 277.25,37.31 v2(277.25,37.31)
  IN3 w0.064: v4(265.91,19.72) 265.56,20.06 265.56,20.48 265.12,20.93 263.88,20.93 263.13,20.18 261.51,20.18 261.18,19.85 v2(259.92,19.85)
  BOTTOM w0.081: v4(265.91,19.72) 266.03,19.84 266.69,19.84 269.3,22.45 273.05,22.45 273.62,21.88 278.15,21.88 v3(278.29,22.02) 278.4,22.13 284.48,22.13 286.06,23.7 286.06,24.24 v5(286.44,24.62) 286.89,25.07 JDB4.5
TBT_R_ROM_DI: length 56.8
  TOP w0.076: v5(278,37.33) 278.32,37.65 URT2.C6
  TOP w0.081: v1(258.1,13.82) UTS2.5
  IN1 w0.064: v2(263.24,19.09) 263.24,19.04 263.04,18.83 263.04,18.11 261.36,16.43 259.68,16.43 259.21,15.97 259.21,14.44 258.99,14.22 258.5,14.22 v1(258.1,13.82)
  IN2 w0.051: v5(286.5,25.73) 285.33,26.91 285.33,33.29 283.98,34.63 282.12,34.63 281.34,35.41 278.61,35.41 278,36.01 v5(278,37.33)
  IN3 w0.064: v4(265.17,19.72) 264.91,19.46 263.61,19.46 v2(263.24,19.09)
  BOTTOM w0.081: JDB4.3 286.84,26.07 v5(286.5,25.73) 285.69,24.92 285.69,23.86 284.33,22.49 274.91,22.49 v3(274.8,22.38) 273.64,22.38 273.19,22.83 269.16,22.83 266.54,20.21 265.63,20.21 265.17,19.75 v4(265.17,19.72)
TBT_R_ROM_DO: length 67.1
  TOP w0.081: UTS2.2 247.78,16.36 v1(247.4,16.74)
  IN1 w0.064: v1(247.4,16.74) 248.2,17.54 255.27,17.54 255.61,17.2 256.76,17.2 257.23,17.68 257.23,18.32 258.43,19.52 v2(259.49,19.52) ; v1(277.55,36.54) v2(277.55,36.21)
  IN2 w0.051: v2(277.55,36.21) 278.49,35.28 281.25,35.28 282.05,34.48 283.92,34.48 285.17,33.22 285.17,26.47 v5(286.47,25.17)
  IN3 w0.064: v4(265.53,19.72) 265.4,19.85 265.4,20.17 264.89,20.67 263.88,20.67 263.14,19.94 261.5,19.94 261.08,19.52 v2(259.49,19.52)
  BOTTOM w0.081: JDB4.4 286.86,25.57 v5(286.47,25.17) 285.88,24.58 285.88,23.78 284.41,22.31 276.69,22.31 v3(276.58,22.2) 276.46,22.09 273.67,22.09 273.12,22.64 269.24,22.64 266.62,20.03 265.83,20.03 v4(265.53,19.72)
TBT_R_ROM_HOLD#: length 3.2
  TOP w0.081: RT45.1 258.5,17.04 v3(258.32,16.86) 257.81,16.36 UTS2.7
TBT_R_ROM_WP#: length 3.4
  TOP w0.081: UTS2.3 v3(248.23,15.09) 247.75,15.09 247.4,15.43 RT44.1
TBT_R_RSENSE: length 1.4
  TOP w0.076: URT2.L5 281.59,37 v1(281.41,37.18)
  IN1 w0.064: v2(281.97,37.37) 281.6,37.37 v1(281.41,37.18)
  IN3 w0.064: v2(281.97,37.37) 282.21,37.13 v4(282.29,37.13)
TBT_R_SMBCLK: length 2.5
  TOP w0.076: URT2.A7 277.07,37.89 276.78,37.89 276.78,37.9 276.61,37.9 276.56,37.85 276.56,37.85 276.55,37.84
  TOP w0.081: 276.55,37.84 276.47,37.77 276.19,37.77 275.95,37.53 275.72,37.53 275.62,37.63 RT200.1 RT196.1
TBT_R_SMBDAT: length 3.5
  TOP w0.076: 276.69,37.69 277.32,37.69 URT2.B7
  TOP w0.081: 276.69,37.69 276.56,37.56 276.28,37.56 275.75,37.03 275.75,36.86 275.57,36.68 275.53,36.68 RT195.1 RT201.1
TBT_R_TEST_PWR_GOOD: length 3.4
  TOP w0.076: URT2.B3 277.32,35.85 276.92,35.85 276.58,35.5 276.58,34.42
  TOP w0.081: 276.58,34.42 276.58,33.54 RT30.2
TBT_R_THERMDA: length 2.3
  TOP w0.076: URT2.M11 282.32,39.76 282.51,39.95 282.51,40.43 282.54,40.46
  TOP w0.081: 282.54,40.46 282.8,40.71 282.8,40.94 TP6A5.1
TBT_R_XTAL_25_IN: length 3.4
  TOP w0.076: URT2.L9 281.92,39.07 282.84,39.07 283.42,39.66 283.42,39.9
  TOP w0.081: RT55.1 283.88,40.55 283.42,40.09 283.42,40.09 283.42,39.9
TBT_R_XTAL_25_IN_R: length 1.9
  TOP w0.081: YT2.1 285.82,40.93 CT45.1 284.77,40.57 RT55.2
TBT_R_XTAL_25_OUT: length 2.4
  TOP w0.076: 282.54,38.84 URT2.M9
  TOP w0.081: RT56.1 283.9,39.91 282.82,38.84 282.54,38.84
TBT_R_XTAL_25_OUT_R: length 3.3
  TOP w0.081: RT56.2 284.77,39.89 CT44.1 285.81,40.23 286.86,40.23 287.54,39.55 YT2.3
TCP0_RST#: length 40.8
  TOP w0.081: RPD124.1 v1(15.1,13.65) 14.68,13.65 RPD170.1 ; v3(7.58,32.15) 7.58,33.11 v1(7.84,33.37) 8.03,33.56 v1(11.69,33.56) ; RT174.2 9.18,37.21 QT1.1 9.18,35.9 9.56,35.52 v1(11.69,35.52)
  IN1 w0.064: v1(15.1,13.65) 14.81,13.94 v2(14.76,13.94) ; v1(11.69,33.56) v1(11.69,35.52) ; v2(7.84,33.82) 7.91,33.76 7.91,33.44 v1(7.84,33.37)
  IN2 w0.051: v2(7.84,33.82) 7.34,33.31 7.34,22.39 6,21.06 6,17.66 6.8,16.86 10.89,16.86 13.81,13.94 v2(14.76,13.94)
TCP0_RST#_R: length 2.8
  TOP w0.081: 15.38,16.75 15.81,16.32 15.81,16.17 v1(15.66,16.02)
  IN1 w0.064: v1(15.09,14.47) 15.4,14.77 15.4,15.76 v1(15.66,16.02)
TCP2_RST#: length 33.3
  TOP w0.081: v1(286.28,23.75) 286.28,23.84 287.18,24.74 RT175.2 ; v1(277.97,7.96) RPD167.1 RPD132.1
  IN1 w0.064: v2(285.4,22.63) 286.28,23.51 v1(286.28,23.75) ; v1(277.97,7.96) 278.18,8.16 v2(279.56,8.16)
  IN2 w0.051: v2(285.4,22.63) 285.4,21.94 284.96,21.5 284.96,20.29 285.78,19.47 286.35,19.47 287.75,18.07 287.75,8.99 285.59,6.83 281.66,6.83 281.15,7.34 281.15,8.55 280.89,8.8 279.75,8.8 279.56,8.61 v2(279.56,8.16)
  IN3 w0.064: v2(279.56,8.16) v4(279.28,8.44)
  BOTTOM w0.081: v4(279.28,8.44) 278.97,8.13 v3(278.82,8.13)
TCP2_RST#_R: length 1.9
  TOP w0.081: RPD132.2 279.12,8.61 280.03,9.53 UPD2.17
TCRCOMP_DN: length 1.8
  TOP w0.305: RC1.1 145.28,23.94
TCRCOMP_DP: length 2.9
  TOP w0.203: UC1.AY2 145.54,24.76 145.86,24.44 145.86,23.95
  TOP w0.305: 145.86,23.95 145.87,23.95 RC1.2
TESMODE: length 6.9
  TOP w0.081: USSD1.Y6 197.52,32.09 197.52,30.45 195.8,28.74 R452.2
THERMTRIP1#: length 1.9
  IN1 w0.064: v1(215.9,65.16) 215.94,65.2 v2(216.42,65.2)
  IN3 w0.064: v4(216.42,64.87) v2(216.42,65.2)
  BOTTOM w0.081: v4(216.42,64.87) 216.42,65.48 v3(216.72,65.78)
THERMTRIP2#: length 17.4
  TOP w0.081: QE16.1 200.97,59.36 RE215.2 199.6,60.58 v1(199.44,60.74) 199.44,62.74 v3(199.4,62.77) ; v1(208.7,60.74) 208.7,60.74 UE1.H3
  IN1 w0.064: v2(199.44,61.82) v1(199.44,60.74) ; v1(208.7,60.74) 208.7,61.01 208.67,61.04 v2(208.67,61.13)
  IN3 w0.064: v2(199.44,61.82) 199.57,61.96 200.86,61.96 201.57,62.67 207.13,62.67 v2(208.67,61.13)
TOUCH_SCREEN_PD#: length 29.2
  TOP w0.081: D468.1 186.32,36.42 RH655.1 RH654.1 187.51,37.72 188.02,38.23 v5(188.8,38.23) ; UC1.DT11 172.94,29.25 v1(173.13,29.06)
  IN1 w0.064: v2(176.01,30.23) 176.01,29.63 175.6,29.21 175.6,29.15 175.12,28.68 174.92,28.68 174.6,29 173.19,29 v1(173.13,29.06)
  IN3 w0.064: v5(188.8,38.23) 188.1,37.53 188.1,34.3 187.3,33.5 185.74,33.5 183.25,31.01 183.25,29.96 181.91,28.63 180.09,28.63 178.5,30.23 v2(176.01,30.23)
  BOTTOM w0.081: v3(188.95,37.76) 188.8,37.91 v5(188.8,38.23)
TOUCH_SCREEN_PD#_R: length 169.1
  TOP w0.081: v1(192.49,46.65) 191.74,46.65 191.1,46.01 190.46,46.01 189.86,45.4 189.34,45.4 188.43,44.49 187.35,44.49 186.35,43.48 186.35,42.32 187.07,41.6 187.07,40.57 186.84,40.35 186.84,39.28 187.52,38.6 188.95,38.6 189.21,38.34 189.21,38.05 RH654.2 188.02,36.85 D468.2 ; QC2.3 220.22,47.39 220.47,47.64 RH743.2 220.47,48.21 220.39,48.28 v1(218.41,48.28) ; v5(130.31,82.41) 130.31,82.68 130.5,82.87 JEDP1.27
  IN1 w0.064: v1(192.49,46.65) 194.04,48.2 194.04,49.47 v2(194.39,49.82) 194.77,49.82 195.04,50.09 195.04,50.46 194.86,50.63 194.86,51.2 195.51,51.85 195.8,51.85 196.03,52.08 196.03,52.36 197.84,54.17 197.84,55.48 198.44,56.08 198.44,59.27 197.86,59.85 197.86,60.15 197.98,60.27 197.98,64.91 198.23,65.16 198.23,68.23 197.86,68.6 195.97,68.6 v2(195.64,68.93) ; v1(218.41,48.28) 218.61,48.49 v2(218.61,48.61) ; v5(130.31,82.41) 130.31,80.28 129.45,79.41 129.45,78.46 v1(128.94,77.95)
  IN2 w0.051: v2(218.61,48.61) 218.6,48.63 216.35,48.63 215.88,48.16 212.49,48.16 211.56,49.08 207.08,49.08 206.5,48.5 204.08,48.5 203.26,47.67 203.26,46.24 202.89,45.87 199.16,45.87 195.21,49.82 v2(194.39,49.82)
  IN3 w0.064: v5(130.31,82.41) 130.31,82.33 v4(130.78,81.86) 131.03,81.61 131.03,81.6 131.04,81.59 131.04,80.36 132.37,79.02 133.9,79.02 134.28,78.64 136.73,78.64 137.11,79.02 144.45,79.02 145.73,77.75 150.76,77.75 152.99,79.98 152.99,83.36 153.87,84.23 169.47,84.23 170.53,83.18 170.53,79.65 171.6,78.58 171.6,75.36 177.05,69.92 178.45,69.92 179.48,68.89 189.71,68.89 190.53,68.07 192.75,68.07 193.16,68.47 193.56,68.47 193.91,68.11 194.82,68.11 v2(195.64,68.93)
TP_A47: length 6.2
  TOP w0.081: UC1.A47 125.25,46.83 123.92,48.16 123.92,49.38 122.97,50.33 TP1.1
TP_AH10: length 1.7
  TOP w0.081: UC1.AH10 139.75,29.33 v5(139.6,29.48)
  BOTTOM w0.081: TP90.1 139.67,29.41 v5(139.6,29.48)
TP_AK10: length 1.2
  TOP w0.081: UC1.AK10 v5(140.66,29.26)
  BOTTOM w0.081: v5(140.66,29.26) 140.66,28.7 TP89.1
TP_AM10: length 1.2
  TOP w0.081: v5(141.57,29.27) 141.58,29.27 UC1.AM10
  BOTTOM w0.081: TP93.1 v5(141.57,29.27)
TP_AT1: length 3.3
  TOP w0.081: TP29.1 142.91,23.21 143.59,23.9 UC1.AT1
TP_AT2: length 5.4
  TOP w0.081: UC1.AT2 143.59,24.79 143.29,24.48 143.29,23.85 142.59,23.15 142.59,20.48 TP28.1
TP_AU1: length 4.6
  TOP w0.081: UC1.AU1 144.24,23.91 143.39,23.05 143.39,20.2 TP30.1
TP_AU2: length 6.9
  TOP w0.081: UC1.AU2 143.92,24.53 143.92,23.85 143.2,23.13 143.2,19.51 TP31.1
TP_AV1: length 3.3
  TOP w0.081: TP27.1 144.3,23.27 144.89,23.86 UC1.AV1
TP_AV2: length 6.6
  TOP w0.081: TP32.1 143.92,23.15 144.56,23.79 144.56,24.29 144.89,24.63 UC1.AV2
TP_B47: length 5.7
  TOP w0.081: TP2.1 122.91,48.74 125.13,46.52 126.52,46.52 UC1.B47
TP_BC10: length 1.3
  TOP w0.081: v5(147.1,29.44) 147.07,29.41 UC1.BC10
  BOTTOM w0.081: TP91.1 147.04,29.37 v5(147.1,29.44)
TP_BH10: length 1.3
  TOP w0.081: UC1.BH10 149.81,29.29 v5(149.83,29.3)
  BOTTOM w0.081: v5(149.83,29.3) 149.82,29.3 TP94.1
TP_BW11: length 0.9
  IN1 w0.064: v2(155.06,28.73) 154.85,28.95 v1(154.85,29.11)
  IN3 w0.064: v2(155.06,28.73) 155.06,28.9 v4(154.91,29.06)
TP_C1: length 5.4
  TOP w0.081: UC1.C1 125.51,22.57 125.51,20.22 TP59.1
TP_CA11: length 1.6
  IN1 w0.064: v2(155.56,28.82) 155.56,28.91 v1(155.76,29.11)
  IN3 w0.064: v2(155.56,28.82) 156.45,28.82 v4(156.69,29.06)
TP_CH33: length 2
  TOP w0.081: UC1.CH33 v5(159.09,39.35)
  BOTTOM w0.081: v5(159.09,39.35) 158.34,40.11 TP92.1
TP_CL32: length 2.5
  TOP w0.081: UC1.CL32 160.59,39.43 v5(160.24,39.09)
  BOTTOM w0.081: TP97.1 161.51,40.35 v5(160.24,39.09)
TP_CM33: length 2.2
  TOP w0.081: UC1.CM33 161.46,39.9 161.8,39.56 161.8,39.06 v5(161.78,39.04)
  BOTTOM w0.081: v5(161.78,39.04) 161.89,38.93 TP16.1
TP_CN32: length 1.8
  TOP w0.081: UC1.CN32 161.5,39.43 v5(161.16,39.09)
  BOTTOM w0.081: TP98.1 161.63,39.56 v5(161.16,39.09)
TP_CT32: length 1.1
  TOP w0.081: v5(163.33,38.95) UC1.CT32
  BOTTOM w0.081: TP6.1 163.29,38.91 v5(163.33,38.95)
TP_CV32: length 2.9
  TOP w0.081: v5(165.7,38.17) 165.7,38.52 165.51,38.71 165.21,38.71 164.49,39.44 UC1.CV32
  BOTTOM w0.081: v5(165.7,38.17) 165.54,38.33 TP5.1
TP_DA11: length 2
  TOP w0.081: 165.83,29.17 165.83,29.58 v5(165.64,29.77)
  TOP w0.089: UC1.DA11 165.83,29.17
  BOTTOM w0.081: TP96.1 165.45,29.57 v5(165.64,29.77)
TP_DB10: length 1.7
  TOP w0.089: UC1.DB10 v5(166.28,27.77)
  BOTTOM w0.081: v5(166.28,27.77) 166.28,27.78 TP15.1
TP_DH49: length 4.9
  TOP w0.081: UC1.DH49 169.27,48.02 169.09,48.19 169.09,49.54 169.35,49.8 169.35,50.91 168.89,51.37 168.41,51.37 TP20.1
TP_DISABLE#: length 95.2
  TOP w0.081: JIO1.33 253.25,6.45 252.31,7.39 249.52,7.39 248.83,8.09 243.75,8.09 242.13,9.71 v3(242.13,14.31) 242.13,14.6 241.67,15.06 v1(241.67,15.46)
  IN1 w0.064: v2(209.53,61.62) 209.5,61.66 v1(209.5,61.96) ; v2(229.04,22.45) 228.79,22.2 228.79,21.81 229.29,21.3 229.29,20.21 229.99,18.53 230.97,17.56 239.15,17.56 239.61,17.09 240.04,17.09 241.11,16.03 241.38,16.03 241.67,15.73 v1(241.67,15.46)
  IN3 w0.064: v2(229.04,22.45) 228.91,22.45 228.2,23.16 227.75,23.16 226.71,24.19 225.51,24.19 221.86,27.84 221.86,34.3 221.86,34.31 221.86,35.43 219.67,37.62 217.05,37.62 216.05,38.62 216.05,44.48 219.77,48.2 219.77,59.96 218.74,60.99 214.69,60.99 214.55,61.13 213.89,61.13 213.67,61.36 210.96,61.36 210.91,61.31 209.65,61.31 209.53,61.42 v2(209.53,61.62)
TP_DL8: length 8.4
  TOP w0.081: 175.6,27.06 177.59,29.06 TP22.1
  TOP w0.089: UC1.DL8 171.3,27.11 174.95,27.11 175.08,26.99 175.52,26.99 175.6,27.06
TP_DP1: length 6.3
  TOP w0.081: TP11.1 176.31,22.26 175.3,23.27 173,23.27 UC1.DP1
TP_DP2: length 7.5
  TOP w0.081: TP12.1 177.64,21.44 175.48,23.6 173.13,23.6 172.07,24.66 UC1.DP2
TP_DV3: length 8
  TOP w0.081: 175.6,24.46 177.6,22.46 177.6,22.46 177.77,22.28 177.78,22.28 178.56,21.5 179.86,21.5 TP19.1
  TOP w0.089: UC1.DV3 174.17,25.48 174.67,24.99 175.07,24.99 175.6,24.46
TP_DV4: length 7.8
  TOP w0.081: UC1.DV4 173.81,25.4 174.08,25.13 174.26,25.13 174.46,24.93 174.46,24.54 174.64,24.36 175.44,24.36 177.42,22.38 177.42,22.38 178.74,21.06 TP14.1
TP_DV6: length 9.6
  TOP w0.081: 175.6,24.99 177.25,23.34 178.72,23.34 180.18,21.88 TP10.1
  TOP w0.089: UC1.DV6 174.11,26.11 174.59,25.63 174.96,25.63 175.6,24.99
TP_DV47: length 7.4
  TOP w0.081: UC1.DV47 174.43,46.95 174.43,47.58 175.41,48.56 176.44,48.56 177.52,49.63 179.49,49.63 TP24.1
TP_DW3: length 5.2
  TOP w0.081: 175.6,24.73 177.75,22.58 TP17.1
  TOP w0.089: 175.6,24.73 175.01,25.31 UC1.DW3
TP_DW4: length 6.9
  TOP w0.081: UC1.DW4 174.88,25.97 177.21,23.64 179.31,23.64 TP13.1
TP_DW6: length 6
  TOP w0.081: UC1.DW6 175.1,26.31 175.1,26.01 177.19,23.91 TP9.1
TP_DW47: length 8.5
  TOP w0.081: TP23.1 181.43,50.42 179.99,48.98 179.07,48.98 178.85,49.21 177.41,49.21 175.03,46.83 UC1.DW47
TP_E1: length 5.2
  TOP w0.081: UC1.E1 127.01,22.77 127.01,20.06 TP60.1
TP_EN: length 90.8
  TOP w0.081: v1(242.13,15.51) 242.13,15.12 242.45,14.8 242.45,11.05 v3(242.6,10.9) 242.6,9.49 243.83,8.27 248.9,8.27 249.59,7.58 252.38,7.58 253.85,6.11 JIO1.35
  IN1 w0.064: v1(213.5,60.36) 213.5,60.36 213.65,60.51 v2(213.65,60.68) ; v2(229.13,21.95) 229.46,21.61 229.46,20.25 230.13,18.63 231.04,17.72 239.22,17.72 239.68,17.26 240.11,17.26 241.18,16.19 241.45,16.19 v1(242.13,15.51)
  IN3 w0.064: v2(213.65,60.68) 213.86,60.47 214.05,60.47 214.26,60.25 214.42,60.25 214.99,60.82 218.67,60.82 219.6,59.89 219.6,48.27 215.88,44.55 215.88,38.55 216.98,37.45 219.6,37.45 221.69,35.36 221.69,34.01 221.7,34 221.7,27.77 225.45,24.03 226.64,24.03 227.68,22.99 228.02,22.99 229.07,21.95 v2(229.13,21.95)
TP_F15: length 1.2
  TOP w0.081: UC1.F15 128.7,31.28 v5(129.06,30.92)
  BOTTOM w0.081: v5(129.06,30.92) 128.75,30.61 TP7.1
TP_G15: length 1.1
  TOP w0.081: v5(129.62,30.91) 129.35,31.18 UC1.G15
  BOTTOM w0.081: v5(129.62,30.91) 129.51,30.8 TP8.1
TP_J34: length 2.3
  TOP w0.089: v5(130.65,40.87) 130.36,40.57 UC1.J34
  BOTTOM w0.081: v5(130.65,40.87) 130.21,41.31 TP95.1
TP_N34: length 1.6
  TOP w0.089: UC1.N34 132.33,40.47 v5(132.67,40.82)
  BOTTOM w0.081: TP88.1 133.19,40.99 132.85,40.99 v5(132.67,40.82)
TP_P10: length 1
  TOP w0.081: UC1.P10 v5(132.94,28.28)
  BOTTOM w0.081: TP87.1 132.56,28.66 v5(132.94,28.28)
TP_R1: length 3.7
  TOP w0.081: TP18.1 133.7,23.83 UC1.R1
TPM_GPIO0: length 3.2
  TOP w0.081: U712.6 207.44,7.58 R747.2 207.42,7.53 207.17,7.28 207.09,7.28 207.09,7.27 206.59,7.27 206.59,7.28 206.22,7.28 v3(205.96,7.53)
TPM_GPIO0_NU: length 2.2
  TOP w0.081: U712.29 211.17,12.08 R54.2 v3(212.19,12.09)
TPM_GPP_B17_SMI#_NMI: length 4
  TOP w0.089: UC1.CF47 158.47,46.22 v1(158.71,46.22)
  IN1 w0.064: v2(159.04,46.2) 159.02,46.22 v1(158.71,46.22)
  IN3 w0.064: v2(159.04,46.2) v4(159.04,46.54)
  BOTTOM w0.081: v4(159.04,46.54) 158.92,46.54 158.64,46.82 RC254.2 RC339.2 158.08,46.81 158.25,46.64 v3(158.25,46.21)
TPM_PIRQ#: length 1.4
  BOTTOM w0.081: RC255.2 159.44,47.42 RC338.2 RH737.2
TPM_PIRQ#_B20: length 3
  IN1 w0.064: v2(161.01,46.71) 160.94,46.65 160.56,46.65 v1(160.55,46.63)
  IN3 w0.064: v2(161.01,46.71) 160.9,46.71 v4(160.56,46.37)
  BOTTOM w0.081: v3(161.96,46.37) v4(160.56,46.37) 160.43,46.49 RH737.1
TPM_PIRQ#_R: length 124.6
  TOP w0.081: v1(213.47,3.66) 215.02,5.21 215.02,5.73 R656.2 214.5,7.08 U712.18
  IN1 w0.064: v2(212.63,3.82) 212.8,3.66 v1(213.47,3.66) ; v2(178.08,16.36) 178.46,16.73 184.11,16.73 184.55,16.29 190.65,16.29 194.74,20.38 194.74,23.03 193.6,24.16 v2(193.6,24.51)
  IN2 w0.051: v2(212.63,3.82) 212.36,3.55 205.87,3.55 204.88,4.55 187.66,4.55 185.83,6.37 181.57,6.37 180.75,7.19 180.75,9.3 178.08,11.97 v2(178.08,16.36) ; v2(193.6,24.51) 193.43,24.68 190.27,24.68 187.7,27.26 187.7,29.87 185.15,32.42 183.71,32.42 182.7,33.43 177.42,33.43 177.05,33.8 176.37,33.8 176,33.43 173.52,33.43 172.56,34.39 171.55,34.39 171.42,34.26 169.45,34.26 169.25,34.47 169.25,35.01 169.46,35.23 169.46,38.04 168.69,38.81 167.51,38.81 167.27,39.05 165.99,39.05 164.55,40.49 164.55,40.86 164.87,41.17 164.87,42.1 163.9,43.06 162.25,43.06 161.71,43.61 161.71,43.99 161.06,44.64 161.06,45.13 160.38,45.81 160.38,46.4 160.23,46.55 160.23,46.95 160.11,47.07 v2(159.85,47.07)
  IN3 w0.064: v4(159.2,47.76) 159.23,47.76 159.85,47.14 v2(159.85,47.07)
  BOTTOM w0.081: v4(159.2,47.76) RC254.1
TS_I2C_SCL: length 170.8
  IN1 w0.064: v2(198.74,65.63) 198.91,65.46 198.91,64.99 199.06,64.84 199.06,63.29 198.88,63.11 198.88,60.51 200.59,58.8 200.59,54.28 198.48,52.17 198.48,50.9 198.54,50.84 198.54,49.61 198.48,49.56 198.48,49.56 194.85,45.93 194.85,36.92 196.28,35.49 196.28,32.96 195.49,32.17 195.49,30.97 195.35,30.82 195.35,26.26 195.55,26.06 195.55,25.52 195.39,25.36 195.12,25.36 v2(194.95,25.53) ; v1(173.14,35.26) 173.41,35.26 v2(173.58,35.43)
  IN2 w0.051: v2(194.95,25.53) 194.79,25.37 190.56,25.37 188.39,27.54 188.39,30.16 185.44,33.11 183.99,33.11 182.97,34.12 179.1,34.12 178.47,34.75 173.41,34.75 173.13,35.03 173.13,35.27 173.3,35.43 v2(173.58,35.43)
  IN3 w0.064: v2(198.74,65.63) 198.74,65.26 198.55,65.07 191.05,65.07 190.95,64.97 173.68,64.97 173.04,65.61 173.04,70.87 169.83,74.09 169.83,77.52 166.88,80.47 159.7,80.47 158.33,79.1 156.41,79.1 153.35,76.04 153.35,74.54 153.4,74.49 153.4,73.24 152.74,72.59 145.54,72.59 142.65,75.47 142.65,76.43 142.21,76.87 141.72,76.87 141.5,77.09 133.09,77.09 132.52,76.52 129.71,76.52 129.03,75.83 129.03,75.23 v4(128.94,75.14)
  BOTTOM w0.081: v4(128.94,75.14) 129.11,75.31 129.11,76.68 129.26,76.83 129.26,78.74 129.65,79.13 v7(130.25,79.13) 131.12,79.13 131.23,79.25 R1015.1
TS_I2C_SCL_R: length 9.8
  TOP w0.081: v1(130.91,83.15) 131,83.23 131,83.44 130.9,83.53 JEDP1.26
  IN1 w0.064: v1(130.91,83.15) 131,83.05 131,82.19 131.65,81.55 131.88,81.55 132,81.42 132,81.27 v2(131.83,81.1) 131.99,80.95 131.99,80.62 131.27,79.9 131.27,79.09 130.95,78.78 130.33,78.78 130.27,78.84 v1(130.27,79.41)
  IN3 w0.064: v4(131.94,80.39) 132.02,80.47 132.02,80.91 v2(131.83,81.1)
  BOTTOM w0.081: R239.1 132.03,80.74 132.03,80.48 v4(131.94,80.39) 132.03,80.3 132.03,80.03 R1015.2
TS_I2C_SDA: length 172
  IN1 w0.064: v2(199.27,65.63) 199.1,65.46 199.1,65.07 199.25,64.92 199.25,63.21 199.07,63.03 199.07,60.59 200.78,58.88 200.78,54.2 198.67,52.09 198.67,50.98 198.73,50.92 198.73,50.92 198.73,49.54 198.72,49.53 195.04,45.85 195.04,36.99 196.47,35.57 196.47,32.88 195.68,32.09 195.68,30.89 195.54,30.75 195.54,26.34 195.74,26.14 195.74,25.44 195.47,25.17 195.12,25.17 v2(194.95,25) ; v2(173.08,35.72) 173.07,35.72 173.07,35.72 173,35.72 v1(172.81,35.91)
  IN2 w0.051: v2(194.95,25) 194.75,25.19 190.48,25.19 188.21,27.47 188.21,30.08 185.36,32.93 183.92,32.93 182.9,33.95 179.03,33.95 178.4,34.57 173.32,34.57 172.94,34.95 172.94,35.35 173.08,35.48 v2(173.08,35.72)
  IN3 w0.064: v2(199.27,65.63) 199.04,65.41 199.04,65.3 198.62,64.88 191.13,64.88 191.03,64.78 173.6,64.78 172.85,65.53 172.85,70.79 169.63,74.01 169.63,77.44 166.8,80.28 159.78,80.28 158.41,78.91 156.49,78.91 153.54,75.96 153.54,74.62 153.59,74.57 153.59,73.16 152.82,72.39 145.46,72.39 142.46,75.4 142.46,76.35 142.13,76.68 141.64,76.68 141.42,76.9 133.17,76.9 132.6,76.33 129.79,76.33 129.22,75.75 129.22,75.24 v4(129.32,75.14)
  BOTTOM w0.081: R1016.1 132.43,78.91 132.27,78.75 131.21,78.75 131.03,78.93 129.74,78.93 129.47,78.66 129.47,76.74 129.32,76.59 v4(129.32,75.14)
TS_I2C_SDA_R: length 10.1
  TOP w0.081: v1(131.29,83.15) 131.2,83.23 131.2,83.44 131.3,83.53 JEDP1.25
  IN1 w0.064: v1(131.29,83.15) 131.2,83.05 131.2,82.27 131.73,81.74 131.96,81.74 132.2,81.5 132.2,81.27 v2(132.37,81.1) 132.18,80.91 132.18,80.54 131.46,79.82 131.46,79.01 131.03,78.59 130.33,78.59 130.27,78.52 v1(130.27,77.95)
  IN3 w0.064: v2(132.37,81.1) 132.21,80.95 132.21,80.5 v4(132.32,80.39)
  BOTTOM w0.081: R1016.2 132.24,80.02 132.24,80.31 v4(132.32,80.39) 132.24,80.47 132.24,80.75 R238.1
TS_INT#: length 157.9
  TOP w0.081: JEDP1.28 130.1,83.01 v5(129.86,82.78)
  IN1 w0.064: v2(196.11,54.65) 197.95,56.49 197.95,59.07 197.37,59.65 197.37,60.36 197.49,60.48 197.49,65.11 197.66,65.29 197.66,66.91 196.15,68.43 195.65,68.43 v2(195.35,68.12) ; v5(129.86,82.78) 129.86,82.1 130.14,81.82 130.14,80.86 128.94,79.65 v1(128.94,79.41) ; v2(184.87,30.89) 183.65,30.89 183.53,30.77 183.53,30.01 182.3,28.78 180.09,28.78 177.67,31.2 174.64,31.2 v1(174.11,30.67)
  IN3 w0.064: v2(195.35,68.12) 195.17,67.95 193.84,67.95 193.49,68.31 193.27,68.31 192.83,67.87 190.5,67.87 189.64,68.72 179.41,68.72 178.39,69.75 176.98,69.75 171.44,75.29 171.44,78.51 170.36,79.59 170.36,83.11 169.41,84.06 153.93,84.06 153.16,83.29 153.16,79.91 151.98,78.74 151.98,75.12 151.43,74.57 145.58,74.57 144.8,75.35 144.8,78.44 144.38,78.86 137.18,78.86 136.8,78.48 134.21,78.48 133.83,78.86 132.16,78.86 130.3,80.72 v4(129.83,80.72) ; v2(184.87,30.89) 185.2,31.22 186.75,31.22 188.86,33.33 189.11,33.58 189.11,35.8 189.25,35.94 189.82,35.94 190.32,36.44 190.32,40.3 191.87,41.85 191.87,47.91 191.44,48.35 191.44,51.3 193.19,53.05 195.15,53.05 195.79,53.69 195.79,54.33 v2(196.11,54.65)
  BOTTOM w0.081: v5(129.86,82.78) 129.86,82.02 129.95,81.93 D471.2 129.86,81.76 129.65,81.76 129.57,81.68 129.57,80.97 v4(129.83,80.72)
TS_RST#: length 117.7
  TOP w0.081: JEDP1.29 129.7,83.3 129.47,83.07 v5(129.47,82.37)
  TOP w0.089: UC1.CV47 v1(163.99,46.34)
  IN1 w0.064: v2(176.23,69.8) 177.08,69.8 177.89,68.99 177.89,65.82 177.32,65.25 174.14,65.25 173.77,64.88 173.77,62.95 173.83,62.88 174.26,62.88 174.77,62.37 175.8,62.37 176.01,62.16 176.01,60.83 175.31,60.13 174.83,60.13 174.47,59.77 174.47,59.21 174.96,58.72 174.96,57.43 174.51,56.98 174.51,55.38 174.8,55.1 174.8,52.51 172.95,50.66 171.78,50.66 170.46,49.34 170.44,49.34 169.98,48.89 169.61,48.89 169.41,48.69 167.26,48.69 167.11,48.54 166.05,48.54 165.67,48.16 165.67,46.56 165.11,46 164.62,46 164.27,46.34 v1(163.99,46.34) ; v1(127.6,77.95) 128.43,78.78 128.43,79.68 129.19,80.44 129.19,82.02 129.47,82.29 v5(129.47,82.37)
  IN3 w0.064: v4(129.13,80.72) 129.13,80.55 130.99,78.69 133.76,78.69 134.14,78.31 136.87,78.31 137.25,78.69 144.31,78.69 144.63,78.37 144.63,75.28 145.51,74.4 151.5,74.4 152.16,75.06 152.16,78.68 153.32,79.84 153.32,83.22 154,83.9 166.63,83.9 167.9,82.62 167.9,81.45 171.27,78.08 171.27,75.22 176.23,70.27 v2(176.23,69.8)
  BOTTOM w0.081: v5(129.47,82.37) 129.13,82.03 D466.2 129.03,81.76 128.88,81.76 128.8,81.68 128.8,81.05 v4(129.13,80.72)
UART2_CTS#: length 32.2
  TOP w0.081: RC656.1 175.8,33.56 175.14,34.23 173.84,34.23 UC1.DU22 173.17,34.9 172.63,34.9 172.32,34.59 172.32,30.21 v1(172.38,30.14)
  IN1 w0.064: v1(172.38,30.14) 172.51,30.02 172.51,29.81 v2(172.37,29.67)
  IN3 w0.064: v2(172.37,29.67) 172.73,29.31 173.56,29.31 173.96,29.72 178.54,29.72 179.96,28.3 182.05,28.3 183.58,29.83 183.58,30.87 185.13,32.42 187.04,32.42 v4(188.12,33.5)
  BOTTOM w0.081: JUART1.4 189.32,33.75 189.07,33.5 v4(188.12,33.5) 188.12,33.36 v3(188.53,32.95)
UART2_RTS#: length 15.4
  TOP w0.081: UC1.DV22 174.41,34.9 174.96,34.9 175.16,35.1 175.47,35.1 175.86,34.71 v1(176.84,34.71)
  IN1 w0.064: v1(176.84,34.71) 177.16,35.03 177.69,35.03 178.22,34.49 183.09,34.49 183.62,33.97 184.09,33.97 v2(184.26,34.14)
  IN3 w0.064: v2(184.26,34.14) 184.44,34.14 184.65,34.35 186.86,34.35 v4(186.92,34.29)
  BOTTOM w0.081: v3(187.11,32.89) 186.92,33.08 v4(186.92,34.29)

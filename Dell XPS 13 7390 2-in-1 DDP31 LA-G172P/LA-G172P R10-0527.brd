# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UART2_RXD: length 226.8
  TOP w0.081: RC222.1 175.86,32.99 175.23,33.63 173.58,33.63 173.16,34.05 173.16,34.26 UC1.DT22 172.65,34.61 172.5,34.45 172.5,30.41 v1(172.76,30.16)
  IN1 w0.064: v1(172.76,30.16) 172.76,29.81 v2(172.92,29.65)
  IN3 w0.064: v4(190.23,51.15) 190.13,51.05 190.13,49.17 190.48,48.81 190.48,48.37 191.21,47.64 191.21,42.13 189.66,40.58 189.66,38.59 188.52,37.44 v4(188.52,34.29) 188.52,34.28 186.82,32.59 185.06,32.59 183.41,30.94 183.41,29.9 181.98,28.46 180.02,28.46 178.61,29.88 173.9,29.88 173.66,29.65 v2(172.92,29.65) ; v4(105.06,9.32) 108.46,9.32 111.07,6.71 112.53,6.71 113.3,5.94 119.36,5.94 120.11,6.68 122.15,6.68 122.68,6.14 122.68,4.01 123.32,3.37 124.8,3.37 v4(125.06,3.11)
  BOTTOM w0.081: v4(190.23,51.15) 189.9,51.15 v3(188.53,52.52) 186.3,54.75 181.94,54.75 176.11,48.92 169.58,48.92 168.12,50.37 168.12,50.45 166.32,52.26 155.3,52.26 154.84,52.72 129.09,52.72 128.65,53.16 126.54,53.16 125.93,53.77 122.82,53.77 120.72,55.87 104.96,55.87 104.55,55.46 104.55,48.1 100.33,43.87 95.37,43.87 93.43,41.92 93.43,32.52 99.57,26.37 103.5,26.37 105.94,23.93 105.94,19 104.78,17.83 104.78,9.61 v4(105.06,9.32)
UART2_TXD: length 214.9
  TOP w0.081: RC223.1 176.17,34.14 175.6,34.71 ; UC1.DW22 175.14,34.61 175.34,34.81 v1(175.34,34.8)
  TOP w0.089: 175.6,34.71 175.51,34.8 v1(175.34,34.8)
  IN1 w0.064: v2(184.25,34.67) 184.09,34.82 178.36,34.82 177.67,35.51 176.46,35.51 175.74,34.8 v1(175.34,34.8)
  IN3 w0.064: v4(104.82,9.06) 105.17,9.06 105.23,9.12 108.42,9.12 111,6.55 112.39,6.55 113.17,5.77 119.43,5.77 120.17,6.51 122.08,6.51 122.52,6.08 122.52,3.73 123.13,3.11 v4(124.43,3.11) ; v2(184.25,34.67) 184.37,34.55 187.46,34.55 v4(187.72,34.29) 187.93,34.5 187.93,39.08 191.01,42.16 191.01,46.58 190.32,47.27 190.32,48.74 189.96,49.1 189.96,51.45 190.02,51.51 v4(190.22,51.51)
  BOTTOM w0.081: v4(104.82,9.06) 104.59,9.29 104.59,17.91 105.76,19.07 105.76,23.86 103.42,26.19 99.5,26.19 93.24,32.45 93.24,42 95.3,44.05 100.25,44.05 104.17,47.97 v3(104.17,50.58) 104.17,55.34 104.88,56.05 108.35,56.05 108.92,56.63 109.27,56.63 109.84,56.05 120.8,56.05 122.77,54.08 125.91,54.08 126.59,53.4 128.35,53.4 129.03,54.08 137.32,54.08 138.49,52.9 154.92,52.9 155.38,52.44 166.4,52.44 168.31,50.53 168.31,50.45 169.65,49.11 176.03,49.11 181.86,54.94 186.79,54.94 v4(190.22,51.51)
UART_RX_I_S: length 17.3
  TOP w0.081: USSD1.AA17 206.39,31.98 206.39,33.84 205.59,34.64 205.59,35.24 206.39,36.04 207.81,36.04 208.57,36.8 208.57,43 v5(209.12,43.56)
  BOTTOM w0.081: JSSD1.6 v5(209.12,43.56)
UART_TX_I_S: length 15.8
  TOP w0.081: v5(209.12,42.56) 208.75,42.19 208.75,36.72 207.81,35.79 206.79,35.79 206.28,35.28 206.28,34.52 207.02,33.78 207.02,32.16 USSD1.AA18
  BOTTOM w0.081: JSSD1.7 v5(209.12,42.56)
UFCAM_LED: length 56.1
  TOP w0.089: UC1.CV48 164.3,47.16 164.42,47.03 v1(164.42,46.98)
  IN1 w0.064: v1(164.42,46.98) 164.52,46.88 164.72,46.88 164.72,46.88 164.86,46.88 164.9,46.84 164.94,46.84 164.98,46.8 165.45,46.8 165.51,46.86 165.51,47.34 165.5,47.36 165.5,48.23 165.98,48.7 167.04,48.7 167.2,48.86 169.11,48.86 v2(169.38,49.13)
  IN3 w0.064: v2(169.38,49.13) 169.5,49.25 169.5,49.53 169.64,49.67 171.67,49.67 171.96,49.38 172.38,49.38 172.58,49.19 172.58,48.76 172.66,48.68 172.8,48.68 173.27,49.15 173.27,49.64 173.82,50.19 174.13,50.19 174.62,50.68 174.66,50.68 175.45,51.47 175.88,51.47 176.66,52.26 176.66,52.63 176.06,53.23 176.06,55.12 176.51,55.57 176.51,57.32 175.05,58.78 174.61,58.78 172.46,60.93 172.46,63.24 171.4,64.3 171.4,67.93 167.63,71.71 167.63,73.63 165.7,75.55 165.7,75.87 164.97,76.6 164.29,76.6 163.94,76.95 163.11,76.95 162.88,77.17 162.55,77.17 162.47,77.1 162.26,77.1 162.18,77.17 160.23,77.17 159.68,76.63 158.63,76.63 v4(158.62,76.62)
  BOTTOM w0.081: R709.1 157.72,77.87 QC1.2 158.5,77.85 v3(158.5,77.06) 158.62,76.93 v4(158.62,76.62)
UFCAM_LED_R: length 7.9
  TOP w0.081: v5(157.83,82.14) 157.8,82.17 157.8,82.87 158.3,83.37 JUFC1.24
  IN1 w0.064: v1(156.99,78.48) 157.23,78.73 157.23,79.3 157.35,79.42 157.35,81.67 v5(157.83,82.14)
  BOTTOM w0.081: v5(157.83,82.14) 158.02,81.96 v3(158.32,81.96) 158.33,81.96 159.23,81.06 R710.2
UFCAM_MCLK: length 60.8
  TOP w0.089: UC1.DP38 171.98,42.72 171.67,43.03 171.67,43.64 171.58,43.72 169.2,43.72 169.07,43.85 169.07,45.57 168.31,46.32 v1(167.86,46.32)
  IN1 w0.064: v1(167.86,46.32) 167.86,46.33 167.63,46.56 v2(167.63,46.81)
  IN3 w0.064: v2(167.63,46.81) 167.36,46.81 167.06,47.11 167.06,47.37 168.81,49.12 168.81,49.59 169.48,50.27 173.33,50.27 174.81,51.75 174.81,52.86 175.54,53.59 175.54,55.84 171.58,59.8 171.58,63.16 170.82,63.92 170.82,66.54 167.59,69.77 167.01,70.35 167.01,72.58 164.4,75.19 164.4,75.76 163.73,76.43 162.5,76.43 162.02,75.95 160.32,75.95 159.92,75.54 159.27,75.54 158.85,75.97 158.04,75.97 157.99,75.92 157.71,75.92 157.65,75.98 157.5,75.98 v4(157.42,76.07)
  BOTTOM w0.081: v4(157.42,76.07) v3(156.9,76.58) 155.05,78.44 155.05,79.32 154.67,79.7 R6141.1
UFCAM_MCLK_R: length 9.6
  TOP w0.081: v5(155.11,81.64) 155.34,81.86 155.59,81.86 157.1,83.37 JUFC1.27
  IN1 w0.064: v5(155.11,81.64) 154.7,81.22 154.7,79.27 155.39,78.57 155.39,78.27 155.78,77.89 v1(155.78,77.57)
  BOTTOM w0.081: R6141.2 154.51,80.93 v3(154.51,81.69) 154.59,81.77 154.98,81.77 v5(155.11,81.64)
UFCAM_RESET#: length 126.5
  TOP w0.081: v1(173.46,35.91) 173.51,35.95 174.03,36.17 175,36.17 175.07,36.1 175.71,36.1 175.99,35.81 176.22,35.81 176.75,35.28 RH658.1
  IN1 w0.064: v1(173.46,35.91) 173.46,36 175.31,37.84 176.44,37.84 176.62,38.02 177.56,38.02 178.78,36.8 179.97,36.8 180.11,36.66 181.57,36.66 181.64,36.73 181.96,36.73 184.08,38.85 184.08,39.71 184.5,40.13 184.5,41.27 184.7,41.47 184.7,42.45 184.07,43.08 181.63,43.08 179.67,45.04 179.67,48.03 181.91,50.27 182.98,50.27 v2(183.55,50.84)
  IN2 w0.051: v5(192.29,51.28) 192.16,51.15 190.58,51.15 189.78,50.35 188.26,50.35 188.12,50.49 183.89,50.49 v2(183.55,50.84)
  IN3 w0.064: v4(155.67,82.84) 156.56,82.84 157.45,83.73 166.56,83.73 167.74,82.56 167.74,81.39 171.11,78.01 171.11,75.15 175.89,70.38 175.89,69.67 176.12,69.44 178.47,69.44 179.48,68.43 189.71,68.43 190.45,67.69 193.02,67.69 v4(193.38,68.05)
  BOTTOM w0.081: v4(155.67,82.84) 156.04,82.84 157.25,81.63 157.37,81.63 157.62,81.38 157.96,81.38 158.11,81.23 158.11,80.87 R6142.1 D450.2 ; v4(193.38,68.04) 193.38,67.52 193.53,67.36 196.36,67.36 v3(197.2,66.52) 198.98,64.74 198.98,59.54 198.14,58.7 198.14,56.85 196.65,55.36 196.65,52.85 196.91,52.59 196.91,49.93 196.28,49.3 195.73,49.3 195.28,48.85 193.66,48.85 192.29,50.22 v5(192.29,51.28)
UFCAM_RESET#_R: length 7.1
  TOP w0.081: v5(157.26,82.14) 157.26,82.8 157.9,83.44 JUFC1.25
  IN1 w0.064: v5(157.26,82.14) 157.19,82.07 157.19,79.62 v1(157,79.44)
  BOTTOM w0.081: v3(156.89,82.46) 156.94,82.46 v5(157.26,82.14) 157.84,81.56 158.03,81.56 158.54,81.06 R6142.2
UPD_L_SMBCLK: length 2.6
  TOP w0.081: UM1.18 13.48,55.09 13.28,55.28 12.66,55.28 12.37,54.99 12.37,54.88 12.42,54.84 12.59,54.84 12.67,54.76 RM19.1
UPD_L_SMBDAT: length 2.7
  TOP w0.081: UM1.17 12.58,55.49 12.16,55.08 12.16,54.56 RM20.1
UPD_L_SMBINT#: length 257.1
  TOP w0.081: RPD17.2 20.34,19.14 v3(20.77,19.14) 20.88,19.25 20.88,20.08 20.77,20.19 v1(20.77,20.46)
  IN1 w0.064: v1(20.77,20.46) 20.86,20.55 v2(21.13,20.55) ; v2(214.35,61.63) 214.35,61.91 v1(214.3,61.96)
  IN2 w0.051: v2(214.35,61.63) 214.54,61.44 214.54,60.68 213.87,60.01 210.95,60.01 210.6,60.37 209.08,60.37 208.43,59.71 207.93,59.71 207.65,59.43 204.97,59.43 204.77,59.23 202.76,59.23 202.53,59 201.65,59 201.17,59.48 196.17,59.48 195.56,60.09 193.08,60.09 190.64,57.66 189.38,57.66 188.37,58.67 183.34,58.67 182.23,59.78 180.94,59.78 180.06,60.65 178.56,60.65 177.88,61.33 172.36,61.33 171.54,60.51 170.87,60.51 169.59,59.23 166.53,59.23 165.66,58.36 165.66,55.95 163.26,53.55 156.92,53.55 155.7,54.77 154.93,54.77 154.36,54.2 149.97,54.2 149.19,54.98 145.85,54.98 145.41,54.54 145.01,54.54 144.71,54.84 143.73,54.84 143.39,54.51 137.04,54.51 136.58,54.96 129.59,54.96 128.71,54.09 127.95,54.09 127.65,53.78 122.79,53.78 121.84,54.74 114.42,54.74 114.29,54.61 113.97,54.61 113.09,53.73 111.59,53.73 111.35,53.49 108.76,53.49 107.92,52.66 101.64,52.66 98.73,49.75 91.82,49.75 89.35,47.28 89.35,22.1 87.12,19.86 87.12,10.39 86.62,9.9 86.62,9.69 85.53,8.6 84.52,8.6 83.46,9.66 83.46,11.01 78.25,16.22 70.13,16.22 69.54,15.63 32.96,15.63 32.24,16.36 31.66,16.36 31.64,16.34 31.47,16.34 30.78,15.66 27.21,15.66 27.07,15.8 27.07,16.36 26.7,16.72 25.12,16.72 25,16.85 23.1,16.85 22.4,17.55 22.4,19.52 21.36,20.55 v2(21.13,20.55)
  IN3 w0.064: v4(214.22,62.04) 214.35,61.91 v2(214.35,61.63)
UPD_R_SMBCLK: length 2
  TOP w0.081: UM2.18 272.89,55.01 272.8,54.91 272.8,54.57 272.53,54.31 272.53,53.97 RM21.1
UPD_R_SMBDAT: length 2
  TOP w0.081: RM22.1 272.32,53.99 272.32,54.39 272.59,54.66 272.59,54.91 272.49,55.01 UM2.17
UPD_R_SMBINT#: length 147.7
  TOP w0.081: RPD109.2 288.51,9.88 288.96,10.32 288.96,15.44 289.26,15.75 v1(289.26,16.57)
  IN1 w0.064: v1(210.3,61.96) 210.3,61.76 v2(210.41,61.65) ; v2(288.99,17.15) 288.99,16.84 v1(289.26,16.57)
  IN2 w0.051: v2(229.47,22.72) 229.48,22.71 229.48,19.28 231.03,17.73 233.18,17.73 234.01,18.55 235.3,18.55 v2(235.49,18.36)
  IN3 w0.064: v4(288.83,17.63) 288.83,17.31 v2(288.99,17.15) ; v2(235.49,18.36) 235.68,18.55 236.06,18.55 236.72,19.22 240.22,19.22 240.26,19.2 241.24,19.02 241.37,18.88 241.96,18.29 257.65,18.29 258.45,19.09 v4(260.7,19.09) ; v2(229.47,22.72) 229.28,22.91 228.68,22.91 228.27,23.32 227.82,23.32 226.78,24.36 225.58,24.36 222.03,27.91 222.03,35.34 222.02,35.35 222.02,35.5 219.74,37.78 217.12,37.78 216.21,38.69 216.21,44.41 219.93,48.13 219.93,60.03 218.81,61.15 214.76,61.15 214.62,61.3 213.96,61.3 213.74,61.52 211.81,61.52 v4(211.11,62.23) 210.99,62.23 v2(210.41,61.65)
  BOTTOM w0.081: v4(288.83,17.63) v6(288.32,18.13) 288.32,18.32 286.51,20.13 286.51,22.36 288.1,23.94 288.1,27.31 287.81,27.6 286.73,27.6 284.97,25.83 284.97,24.31 283.88,23.21 273.97,23.21 273.53,23.66 268.89,23.66 267.18,21.94 265.72,21.94 263.43,19.66 261.59,19.66 261.02,19.09 v4(260.7,19.09)
UPD_SMBCLK: length 9.6
  TOP w0.081: Q30.1 210.52,70.46 209.81,70.46 RE462.1 209.29,70.29 v1(209.2,70.2)
  IN1 w0.064: v1(209.2,70.2) 209.31,70.31 209.46,70.31 209.52,70.25 209.52,69.78 209.01,69.27 209.01,66.08 209.16,65.93 209.16,64.49 v2(209.03,64.36) v1(208.7,64.36)
  IN3 w0.064: v2(209.03,64.36) 208.48,64.91 v4(208.25,64.91)
UPD_SMBCLK_Q: length 551.2
  TOP w0.081: v1(271.24,52.47) 271.33,52.56 272.32,52.56 272.52,52.76 272.52,53.03 RM21.2 ; v1(258.41,11.02) 258.35,11.09 258.35,12.74 260.07,14.45 260.07,18.41 260.41,18.75 261.1,18.75 261.43,19.08 261.43,19.62 261.23,19.83 260.79,19.83 v1(260.7,19.91) ; v5(79.58,7.82) 79.32,7.82 79.11,7.61 78.22,7.61 76.6,5.99 74.63,5.99 71.24,9.38 71.24,14.62 v1(71.16,14.71) ; v5(12.68,53.17) 12.49,53.36 12.49,53.73 RM19.2 ; v1(211.81,71.35) 211.46,71.69 210.07,71.69 209.65,71.27 RE462.2 210.43,70.88 Q30.6
  IN1 w0.064: v2(70.77,15.58) 70.95,15.41 70.95,15.26 71.25,14.96 71.25,14.8 v1(71.16,14.71) ; v2(211.39,71.54) 211.23,71.39 211.23,71.24 211.51,70.96 211.73,70.96 211.81,71.03 v1(211.81,71.35) 211.93,71.35 212.31,70.97 213.2,70.97 214.23,69.94 216.86,69.94 217.22,70.3 219.73,70.3 222.04,67.99 222.04,43.25 221.33,42.53 221.33,27.56 224.48,24.42 224.48,23.6 224.9,23.18 224.9,21.47 225.77,20.6 225.77,17.99 229.51,14.25 232.42,14.25 232.86,13.81 239.38,13.81 239.83,13.37 244.22,13.37 246.76,15.9 247.75,15.9 248.6,16.75 254.4,16.75 254.67,16.48 257.07,16.48 260.38,19.79 260.57,19.79 v1(260.7,19.91) 260.83,19.79 261.08,19.79 261.58,20.28 261.58,21.16 262.43,22.02 262.43,23.06 263.81,24.44 267.1,24.44 270.99,28.32 270.99,33.25 270.77,33.47 270.77,35.97 271.3,36.5 271.3,37.01 272.29,37.99 272.29,42.04 272.61,42.37 273.1,42.37 v2(273.38,42.65) ; v2(284.68,6.26) 284.83,6.41 284.83,7.66 v1(284.63,7.86) ; v1(271.24,52.47) v2(271.24,52.11) ; v1(258.41,11.02) 258.32,10.93 258.32,10.55 v2(258.47,10.39)
  IN2 w0.051: v5(79.58,7.82) 79.58,8.1 79.74,8.26 79.74,8.48 76.32,11.9 76.02,11.9 75.99,11.92 31.64,11.92 30.95,12.61 23.81,12.61 18.87,17.55 18.87,18.8 14.69,22.98 14.69,33.74 15.93,34.98 16.05,34.98 v2(16.23,34.81) ; v2(271.24,52.11) 271.24,52.61 271.36,52.73 271.82,52.73 272.78,51.78 272.78,44.64 273.76,43.66 273.76,42.55 273.68,42.47 273.56,42.47 v2(273.38,42.65)
  IN3 w0.064: v5(12.68,53.17) 12.48,52.97 12.48,52.49 15.08,49.88 15.08,48.19 15.48,47.79 18.15,47.79 18.56,47.38 18.56,43.88 17.56,42.88 17.56,35.84 17.38,35.66 17.15,35.66 17.02,35.66 v4(16.96,35.6) 16.8,35.44 16.8,35.38 v2(16.23,34.81) ; v2(284.68,6.26) 284.89,6.04 284.89,5.75 284.83,5.69 283.75,5.69 282.1,7.34 281.1,7.34 280.78,7.66 275,7.66 273.72,8.94 266.31,8.94 265.44,9.82 262,9.82 261.73,9.54 261.45,9.54 260.92,10.07 258.53,10.07 258.38,10.22 258.38,10.31 v2(258.47,10.39) ; v2(211.39,71.54) 211.21,71.71 211.21,72.13 210.8,72.54 204.72,72.54 203.93,71.76 203.93,69.67 202.81,68.55 200.57,68.55 200.18,68.17 198.39,68.17 197.21,66.99 190.08,66.99 189.34,67.73 178.78,67.73 177.81,68.7 175.87,68.7 175.19,69.38 175.19,70.09 170.38,74.89 170.38,77.75 167.11,81.02 159.46,81.02 158.1,79.66 156.18,79.66 152.79,76.27 152.79,74.22 152.84,74.17 152.84,73.48 152.51,73.14 145.95,73.14 143.53,75.56 143.53,76.53 143.12,76.94 142.94,76.94 142.44,77.44 141.96,77.44 141.62,77.78 130.08,77.78 126.13,73.82 124.01,73.82 122.07,71.88 106.01,71.88 103.38,69.25 96.47,69.25 96.13,69.59 88.6,69.59 85.1,73.1 73.16,73.1 70.2,70.14 70.2,17.74 70.9,17.04 70.9,15.71 v2(70.77,15.58)
  BOTTOM w0.081: v4(16.96,35.6) v7(15.91,35.6) 14.51,35.6 14.38,35.47 13.17,35.47 RPD163.2
UPD_SMBDAT: length 12.6
  TOP w0.081: v1(209.2,70.59) 209.2,71.37 209.95,72.12 211.77,72.12 212.19,71.7 RE463.1 212.08,70.9 211.63,70.9 Q30.4
  IN1 w0.064: v1(209.5,65.16) 209.5,65.49 v2(209.49,65.49) 209.49,65.68 209.35,65.83 209.35,66.01 209.2,66.16 209.2,69.19 209.71,69.7 209.71,70.33 209.53,70.5 209.29,70.5 v1(209.2,70.59)
  IN3 w0.064: v4(209.52,64.91) 209.52,65.46 v2(209.49,65.49)
UPD_SMBDAT_Q: length 547.4
  TOP w0.081: v1(212.19,70.42) 212.02,70.59 211.69,70.59 Q30.3 ; v1(258.03,11.02) 258.14,11.13 258.14,12.82 259.86,14.54 259.86,18.5 260.32,18.96 261.02,18.96 261.22,19.16 261.22,19.54 261.14,19.62 260.79,19.62 v1(260.7,19.53) ; v5(79.17,8.23) 79.17,7.96 79.02,7.82 78.13,7.82 76.51,6.2 74.72,6.2 71.45,9.46 71.45,14.62 v1(71.54,14.71) ; RM22.2 272.31,53.03 272.31,52.85 272.23,52.77 271.33,52.77 v1(271.24,52.85) ; v5(12.09,53.17) 12.28,53.36 12.28,53.73 RM20.2
  IN1 w0.064: v1(285.26,7.86) 285.02,7.62 285.02,6.45 v2(285.21,6.26) ; v2(71.31,15.58) 71.14,15.42 71.14,15.34 71.44,15.04 71.44,14.8 v1(71.54,14.71) ; 212.19,70.46 v1(212.19,70.42) ; 212.19,70.46 211.88,70.77 211.73,70.77 211.43,70.77 211.04,71.16 211.04,71.35 v2(210.85,71.54) ; 212.19,70.46 212.19,70.71 212.25,70.78 213.12,70.78 214.15,69.75 216.94,69.75 217.3,70.11 219.66,70.11 221.85,67.91 221.85,43.32 221.14,42.61 221.14,27.49 224.29,24.34 224.29,23.52 224.71,23.1 224.71,21.39 225.58,20.52 225.58,17.91 229.43,14.06 232.34,14.06 232.78,13.62 239.3,13.62 239.75,13.17 244.3,13.17 246.83,15.71 247.83,15.71 248.68,16.56 254.32,16.56 254.59,16.29 257.15,16.29 260.46,19.59 260.64,19.59 v1(260.7,19.53) 260.76,19.59 261.16,19.59 261.77,20.2 261.77,21.08 262.62,21.94 262.62,22.98 263.88,24.25 267.18,24.25 271.18,28.24 271.18,33.33 270.96,33.54 270.96,35.89 271.5,36.42 271.5,36.93 272.48,37.91 272.48,41.96 272.69,42.18 273.32,42.18 v2(273.38,42.12) ; v1(271.24,52.85) v2(271.24,53.19) ; v2(257.94,10.39) 258.13,10.58 258.13,10.93 v1(258.03,11.02)
  IN2 w0.051: v2(273.38,42.12) 273.56,42.29 273.75,42.29 273.93,42.47 273.93,43.73 272.96,44.71 272.96,51.85 271.89,52.91 271.52,52.91 v2(271.24,53.19) ; v5(79.17,8.23) 79.46,8.23 79.56,8.33 79.56,8.4 76.25,11.72 75.94,11.72 75.92,11.75 31.57,11.75 30.88,12.43 23.73,12.43 18.69,17.48 18.69,18.72 14.51,22.9 14.51,33.82 15.85,35.16 16.05,35.16 v2(16.23,35.34)
  IN3 w0.064: v2(71.31,15.58) 71.22,15.67 71.22,16.99 70.39,17.82 70.39,70.06 73.23,72.91 85.02,72.91 88.53,69.4 96.05,69.4 96.39,69.06 103.46,69.06 106.09,71.69 122.15,71.69 124.09,73.63 126.21,73.63 130.16,77.59 141.54,77.59 141.88,77.24 142.36,77.24 142.86,76.74 143.04,76.74 143.34,76.45 143.34,75.48 145.87,72.95 152.59,72.95 153.03,73.4 153.03,74.25 152.98,74.3 152.98,76.19 156.26,79.47 158.18,79.47 159.54,80.83 167.03,80.83 170.19,77.67 170.19,74.81 175,70.01 175,69.3 175.79,68.51 177.73,68.51 178.7,67.54 189.26,67.54 190,66.8 197.29,66.8 198.47,67.98 200.26,67.98 200.64,68.36 202.89,68.36 204.12,69.59 204.12,71.68 204.79,72.35 210.72,72.35 211.02,72.05 211.02,71.71 v2(210.85,71.54) ; v5(12.09,53.17) 12.29,52.97 12.29,52.41 14.89,49.81 14.89,48.11 15.4,47.6 18.07,47.6 18.37,47.3 18.37,43.96 17.37,42.96 17.37,35.91 17.3,35.85 17.09,35.85 v4(16.96,35.98) 16.61,35.63 16.61,35.46 16.49,35.34 v2(16.23,35.34) ; v2(285.21,6.26) 285.08,6.13 285.08,5.67 284.91,5.5 283.67,5.5 282.02,7.15 281.02,7.15 280.7,7.47 274.92,7.47 273.64,8.75 266.23,8.75 265.36,9.63 262.08,9.63 261.81,9.35 261.37,9.35 260.84,9.88 258.45,9.88 v2(257.94,10.39)
  BOTTOM w0.081: RPD164.2 13.26,35.68 v7(13.69,35.68) 14.3,35.68 14.42,35.8 16.78,35.8 v4(16.96,35.98)
USB2_COMP: length 4.3
  TOP w0.089: UC1.DN5 171.28,26.17 171.06,25.94 171.06,24 171.02,23.96 171.02,23.95
  TOP w0.305: 171.02,23.95 171.02,23.7 170.91,23.6 RH10.1
USB2_ID: length 5.1
  TOP w0.081: RH8.1 170.1,22.29 170.1,23.95
  TOP w0.089: 170.1,23.95 170.1,24.62 170.44,24.97 170.44,25.06 170.44,25.06 170.44,25.3 170.44,25.3 170.44,25.38 170.43,25.39 170.43,25.62 170.44,25.63 170.44,25.71 170.44,25.71 170.44,25.95 170.44,25.95 170.44,26.03 170.43,26.04 170.43,26.27 170.44,26.28 170.44,26.62 170.64,26.82 UC1.DL6
USB2_VBUSSENSE: length 19.7
  TOP w0.081: v5(170.4,29.96) 170.4,29.85 UC1.DL11 ; v1(183.9,30.58) 183.9,30.93 183.38,31.44 RH9.1
  IN1 w0.064: v1(183.9,30.58) 183.9,30.15 182.36,28.61 179.29,28.61 178.72,29.18 177.73,29.18 175.61,27.06 174.25,27.06 172.65,28.66 170.96,28.66 170.4,29.22 v5(170.4,29.96)
  BOTTOM w0.081: v5(170.4,29.96) v6(170.4,30.51)
USB3_PRX_DTX_N2: length 90.6
  TOP w0.091: JDEBUG1.10 228.08,3.32 227.68,3.72 227.68,5.37 227.56,5.49 227.07,5.49 v1(226.98,5.4)
  IN1 w0.081: v1(168.57,28.18) 168.71,28.04 169.29,28.04 v2(169.34,28.08) ; v2(221.3,20.1) 221.2,20 221.2,19.57 221.63,19.14 221.63,16.34 224.58,13.4 224.58,9.77 227.59,6.76 227.59,5.62 227.39,5.43 227.01,5.43 v1(226.98,5.4)
  IN3 w0.081: v2(221.3,20.1) 221.2,20.2 221.2,20.7 222.42,21.92 222.42,24.28 221.35,25.36 217.63,25.36 217.06,24.78 212.88,24.78 212.7,24.6 211.78,24.6 210.9,25.48 210.9,26.24 209.67,27.48 202.74,27.48 199.3,24.04 199.3,22.64 198.42,21.76 180.36,21.76 178.72,23.4 178.72,25.56 178.09,26.2 174.98,26.2 172.52,28.66 170.64,28.66 170.06,28.08 v2(169.34,28.08)
USB3_PRX_DTX_P2: length 90.5
  TOP w0.091: v1(226.98,5.78) 227.07,5.69 227.65,5.69 227.88,5.45 227.88,3.8 228.16,3.52 228.4,3.52 228.49,3.62 228.49,3.67 228.64,3.82 JDEBUG1.9
  IN1 w0.081: v2(220.77,20.1) 221,19.87 221,19.49 221.44,19.06 221.44,16.26 224.38,13.32 224.38,9.69 227.39,6.68 227.39,5.71 227.31,5.62 227.14,5.62 v1(226.98,5.78) ; v2(169.34,27.55) 169.04,27.84 168.88,27.84 v1(168.57,27.53)
  IN3 w0.081: v2(169.34,27.55) 169.67,27.88 170.15,27.88 170.72,28.46 172.44,28.46 174.89,26 178,26 178.52,25.48 178.52,23.32 180.28,21.57 198.5,21.57 199.49,22.56 199.49,23.96 202.82,27.28 209.59,27.28 210.71,26.16 210.71,25.39 211.7,24.4 212.78,24.4 212.96,24.59 217.14,24.59 217.71,25.16 221.27,25.16 222.22,24.2 222.22,22 221,20.78 221,20.34 v2(220.77,20.1)
USB3_PTX_C_DRX_N2: length 8.5
  IN1 w0.081: v1(229.18,4.82) 229.22,4.86 229.66,4.86 229.97,5.17 229.97,5.71 229.28,6.41 229.28,7.46 228.05,8.68 226.61,8.68 225.59,9.7 225.59,9.96 v1(225.7,10.07)
USB3_PTX_C_DRX_P2: length 8.4
  IN1 w0.081: v1(229.18,5.32) 229.18,5.18 229.3,5.06 229.58,5.06 229.77,5.25 229.77,5.63 229.08,6.32 229.08,7.38 227.97,8.48 226.53,8.48 225.39,9.62 225.39,9.82 v1(225.14,10.07)
USB3_PTX_DRX_N2: length 76.1
  IN1 w0.081: v1(169.59,25.51) 169.64,25.46 169.64,24.89 v2(170.26,24.27) ; v2(220.68,22.53) 220.51,22.36 220.51,21.87 220.88,21.51 221.6,21.51 222.22,20.89 222.22,16.68 225.52,13.38 225.52,11.28 225.58,11.21 225.58,10.77 v1(225.7,10.65)
  IN3 w0.081: v2(170.26,24.27) 170.41,24.41 170.65,24.41 170.88,24.64 170.88,24.96 171.19,25.27 172.23,25.27 177.31,20.19 199.26,20.19 200.88,21.82 200.88,23.4 203.22,25.75 203.53,25.75 205.43,23.85 209.11,23.85 210.85,22.11 211.95,22.11 212.87,23.03 213.39,23.03 213.54,23.18 218.08,23.18 218.17,23.26 218.73,23.26 218.87,23.12 218.87,22.16 219.34,21.69 220.19,21.69 220.5,22.01 220.5,22.35 v2(220.68,22.53)
USB3_PTX_DRX_P2: length 76.1
  IN1 w0.081: v2(220.15,22.53) 220.32,22.36 220.32,21.79 220.8,21.31 221.52,21.31 222.02,20.81 222.02,16.6 225.32,13.3 225.32,11.2 225.39,11.13 225.39,10.9 v1(225.14,10.65) ; v1(169.59,26.16) 169.59,25.85 169.84,25.61 169.84,24.98 170.01,24.8 v2(170.26,24.8)
  IN3 w0.081: v2(170.26,24.8) 170.45,24.61 170.57,24.61 170.68,24.72 170.68,25.04 171.11,25.47 172.31,25.47 177.39,20.39 199.18,20.39 200.68,21.9 200.68,23.49 203.14,25.94 203.61,25.94 205.51,24.05 209.19,24.05 210.93,22.31 211.87,22.31 212.78,23.23 213.3,23.23 213.46,23.38 218,23.38 218.09,23.46 218.81,23.46 219.07,23.2 219.07,22.24 219.42,21.89 220.11,21.89 220.31,22.09 220.31,22.37 v2(220.15,22.53)
USB20_N1: length 84.5
  TOP w0.091: JDEBUG1.4 226.66,6.32 v1(226.6,6.26)
  IN1 w0.081: v1(226.6,6.26) 226.16,6.26 225.89,6.52 225.89,7.21 223.69,9.41 223.69,13.03 220.75,15.97 220.75,18.62 220.2,19.17 220.2,19.7 220.07,19.83 220.07,20.54 v2(220,20.61) ; v1(171.33,27.74) v2(171.59,28)
  IN3 w0.081: 171.8,27.77 171.79,27.65 171.79,27.57 172.21,27.14 172.53,27.14 173.38,26.3 173.38,26.1 174.22,25.26 174.22,24.26 177.6,20.88 198.98,20.88 200.2,22.1 200.2,23.69 203.1,26.59 209.3,26.59 210.02,25.88 210.02,25.11 211.41,23.72 213.08,23.72 213.25,23.88 217.42,23.88 218.02,24.47 220.97,24.47 221.54,23.91 221.54,22.35 220.16,20.98 220.16,20.78 v2(220,20.61) 220,20.6 219.98,20.59 219.98,20.32 v4(219.93,20.27) ; 171.8,27.77 171.79,27.77 171.8,27.77 ; 171.8,27.77 171.8,27.77 v2(171.59,28)
  BOTTOM w0.091: v3(219.46,20.74) v4(219.93,20.27)
USB20_N5: length 129.5
  TOP w0.091: ML18.4 63.53,16.99 63.83,16.69 63.96,16.69 64.07,16.8 64.07,17.1 v1(63.91,17.25)
  IN1 w0.081: v1(63.91,17.25) 64,17.16 64,16.86 64.27,16.6 66.31,16.6 67.14,17.44 67.79,17.44 68.59,16.64 68.59,15.38 71.17,12.79 72.93,12.79 74.52,11.21 77.21,11.21 78.64,9.78 79.41,9.78 80.22,10.59 83.59,10.59 83.85,10.85 85.77,10.85 86.2,11.28 91.35,11.28 92.49,10.14 92.61,10.14 92.61,10.13 115.46,10.13 116.87,11.54 121.41,11.54 126.52,16.66 129.2,16.66 v2(129.37,16.49)
  IN1 w0.089: v1(170.72,26.16) 170.72,26.13 v2(170.4,25.82)
  IN3 w0.081: v2(129.37,16.49) 129.51,16.63 129.71,16.63 129.9,16.82 129.9,17.59 130.7,18.39 136.38,18.39 140.38,22.38 140.38,22.65 140.38,22.73 140.38,23.43 142.08,25.14 142.08,26.77 143.67,28.36 146.08,28.36 146.4,28.68 153.34,28.68 153.88,28.13 153.88,26.88 158.17,22.59 166.1,22.59 169.7,26.19 170.53,26.19 170.62,26.11 170.62,25.9 170.54,25.82 v2(170.4,25.82)
USB20_N5_R: length 4.8
  TOP w0.091: JFP1.6 58.48,17.35 58.62,17.2 v7(59.14,17.2) 59.39,17.2 60.01,16.58 60.36,16.58 60.61,16.83 60.77,16.83 D14.1 61.33,16.84 61.53,16.84 61.67,16.99 ML18.3
USB20_N8: length 221
  TOP w0.091: UM1.9 17.53,55.49 17.58,55.45 17.9,55.45 v1(17.94,55.49)
  IN1 w0.081: v2(21.58,23.89) 21.62,23.84 21.62,22.99 21.9,22.72 21.9,21.65 22.31,21.24 22.31,16.19 24.75,13.75 30.96,13.75 32.87,15.65 35.49,15.65 36.51,14.64 40.21,14.64 40.96,15.39 44.41,15.39 45.22,16.2 45.22,16.8 45.43,17.01 46.05,17.01 46.24,16.82 48.69,16.82 49.68,17.8 51.12,17.8 51.51,17.41 57.04,17.41 58.08,18.44 59.28,18.44 59.93,17.79 61.68,17.79 63.99,15.49 67.55,15.49 71.09,11.95 72.95,11.95 74.3,10.6 76.94,10.6 78.37,9.16 79.76,9.16 80.59,9.99 83.9,9.99 84.17,10.26 86.02,10.26 86.45,10.69 91.04,10.69 92.19,9.55 102.55,9.55 102.85,9.24 109.65,9.24 109.96,9.55 115.78,9.55 117.17,10.94 121.68,10.94 126.45,15.71 v2(127.37,15.71) ; v1(17.94,55.49) 18.29,55.49 v2(18.36,55.56)
  IN1 w0.089: v2(171.67,26.52) 171.37,26.82 v1(171.33,26.82)
  IN3 w0.081: v2(127.37,15.71) 127.54,15.88 127.78,15.88 128.11,16.2 128.11,16.68 130.45,19.02 136.19,19.02 139.79,22.62 139.79,23.67 141.5,25.38 141.5,27.2 142.21,27.91 142.21,29.56 142.91,30.26 153.99,30.26 154.28,29.98 154.28,29.88 154.28,28.56 154.47,28.37 154.47,27.5 158.69,23.28 165.96,23.28 169.46,26.78 170.91,26.78 171,26.69 171.5,26.69 v2(171.67,26.52) ; v2(21.58,23.89) 21.58,24.75 19.11,27.21 19.11,49.84 16.79,52.17 16.79,54.79 17.46,55.45 18.25,55.45 v2(18.36,55.56)
USB20_N9: length 157
  TOP w0.091: UM2.9 272.49,59.24 272.59,59.34 272.59,59.52 272.84,59.76 v7(273.34,59.76) 274,59.76 274.33,59.43 275.11,59.43 275.21,59.54 v1(275.24,59.54)
  IN1 w0.081: v1(275.24,59.54) 275.34,59.43 275.45,59.43 v2(275.62,59.6) ; v2(224.71,20.17) 224.82,20.06 224.82,17.72 229.15,13.39 232.06,13.39 232.5,12.95 239,12.95 239.45,12.5 244.58,12.5 247.09,15 248.18,15 249.03,15.85 254.04,15.85 254.31,15.59 257.83,15.59 259.37,17.13 261.07,17.13 261.98,18.04 261.98,19.3 262.48,19.8 262.48,20.8 263.3,21.62 263.3,22.68 264.13,23.5 267.39,23.5 271.86,27.97 271.86,33.79 271.64,34 271.64,34.93 272.46,35.74 272.46,36.69 273.22,37.46 273.22,37.91 273.4,38.08 v2(274.01,38.08)
  IN1 w0.089: v1(170.72,24.85) 170.84,24.74 v2(171.36,24.74)
  IN3 w0.081: v2(275.62,59.6) 275.52,59.5 274.8,59.5 273.15,57.85 273.15,56.32 272.7,55.87 272.7,44.45 273.74,43.41 273.74,41.51 273.22,40.99 273.22,38.28 273.42,38.08 v2(274.01,38.08) ; v2(224.71,20.17) 224.71,19.96 224.45,19.71 177.11,19.71 172.23,24.58 171.51,24.58 v2(171.36,24.74)
USB20_N10: length 58.3
  TOP w0.091: RW4.1 196.07,67.09 v1(196.11,67.09) ; v1(171.83,29.01) 171.83,28.81 UC1.DP10
  IN1 w0.081: v1(171.83,29.01) 171.83,30.52 172.32,31.01 172.88,31.01 173.71,31.84 178.64,31.84 178.77,31.71 183.76,31.71 184.46,32.41 184.84,32.41 185.31,32.89 185.31,39.1 187.89,41.68 187.89,44.94 188.38,45.44 190.24,45.44 191.51,46.7 191.51,47.19 193.23,48.92 193.23,50.72 194.63,52.12 194.63,53.31 194.33,53.62 194.33,54.15 195.92,55.74 196.16,55.74 197.3,56.88 197.3,58.8 196.72,59.38 196.72,60.62 196.84,60.75 196.84,65.65 196.98,65.79 196.98,66.61 196.5,67.09 v1(196.11,67.09)
USB20_N10_R: length 5.9
  TOP w0.091: RW4.2 194.9,67.09 v1(194.86,67.09)
  IN1 w0.081: v1(194.86,67.09) 194.79,67.16 194.61,67.16 194.53,67.07 194.53,66.87 194.45,66.79 191.75,66.79 191.21,67.33 191.21,68.09 191.29,68.17 191.44,68.17 191.51,68.1 191.58,68.1 191.66,68.02 191.66,67.9 v1(191.62,67.87)
USB20_P1: length 84.5
  TOP w0.091: v1(226.6,6.64) 226.72,6.52 228.45,6.52 228.75,6.82 JDEBUG1.3
  IN1 w0.081: v2(220.53,20.61) 220.27,20.35 220.27,19.91 220.4,19.78 220.4,19.25 220.95,18.71 220.95,16.05 223.89,13.11 223.89,9.49 226.09,7.29 226.09,6.6 226.24,6.46 226.42,6.46 v1(226.6,6.64) ; v2(172.22,27.97) v1(171.98,27.74)
  IN3 w0.081: v2(172.22,27.97) 171.99,27.76 171.99,27.65 172.3,27.34 172.62,27.34 173.58,26.38 173.58,26.19 174.42,25.35 174.42,24.34 177.68,21.08 198.89,21.08 200,22.18 200,23.77 203.02,26.79 209.38,26.79 210.22,25.96 210.22,25.19 211.49,23.92 213,23.92 213.16,24.08 217.34,24.08 217.93,24.67 221.05,24.67 221.73,23.99 221.73,22.27 220.36,20.89 220.36,20.78 v2(220.53,20.61) 220.31,20.39 v4(220.31,20.28)
  BOTTOM w0.091: v3(220.75,20.76) 220.31,20.32 v4(220.31,20.28)
USB20_P5: length 129.6
  TOP w0.091: ML18.1 64.04,16.49 64.27,16.71 64.27,17.23 v1(64.29,17.25)
  IN1 w0.081: v1(64.29,17.25) 64.2,17.16 64.2,16.95 64.35,16.8 66.23,16.8 67.06,17.63 67.87,17.63 68.79,16.72 68.79,15.46 71.25,12.99 73.02,12.99 74.6,11.41 77.29,11.41 78.72,9.98 79.33,9.98 80.14,10.79 83.51,10.79 83.76,11.05 85.69,11.05 86.12,11.48 91.43,11.48 92.57,10.33 92.69,10.33 92.7,10.33 115.37,10.33 116.78,11.74 121.32,11.74 126.44,16.86 129.2,16.86 v2(129.37,17.02)
  IN1 w0.089: v1(170.72,25.51) 170.72,25.56 170.97,25.82 v2(170.99,25.82)
  IN3 w0.081: v2(129.37,17.02) 129.57,16.83 129.62,16.83 129.7,16.91 129.7,17.67 130.62,18.59 136.3,18.59 140.18,22.47 140.18,22.64 140.18,22.69 140.18,23.51 141.88,25.22 141.88,26.85 143.59,28.56 146,28.56 146.32,28.87 153.42,28.87 154.08,28.21 154.08,26.96 158.25,22.79 166.02,22.79 169.62,26.39 170.62,26.39 170.82,26.19 170.82,25.99 v2(170.99,25.82)
USB20_P5_R: length 4.8
  TOP w0.091: JFP1.5 58.5,16.85 58.65,17 59.31,17 59.93,16.38 v7(60.14,16.38) 60.45,16.38 60.69,16.62 60.8,16.62 D13.1 61.33,16.64 61.55,16.64 61.69,16.49 ML18.2
USB20_P8: length 221
  TOP w0.091: v1(17.94,55.11) 17.8,55.25 17.7,55.25 17.55,55.09 UM1.8
  IN1 w0.081: v2(127.37,16.24) 127.04,15.91 126.37,15.91 121.6,11.14 117.09,11.14 115.7,9.75 109.88,9.75 109.57,9.44 102.93,9.44 102.63,9.75 92.27,9.75 91.13,10.89 86.37,10.89 85.94,10.46 84.09,10.46 83.82,10.19 80.5,10.19 79.67,9.36 78.46,9.36 77.02,10.8 74.38,10.8 73.03,12.15 71.17,12.15 67.63,15.69 64.07,15.69 61.77,17.99 60.01,17.99 59.36,18.64 58,18.64 56.96,17.6 51.59,17.6 51.2,18 49.59,18 48.61,17.01 46.32,17.01 46.13,17.2 45.35,17.2 45.02,16.88 45.02,16.28 44.33,15.59 40.88,15.59 40.12,14.83 36.59,14.83 35.57,15.85 32.79,15.85 30.88,13.95 24.83,13.95 22.51,16.27 22.51,21.33 22.1,21.74 22.1,22.8 21.82,23.08 21.82,23.6 v2(22.11,23.89) ; v2(18.36,55.03) 18.36,55.1 18.22,55.25 18.08,55.25 v1(17.94,55.11)
  IN1 w0.089: v2(171.67,27.09) 171.94,26.82 v1(171.98,26.82)
  IN3 w0.081: v2(171.67,27.09) 171.48,26.89 171.08,26.89 170.99,26.98 169.38,26.98 165.87,23.48 158.77,23.48 154.67,27.59 154.67,28.45 154.47,28.64 154.47,30.06 154.08,30.46 142.83,30.46 142.01,29.65 142.01,28 141.3,27.28 141.3,25.46 139.59,23.76 139.59,22.71 136.11,19.22 130.37,19.22 127.91,16.76 127.91,16.28 127.7,16.08 127.54,16.08 v2(127.37,16.24) ; v2(18.36,55.03) 18.13,55.26 17.54,55.26 16.99,54.7 16.99,52.25 19.31,49.93 19.31,27.29 21.77,24.83 21.77,24.22 v2(22.11,23.89)
USB20_P9: length 157
  TOP w0.091: UM2.8 272.89,59.24 272.79,59.34 272.79,59.43 272.92,59.56 273.92,59.56 274.25,59.23 275.1,59.23 275.17,59.16 v1(275.24,59.16)
  IN1 w0.081: v1(275.24,59.16) 275.32,59.24 275.44,59.24 v2(275.62,59.06) ; v2(225.24,20.17) 225.02,19.94 225.02,17.8 229.23,13.59 232.15,13.59 232.59,13.15 239.09,13.15 239.54,12.7 244.5,12.7 247,15.2 248.1,15.2 248.95,16.05 254.12,16.05 254.39,15.78 257.74,15.78 259.29,17.33 260.98,17.33 261.78,18.12 261.78,19.38 262.28,19.89 262.28,20.88 263.1,21.7 263.1,22.76 264.04,23.7 267.31,23.7 271.66,28.05 271.66,33.71 271.45,33.92 271.45,35.01 272.26,35.83 272.26,36.78 273.03,37.54 273.03,37.99 273.32,38.28 273.67,38.28 v2(274.01,38.62)
  IN1 w0.089: v2(171.36,24.2) 171.36,24.28 171.1,24.53 170.81,24.53 170.72,24.44 v1(170.72,24.2)
  IN3 w0.081: v2(275.62,59.06) 275.38,59.3 274.88,59.3 273.34,57.77 273.34,56.23 272.9,55.79 272.9,44.53 273.94,43.49 273.94,41.43 273.42,40.9 273.42,38.36 273.5,38.28 273.67,38.28 v2(274.01,38.62) ; v2(225.24,20.17) 224.96,19.88 224.91,19.88 224.53,19.51 177.02,19.51 172.15,24.39 171.54,24.39 v2(171.36,24.2)
USB20_P10: length 58.3
  TOP w0.091: RW5.1 196.07,66.59 v1(196.11,66.59) ; v1(171.42,29) 171.5,28.92 171.5,28.82 UC1.DN10
  IN1 w0.081: v1(196.11,66.59) 196.11,66.71 196.29,66.89 196.42,66.89 196.78,66.53 196.78,65.87 196.64,65.73 196.64,60.83 196.52,60.71 196.52,59.3 197.1,58.72 197.1,56.96 196.08,55.94 195.84,55.94 194.13,54.23 194.13,53.54 194.44,53.23 194.44,52.2 193.03,50.8 193.03,49 191.31,47.28 191.31,46.79 190.16,45.64 188.3,45.64 187.69,45.03 187.69,41.76 185.11,39.18 185.11,32.97 184.75,32.61 184.37,32.61 183.67,31.91 178.85,31.91 178.72,32.04 173.62,32.04 172.79,31.21 172.24,31.21 171.63,30.6 171.63,29.21 v1(171.42,29)
USB20_P10_R: length 6
  TOP w0.091: v1(194.86,66.59) 194.9,66.59 RW5.2
  IN1 w0.081: v1(194.86,66.59) 191.67,66.59 191.02,67.24 191.02,68.17 191.21,68.37 v1(191.62,68.37)
USB_OC0#: length 4.7
  IN1 w0.064: v1(174.76,30.67) 174.76,30.47 v2(175,30.24) ; v2(177.98,28.71) v1(177.98,28.17)
  IN2 w0.051: v2(175,30.24) 175.53,30.24 177.06,28.71 v2(177.98,28.71)
USB_OC1#: length 1.3
  IN1 w0.081: v2(162.53,43.92) 162.42,43.81 v1(162.42,43.61)
  IN3 w0.064: v4(162.53,43.57) v2(162.53,43.92)
  BOTTOM w0.081: RH742.1 v4(162.53,43.57)
USB_OC2#: length 0.7
  IN1 w0.081: v1(163.33,43.61) 163.33,43.84 v2(163.42,43.93)
  IN3 w0.064: v4(163.42,43.57) v2(163.42,43.93)
USB_OC3#: length 2.8
  IN1 w0.064: 163.48,45.69 v2(163.73,45.94)
  IN1 w0.081: v1(163.33,44.91) 163.33,45.54 163.48,45.69
  IN3 w0.064: v2(163.73,45.94) v4(163.42,45.63)
  BOTTOM w0.081: v4(163.42,45.63) 162.91,45.63 v3(162.47,45.19)
VCI_IN3#: length 6.8
  TOP w0.081: UE1.E4 209.76,62.76 210.15,63.16 210.52,63.16 210.76,63.4 210.76,66.06 210.97,66.27 211.11,66.27 211.3,66.46 211.3,66.91 210.66,67.54 RE244.1
VFB: length 3.9
  TOP w0.203: PC1103.1 PR1117.1 98.81,43.7 PU1100.5
  TOP w0.254: PR1120.2 98.85,42.67 PC1103.1
VRACPU_VTEMP: length 37
  TOP w0.203: v1(93.05,47.15) PR1101.1 93.2,47.65 93.28,47.57 94.58,47.57 94.81,47.34 PC1100.1 94.89,46.96 PU1100.26 ; PR1205.1 v5(101.7,23.93)
  IN1 w0.254: v2(93.44,46.25) 93.44,46.76 v1(93.05,47.15) ; v1(101.15,34.39) 101.15,33.62 101.32,33.45 v2(101.32,33.06) 101.3,33.04 100.44,33.04 99.85,33.63 98.39,33.63 97.99,34.03 97.99,35.3 97.73,35.56 96.79,35.56 v2(96.34,36.02)
  IN3 w0.254: v2(101.32,33.06) 101.32,32.74 101.16,32.59 101.16,30.66 100.4,29.89 100.4,28.9 101.44,27.86 101.44,25.56 102.2,24.8 102.2,24.36 101.77,23.93 v5(101.7,23.93) ; v2(93.44,46.25) 93.75,46.25 94.03,45.97 94.03,39.04 96.34,36.73 v2(96.34,36.02)
  BOTTOM w0.081: v5(101.7,23.93) v6(101.07,23.93)
VRALERT#: length 18.7
  TOP w0.089: UC1.CN38 v1(162.08,43.22)
  IN1 w0.064: v1(162.08,43.22) 162.21,43.09 162.85,43.09 163.04,43.28 165.33,43.28 165.91,42.7 166.65,42.7 167.34,42 170.66,42 171.24,42.58 175.98,42.58 176.17,42.77 v1(178.75,42.77)
VRALERT#_R: length 134.2
  TOP w0.081: v1(84.27,14.98) 84.27,14.68 85.19,13.77 85.19,12.74 84.98,12.53 PR217.1 ; D21.1 186.15,45.92 v3(184.97,44.74) 184.8,44.74 183.91,43.84 183.54,43.84 182.47,42.77 181.99,42.77 RC744.1 181.39,42.94 v1(180.66,42.94) 180.5,42.77 RC688.2
  IN1 w0.064: v1(180.66,42.94) 180.86,42.75 183.88,42.75 184.37,42.26 184.37,41.6 184.17,41.41 184.17,40.6 182.59,39.03 v2(182.4,39.03) ; v1(84.27,14.98) 84.99,15.7 89.14,15.7 89.44,15.4 92.93,15.4 94.08,14.26 104.24,14.26 105.87,15.9 110.65,15.9 111.25,16.5 113.92,16.5 114.37,16.05 119.42,16.05 121.25,17.88 v2(121.76,17.88)
  IN3 w0.064: v2(182.4,39.03) 182.19,39.03 181.24,38.07 180.99,38.07 180.83,37.91 179.48,37.91 179.15,38.24 178.68,38.24 178.28,37.83 178.28,35.66 177.9,35.28 177.01,35.28 176.5,34.77 175.91,34.77 175.72,34.58 174.09,34.58 173.03,33.52 172.07,33.52 172,33.44 171.42,33.44 171.3,33.56 170.85,33.56 170.73,33.44 169.77,33.44 166.45,30.13 159.54,30.13 158.73,30.94 142.26,30.94 141.19,29.87 141.19,29.01 140.71,28.53 140.71,26.66 134.12,20.07 130.01,20.07 127.63,17.69 125.57,17.69 125.46,17.58 123.05,17.58 122.74,17.88 v2(121.76,17.88)
VSET_5105: length 7
  TOP w0.081: RE199.1 CE79.1 218.14,65.06 217.04,65.06 216.72,64.74 213.88,64.74 UE1.C9
WAKE#: length 8.7
  TOP w0.089: UC1.DL45 170.58,45.87 v1(171.06,45.39)
  IN1 w0.064: v1(177.86,46.57) 177.35,46.57 v2(177.2,46.72)
  IN1 w0.089: v2(171.42,45.69) 171.37,45.69 v1(171.06,45.39)
  IN2 w0.051: v2(171.42,45.69) 171.42,46.02 171.73,46.33 172.24,46.33 172.66,45.91 175.31,45.91 176.12,46.72 v2(177.2,46.72)
WLAN_PWR_EN: length 9.2
  TOP w0.081: R533.2 v1(173.6,61.71) ; U34.5 175.38,66.72 175.87,66.22 v5(175.87,66.2)
  IN1 w0.064: v5(175.87,66.2) 175.87,66.09 175.45,65.67 174.32,65.67 173.5,64.85 173.5,61.81 v1(173.6,61.71)
  BOTTOM w0.081: v5(175.87,66.2) 175.94,66.27 v3(176.37,66.27) 176.45,66.19 176.45,65.75 176.5,65.7 R534.2
WLAN_PWR_EN_EC: length 9.1
  TOP w0.081: RE321.2 RE322.2 175.39,62.16 175.74,61.82 D23.1 175.35,59.22 174.53,59.22 174.09,59.66 R533.1 R6137.2 173.3,60.64 172.94,61 172.94,61.82 173.13,62.01 v3(173.13,62.08)
WLAN_PWR_EN_PCH: length 2.4
  BOTTOM w0.081: v3(175.61,64.83) R534.1 R532.2 177.13,64.55 176.88,64.3 Q350.1
WLAN_WIGIG60GHZ_DIS#: length 47.6
  TOP w0.081: RE208.2 218.69,55.98 v1(218.44,56.23) 218.42,56.23 UE1.L13 ; DZ4.1 v1(198.12,60.04) 198.12,61.18 v3(198.65,61.71)
  IN1 w0.064: v1(218.44,56.23) 218.59,56.08 218.59,54.86 v2(218.44,54.71) ; v2(195.47,50.67) 196.23,51.43 196.23,52.32 198.01,54.1 198.01,55.41 198.61,56.01 198.61,59.56 v1(198.12,60.04)
  IN2 w0.051: v2(195.47,50.67) 196,51.2 197,51.2 197.54,50.66 199.5,50.66 200.25,51.41 204.59,51.41 204.82,51.18 207.38,51.18 208.35,52.15 209.77,52.15 210.19,52.56 212.71,52.56 213.2,53.06 213.2,53.43 213.46,53.7 215.11,53.7 215.61,53.2 215.61,52.17 216.07,51.72 217.36,51.72 218.03,52.39 218.03,54.3 v2(218.44,54.71)
WLAN_WIGIG60GHZ_DIS#_R: length 22.1
  TOP w0.081: UWL1.28 180.81,57.87 v1(180.99,57.68)
  IN1 w0.064: v1(195.21,60.04) 195.03,60.04 194.85,59.87 194.85,59.55 195.26,59.14 195.26,58.92 195.23,58.89 195.23,58.88 194.13,57.77 v2(194.13,56.82) ; v1(180.99,57.68) 180.99,57.05 180.69,56.74 180.69,55.32 v2(180.4,55.03)
  IN2 w0.051: v2(180.4,55.03) 180.83,55.46 192.16,55.46 193.52,56.82 v2(194.13,56.82)
WOV_DMIC_CLK0: length 21.7
  IN1 w0.064: v2(168.37,41.38) 168.46,41.46 v1(168.73,41.46)
  IN3 w0.064: v4(174.4,54.38) 174.28,54.25 174.28,53.81 173.76,53.29 173.76,52.19 172.89,51.32 169.04,51.32 167.49,49.77 167.39,49.77 167.16,49.54 167.16,48.99 165.81,47.64 165.81,47.3 165.64,47.14 165.64,42.77 165.83,42.58 166.34,42.58 167.16,41.76 167.43,41.76 168.16,41.03 168.25,41.03 168.32,41.08 v2(168.37,41.38)
WOV_DMIC_DATA0: length 22.3
  IN1 w0.089: v1(168.73,40.55) v2(168.73,40.88)
  IN3 w0.064: v4(173.83,54.38) 174.02,54.38 174.09,54.32 174.09,53.89 173.57,53.37 173.57,52.27 172.81,51.51 168.96,51.51 167.41,49.96 167.31,49.96 166.97,49.62 166.97,49.07 165.62,47.72 165.62,47.38 165.43,47.2 165.43,42.66 165.74,42.35 166.25,42.35 167.05,41.55 167.35,41.55 168.07,40.83 168.32,40.83 168.37,40.88 168.44,40.92 v2(168.73,40.88)
XTAL_38P4M_IN: length 2.7
  TOP w0.081: RH14.2 178.1,30.57 RH17.2 178.99,30.57 179.16,30.73 CH11.2 179.48,30.75 179.84,31.1 YH1.3
XTAL_38P4M_IN_CPU: length 5.2
  IN1 w0.064: v1(177.49,30.59) 177.33,30.75 176.86,30.75 176.78,30.67 176.78,30.56 176.84,30.5 177.14,30.5 177.22,30.42 177.22,30.32 177.14,30.24 176.92,30.24 176.84,30.17 176.84,29.72 175.17,28.05 v1(174.76,28.05)
XTAL_38P4M_OUT: length 4
  TOP w0.081: RH15.2 178.29,29.96 178.32,29.98 RH17.1 179.1,29.98 179.16,30.05 CH10.2 179.71,30.05 180.06,30.39 180.95,30.39 YH1.1
XTAL_38P4M_OUT_CPU: length 5.5
  TOP w0.089: UC1.DU8 173.53,28.05 v1(173.77,28.29)
  IN1 w0.064: v1(177.49,29.96) 177.49,29.74 175.36,27.61 174.45,27.61 v1(173.77,28.29)
N04830: length 7.7
  TOP w0.081: v3(87.22,23.85) 87,23.63 v1(87,22.91)
  TOP w0.178: PU200.3 82.96,19.72 83.54,20.29 v1(83.54,20.42)
  TOP w0.254: v1(87,22.91) PC235.1
  IN1 w0.254: v1(83.54,20.42) 86.02,22.91 v1(87,22.91)
N20151644: length 8.2
  IN1 w0.254: v1(74.39,22.96) 74.39,22.94 73.78,22.33 73.78,18.89 76.47,16.2 v1(76.55,16.2)
N20151664: length 9.3
  IN1 w0.254: v1(76.52,16.91) 76.5,16.89 74.29,19.1 74.29,22.12 74.9,22.73 74.9,24.23 v1(74.39,24.74)
N27076067: length 2.2
  TOP w0.081: v3(88.51,17.96) 88.44,17.89 PC243.1
  TOP w0.254: PR231.2 PC243.1
N30248348: length 6.6
  TOP w0.254: PR211.2 92.04,22.07 91.86,21.89 89.62,21.89 89.43,22.08 89.05,22.08 89,22.02 86.76,22.02 86.73,22.06 PR221.1
N30252391: length 1.2
  TOP w0.508: PC230.2 PR210.2
N30253802: length 2.4
  TOP w0.081: PR234.1 PR233.1 PR230.2 PC244.1
N30256954: length 3.3
  TOP w0.203: PU200.24 83.76,15.31 83.85,15.4 84.45,15.4 v3(85.48,14.37) 85.75,14.11 PR220.2
N30277718: length 3.6
  TOP w0.508: PR208.1 79.79,10.15 PD202.1 78.14,9.09 PD201.1
N35975325: length 5.7
  TOP w0.081: v3(88.35,15.39) 88.35,15.26 86.9,13.82 PR224.2
  TOP w0.203: PU200.25 84.81,15.87 84.94,15.73 84.94,15.45 86.2,14.2 86.44,14.2 PR224.2
N39629096: length 2.2
  BOTTOM w0.081: v3(204.6,54.19) R530.2 204.6,56.12 LED1.2
N39629103: length 3.4
  BOTTOM w0.081: R531.2 201.9,56.01 v3(201.9,56.87) 201.9,57 202.41,57.5 LED2.2
N41228936: length 2.8
  TOP w0.203: PR226.1 85.88,15.28 85.38,15.78 85.38,16.29 85,16.67 PU200.27
N49696201: length 2.3
  TOP w0.254: PR1200.2 PC1206.1 103.16,34.56 PU1200.14
N49776653: length 0.6
  TOP w0.081: RE172.2 212.69,69.03 CE65.1
N51014739: length 1.5
  TOP w0.254: PR901.2 141.69,7.28 142.06,7.65 PU900.7
N52032474: length 1.7
  TOP w0.081: PL501.2 215.17,20.31 v3(216.06,19.41)
N52343314: length 2.3
  TOP w0.081: RD21.2 147.76,54.44 UD2.A5
N52343316: length 2.2
  TOP w0.081: UD2.A8 145.63,52.75 RD22.2
N52343354: length 2.1
  TOP w0.081: RD2.2 161.6,53.02 161.61,53.03 UD1.A5
N52343360: length 2.2
  TOP w0.081: UD1.A8 159.25,54.67 159.25,52.79 159.16,52.7 RD1.2
N52360782: length 2.1
  TOP w0.081: RD4.2 128.47,68.81
  TOP w0.102: UD3.A5 128.47,68.37 128.47,68.81
N52360800: length 2.1
  TOP w0.081: 130.88,68.62 RD3.2
  TOP w0.102: UD3.A8 130.88,68.62
N52360829: length 2.1
  IN1 w0.064: v1(115.92,70.42) 115.92,68.58
  IN1 w0.081: 115.92,68.58 115.92,68.46 v1(116.02,68.36)
N52416800: length 4.6
  TOP w0.081: PR227.1 89.82,12.41 89.82,13.18 v3(90.33,13.69)
  TOP w0.254: PQ205.2 88.32,10.41 89.01,11.1 PR223.2 PR227.1
N52576195: length 1.3
  TOP w0.081: UM1.11 16.39,57.45 RM10.1
N52576366: length 1.4
  TOP w0.081: RM9.1 14.32,57.69 14.79,57.22 UM1.15
N52676089: length 1.7
  TOP w0.081: UCR1.28 280.2,30.11 RR10.2
N52692386: length 1
  TOP w0.254: PR1120.1 PC1105.2
N52692507: length 3.9
  TOP w0.081: PR1102.2 94.84,49.63 v3(94.52,49.95)
  TOP w0.203: PR1102.2 PC1101.1 94.84,47.98 95.46,47.36 PU1100.25
N52692519: length 6.8
  TOP w0.081: PR1106.1 94.39,43.1 93.62,43.1 92.97,42.44 v3(92.97,41.81)
  TOP w0.203: PU1100.28 96.01,46.16 95.75,45.91 95.75,45.56 95.5,45.3 94.82,45.3 PC1104.1 PR1104.2 PR1106.1
N52692565: length 5.4
  TOP w0.081: v3(104.72,44.95) 104.72,45.54 PR1134.1
  TOP w0.203: PR1134.1 103.78,46.48 101.37,46.48 100.89,46.96 PU1100.10
N52692863: length 4
  TOP w0.081: v3(102.35,50.7) 102.09,50.45 101.21,50.45 PR1125.1
  TOP w0.203: PU1100.15 99.61,50.27 PR1114.2
  TOP w0.254: PR1125.1 100.88,50.78 PR1114.2
N52692927: length 4.8
  TOP w0.203: PU1100.27 95.78,46.56 95.41,46.19 v1(94.82,46.19)
  TOP w0.254: PR1103.2 93.09,45.24 PR1100.1
  IN1 w0.254: v1(94.82,46.19) 94.32,45.69 93.14,45.69 v1(93.1,45.65)
N52693170: length 4.3
  TOP w0.203: v1(95.68,43.6) 95.68,43.74 96.54,44.6 97.35,44.6 97.61,44.86 PU1100.2
  IN1 w0.254: v1(95.68,43.6) 94.83,42.75 v1(94.83,42.61)
N52693178: length 4.9
  TOP w0.203: PU1100.3 98.01,44.5 97.71,44.19 97.16,44.19 PR1107.2 96.79,43.6 97.12,43.27 97.12,42.14 96.79,41.81 PR1116.2
N52751344: length 2.4
  TOP w0.254: PU500.8 209.63,19.36 PC510.1 208.91,18.64 PR503.2
N52752447: length 4.6
  TOP w0.081: PR510.2 213.28,17.32 212.76,16.8 212.76,15.28 v3(212.44,14.96)
  TOP w0.254: PR510.2 212.92,17.85 PC505.1 213.28,18.55 PR501.1
N52755459: length 3.3
  TOP w0.254: PU900.8 142.46,7.44 142.29,7.26 v1(142.29,7.04)
  IN1 w0.254: v1(142.31,5.5) 141.89,5.92 141.89,6.65 v1(142.29,7.04)
N52755987: length 1.2
  TOP w0.254: PR907.1 142.91,13.24 PU900.14
N52759880: length 4.3
  TOP w0.081: v3(140.43,15.59) 140.43,14.96 140,14.53 PR900.2
  TOP w0.203: PU900.18 141.26,12.46 140.69,13.03 140.41,13.03 PC900.1 PR900.2
N52768180: length 2.3
  TOP w0.203: PU1201.14 103.14,25.25 PC1219.1 PR1202.2
N52827933: length 0.7
  IN1 w0.064: v1(13.05,45.62) 13.13,45.69 v2(13.38,45.69)
  IN3 w0.064: v4(13.01,45.69) v2(13.38,45.69)
N52905539: length 3.5
  TOP w0.254: PU700.17 93.19,60.06 93.03,59.9 PC713.1 ; PR705.1 92.49,59.15 PC713.1 ; PC713.1 92.02,60.37 PR703.2
N52905567: length 4.5
  TOP w0.081: v3(93.12,57.19) 92.58,57.73 PR705.2
  TOP w0.254: PR706.1 92.19,58.14 PR705.2 93.12,58.68 93.12,59.05 93.63,59.56 PU700.18
N52905575: length 1.5
  TOP w0.254: PU700.14 92.77,61.56 PC714.1
N52905683: length 0.9
  BOTTOM w0.081: v5(94.9,65.45) 95.22,65.77 v3(95.22,66.2)
  vias: v5(94.77,57.84) v5(94.77,57.13) v5(94.77,56.5) v5(94.77,55.7) v5(94.9,64.9) v5(94.9,64.32) v5(94.89,63.72)
N52924590:
  vias: v5(86.44,67.51)
N52924674: length 6.4
  TOP w0.254: PU800.8 80.75,66.2 v1(80.6,66.05)
  IN1 w0.254: v1(80.6,71.17) v1(80.6,66.05)
N52928923: length 1.3
  TOP w0.635: PC512.1 210.57,25.25 PR506.2
N52929663: length 1.1
  TOP w0.508: PC811.1 PR804.2
N52929949: length 1.1
  TOP w0.508: PR910.2 PC912.1
N52994210: length 8.8
  TOP w0.254: v1(213.23,28.87) 213.23,29.03 213.82,29.48 PR1409.2
  IN1 w0.254: v1(219.45,26.64) 219.23,26.86 216.6,26.86 216.09,27.38 216.09,28.46 215.68,28.87 v1(213.23,28.87)
N52994226: length 1.3
  TOP w0.254: PU1400.12 214.29,28.92 214.23,28.87 PR1406.1
N52995203: length 3.8
  TOP w0.254: PR604.1 79.28,7.1 PQ600.2 80.7,7.1 81.92,8.31 PR603.2
N53135832: length 1.2
  TOP w0.508: RC589.2 178.65,36.37 179.2,36.93 CC176.1
N53160037: length 1.1
  TOP w0.254: PR712.2 91.73,63.77 92.01,63.77 PC711.2
N53169467: length 3.4
  TOP w0.081: PR602.2 92.16,7.33 v3(92.36,7.53)
  TOP w0.254: PR602.2 91.33,7.31 PC600.1 91.32,6.46 PU600.7
N53193542: length 6
  TOP w0.254: PR222.1 87.04,21.41 87.29,21.66 89.34,21.66 89.57,21.44 91.92,21.44 92.04,21.31 PR211.3
N53198392: length 1.8
  TOP w0.081: v3(80.04,63.47) 80.17,63.35 81.76,63.35
N53198778: length 2.2
  TOP w0.254: PU300.16 83.39,58.43 83.83,58.86 83.83,59.29 84.2,59.66 PR300.2
N53198814: length 3
  IN1 w0.254: v1(85.24,54.51) 84.61,55.13 84.61,55.68 84.36,55.93 v1(83.12,55.93)
N53198852: length 4.4
  TOP w0.254: PR307.1 86.45,55.86 v1(86.53,55.79)
  IN1 w0.254: v1(85.16,53.12) 85.86,53.12 86.43,53.69 86.43,55.69 v1(86.53,55.79)
N53198984: length 1.6
  TOP w0.254: PU300.14 83.92,57.43 84.35,57.86 PR310.1
N53199059: length 1.4
  TOP w0.508: PR311.2 84.34,49.03 PC314.1
N53201443:
  vias: v3(27.27,2.39)
N53201562: length 4
  IN1 w0.254: v1(25.29,2.64) 25.88,3.22 25.88,4.67 24.89,5.66 v1(24.59,5.66)
N53201576: length 1.1
  TOP w0.508: PC400.1 20.3,2.83 PR403.2
N53201602: length 1.3
  TOP w0.254: PU400.11 22.09,4.69 PR401.2
N53201659: length 1.9
  TOP w0.254: PR406.2 22.96,2.56 PR407.1 23.72,2.04 PC405.1
N53201824: length 10.3
  TOP w0.254: v1(24.45,10.29) 24.59,10.15 PU400.3
  IN1 w0.254: v1(24.45,10.29) 22.79,10.29 22.07,9.56 22.07,8.23 22.38,7.91 22.38,4.44 v1(22.96,3.87)
N53201840: length 2.5
  IN1 w0.254: v1(25.31,4.37) 24.4,4.37 23.59,5.18 v1(23.59,5.66)
N53202040:
  vias: v6(264.64,7.78)
N53202160: length 5.8
  TOP w0.081: v3(264.92,9.31) 264.92,8.94 265.68,8.18 266.53,8.18 266.94,8.59 PR412.2
  TOP w0.254: PU401.16 268.6,7.29 268.45,7.44 267.89,7.44 267.61,7.72 267.61,8.2 267.2,8.61 PR412.2
N53202164: length 2
  TOP w0.508: PR415.2 271.66,9.58 272.51,8.74 272.51,8.33 PC416.1
N53202194: length 1.3
  TOP w0.254: PR413.2 270.78,8.07 270.78,7.72 271.1,7.41 PU401.11
N53202247: length 1.9
  TOP w0.254: 270.1,9.92 270.69,10.51 PR418.2 ; 270.1,9.92 PR419.1 ; 270.1,9.92 270.1,10.34 269.95,10.5 PC421.1
N53202418: length 3.9
  TOP w0.254: v1(268.58,2.64) 268.6,2.65 PU401.3
  IN1 w0.254: v1(271.16,2.64) 270.95,2.42 268.8,2.42 v1(268.58,2.64)
N53202436: length 5.3
  TOP w0.081: v3(267.24,10.51) 267.77,9.99 PR423.1
  IN1 w0.254: v1(268.24,10.01) 268.24,7.62 268.95,6.91 v1(269.6,6.91)
N53208559: length 3
  TOP w0.081: PR1400.2 213.62,30.7 v3(213.11,31.22)
  TOP w0.254: PU1400.11 214.74,29.42 214.56,29.61 214.56,29.79 214.02,30.33 PR1400.2
N53208718: length 1.5
  TOP w0.254: PU1400.14 214.61,27.92 214.09,27.41 PR1408.1
N53270797: length 0.9
  TOP w0.254: PR1403.1 212.74,28.17 212.27,27.69 PC1405.2
N53355134: length 1.4
  TOP w0.203: PR1123.1 99.21,50.76 PU1100.16
N53373804: length 3.7
  TOP w0.081: QM1.2 188.07,27.53 187.93,27.68 187.93,28.04 188.07,28.18 QM1.3 189.06,28.18 189.11,28.13 RC616.2 189.45,27.53 v3(189.83,27.15)
N53375471: length 1.9
  TOP w0.081: v3(185.9,39.34) 185.77,39.22 RC627.1 184.77,38.49 UC9.4
N53408431: length 3.2
  TOP w0.081: v3(205.46,16.42) 205.46,15.98 204.49,15.01 C1467.1 204.44,14.61 204.39,14.56 U31.10
N53408470: length 3.4
  TOP w0.081: U31.12 203.59,14.58 203.55,14.61 C217.1 203.55,15.02 203.99,15.47 v3(203.99,16.93)
N53437419: length 20.1
  TOP w0.081: R360.1 138.46,20.82 138.32,20.67 134.58,20.67 132.69,18.78 129.26,18.78 128.69,18.22 125.15,18.22 123.79,16.86 121.44,16.86 v5(121.11,17.2)
  vias: v3(122.52,17.44)
N53659927: length 2.3
  IN1 w0.064: v1(113.51,70.61) 113.51,69.06 113.62,68.95 113.62,68.58
  IN1 w0.081: 113.62,68.58 v1(113.62,68.36)
N54122777: length 0.8
  BOTTOM w0.081: RC623.1 111.75,19.46 UC8.4
N54819198: length 1.8
  TOP w0.152: URT1.A12 9.22,48.31 9.09,48.45 9.09,49.07 9.44,49.43 RT101.2
N54819372: length 2
  TOP w0.076: URT2.A12 277.09,40.59 276.9,40.78 276.63,40.78 276.31,41.1
  TOP w0.081: 276.31,41.1 275.92,41.49 275.92,41.53 275.9,41.55 RT102.2
N55030338: length 0.9
  IN1 w0.064: v1(280.92,37.69) 280.92,37.68 v2(280.53,37.29)
  IN3 w0.064: v4(280.3,37.06) v2(280.53,37.29)
N55957128:
  vias: v3(24.8,22.07)
N55957255: length 2.4
  TOP w0.081: CA47.1 RA27.2 ; CA47.1 21.95,20.01 v3(21.95,19.67) ; CA47.1 RA28.1
N55957257: length 3.3
  TOP w0.081: RA27.1 CA46.1 RA8.2 21.9,23.57 22.36,24.02 v3(22.67,24.02)
N55962826: length 2.1
  TOP w0.203: UA1.32 29.34,20.19 28.86,20.67 CA15.1
N55978423: length 3.1
  TOP w0.203: UA1.38 26.5,18.03 26.13,18.4 26.13,19.91 26.26,20.04 CA17.2
N55978441: length 4.9
  TOP w0.081: RA10.2 24.65,18.86 24.35,19.15 23.59,19.15 v3(23.05,18.61)
  TOP w0.203: UA1.39 26.44,17.63
  TOP w0.254: RA10.2 24.82,18.86 24.85,18.88 CA20.2 25.56,18.51 26.44,17.63
N56357496: length 1.9
  TOP w0.081: RA63.2 28.48,12.04 27.74,12.78 UA1.1
N56357525: length 2.2
  TOP w0.203: RA64.1 28.1,20.93 28.94,20.09 UA1.33
N56877756: length 1.5
  TOP w0.081: UM2.11 270.35,57.92 RM12.1
N56877758: length 1.6
  TOP w0.081: RM11.1 270.61,56.32 UM2.15
N56965750: length 1.6
  TOP w0.081: RPD149.2 283.74,18.26 283.63,18.16 UPD2.45
N56965760: length 1.6
  TOP w0.081: UPD2.46 283.23,18.13 283.1,18.26 RPD150.2
N56965771: length 1.7
  TOP w0.081: RPD151.2 282.47,18.58 282.83,18.22 UPD2.47
N56966161: length 1.6
  TOP w0.081: RPD152.2 12,24.77 12.46,24.77 UPD1.45
N56966164: length 4.7
  TOP w0.081: v3(9.94,27.28) 10.7,26.52 RPD153.2 10.7,25.56 11.73,24.53 11.74,24.53 11.78,24.49 12.17,24.49 UPD1.46
N56966167: length 1.6
  TOP w0.081: RPD154.2 11.41,24.35 11.66,24.35 11.82,24.19 11.9,24.19 UPD1.47

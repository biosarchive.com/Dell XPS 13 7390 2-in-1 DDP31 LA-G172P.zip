# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D2_5: length 31.1
  IN1 w0.099: v1(141.78,46.63) 141.47,46.94 141.47,48.91 141.36,49.03 141.36,52.13 138.5,54.99 138.5,55.56 138.28,55.77 138.28,59.71 138.1,59.9 138.1,63.34 138.15,63.39 138.15,67.46 139.13,68.45 143.54,68.45 143.71,68.62 144.43,68.62 145.12,67.93 145.12,67.35 v1(144.83,67.06)
DDR_B_D2_6: length 28.1
  IN1 w0.099: v1(144.83,67.71) 144.5,68.03 143.46,68.03 143.29,68.2 139.9,68.2 138.4,66.7 138.4,63.29 138.35,63.24 138.35,60.01 138.54,59.82 138.54,55.88 138.75,55.66 138.75,55.09 141.61,52.24 141.61,49.09 141.7,49 141.7,47.36 v1(141.78,47.29)
DDR_B_D2_7: length 25.4
  TOP w0.089: v1(141.97,48.37) 141.78,48.18 UC1.AM49
  IN1 w0.099: v1(141.97,48.37) 141.92,48.42 141.92,49.05 141.92,49.05 141.92,49.1 141.86,49.16 141.86,52.34 139,55.2 139,55.76 138.79,55.98 138.79,59.92 138.6,60.11 138.6,63.13 138.65,63.18 138.65,66.59 139.99,67.94 142.99,67.94 v1(143.23,67.71)
DDR_B_D3_0: length 41.8
  IN1 w0.099: v2(148.49,66.76) 148.51,66.76 148.52,66.75 148.66,66.75 148.83,66.91 v1(148.83,67.06) ; v1(143.87,44.26) v2(143.42,44.45)
  IN3 w0.099: v2(148.49,66.76) 148.49,66.92 148.72,67.15 148.83,67.15 148.93,67.05 148.93,66.5 148.83,66.41 148.21,66.41 148,66.19 148,66 148.18,65.82 148.18,65.7 147.94,65.46 147.78,65.46 147.48,65.77 146.39,65.77 146.08,66.08 145.7,66.08 145.51,65.89 145.35,65.89 145.24,66 145.24,66.3 145.12,66.41 144.96,66.41 144.84,66.3 144.84,66 144.73,65.89 144.5,65.89 143.84,65.24 142.25,65.24 142.13,65.12 142.13,64.56 142.04,64.46 141.84,64.46 141.74,64.56 141.74,65.12 141.62,65.24 141.18,65.24 141.08,65.14 141.08,64.94 141.2,64.81 141.2,64.61 141.56,64.26 141.56,60.4 141.66,60.3 141.94,60.3 142.04,60.19 142.04,60.05 141.95,59.95 141.1,59.95 141,59.86 141,59.72 141.1,59.62 141.92,59.62 142.02,59.52 142.02,59.38 141.77,59.14 141.61,59.14 141.47,59.27 141.31,59.27 141.19,59.16 141.19,58.99 141.33,58.86 141.33,58.69 141.08,58.44 141.08,56.54 141.54,56.08 141.54,55.73 141.38,55.58 141.38,55.36 141.54,55.2 141.54,54.95 141.38,54.79 141.38,54.49 141.74,54.14 141.74,53.99 141.53,53.78 141.53,53.61 141.64,53.5 141.81,53.5 142.02,53.71 142.18,53.71 142.3,53.59 142.3,53.43 142.09,53.22 142.09,53.05 142.2,52.94 142.37,52.94 142.58,53.15 142.74,53.15 142.86,53.03 142.86,52.87 142.65,52.66 142.65,52.49 142.76,52.38 142.93,52.38 143.14,52.59 143.3,52.59 143.42,52.48 143.42,46.57 143.75,46.24 143.75,45.13 143.53,44.92 143.53,44.57 v2(143.42,44.45)
DDR_B_D3_1: length 41.1
  IN1 w0.081: v2(148.44,65.47) 148.72,65.76 v1(148.83,65.76)
  IN1 w0.099: v1(143.87,42.96) v2(143.42,42.59)
  IN3 w0.099: v2(143.42,42.59) 143.42,42.72 143.29,42.84 142.93,42.84 142.83,42.74 142.83,42.28 142.93,42.18 143.66,42.18 143.76,42.28 143.76,44.79 144,45.03 144,46.32 143.67,46.65 143.67,52.58 141.79,54.45 141.79,56.18 141.33,56.64 141.33,58.19 141.49,58.35 141.49,58.5 142.34,59.34 142.34,60.5 142.27,60.57 142.03,60.57 142.03,60.56 141.89,60.56 141.81,60.65 141.81,61.81 141.91,61.91 142.21,61.91 142.31,62.01 142.31,62.2 142.21,62.3 141.91,62.3 141.81,62.4 141.81,62.6 141.91,62.7 142.21,62.7 142.31,62.8 142.31,63 142.21,63.1 141.91,63.1 141.81,63.19 141.81,64.12 141.88,64.19 142.2,64.19 142.34,64.05 142.97,64.05 143.07,64.15 143.07,64.35 142.97,64.45 142.55,64.45 142.45,64.55 142.45,64.88 142.55,64.97 142.84,64.97 142.96,64.85 143.2,64.85 143.35,65 143.59,65 143.69,64.9 143.69,64.8 143.79,64.7 143.99,64.7 144.09,64.8 144.09,65 144.19,65.1 144.39,65.1 144.49,65 144.49,64.8 144.58,64.7 144.78,64.7 144.88,64.8 144.88,65 144.98,65.1 145.18,65.1 145.28,65 145.28,64.8 145.38,64.7 145.57,64.7 145.67,64.8 145.67,65 145.77,65.1 145.97,65.1 146.07,65 146.07,64.8 146.17,64.7 146.37,64.7 146.47,64.8 146.47,65.26 146.57,65.36 146.76,65.36 146.86,65.26 146.86,64.8 146.96,64.7 147.58,64.7 147.64,64.76 147.64,64.98 147.81,65.15 148.35,65.15 148.44,65.24 v2(148.44,65.47)
DDR_B_D3_2: length 40.6
  IN1 w0.081: v1(142.95,44.91) v2(142.5,45.3)
  IN1 w0.099: v1(150.43,67.06) 150.43,67.06 v2(150.74,67.37)
  IN3 w0.099: v2(150.74,67.37) 150.33,67.77 150.33,68 149.86,68.47 143.47,68.47 143.44,68.45 142.53,68.45 142.42,68.57 142.42,68.75 142.3,68.87 142.14,68.87 142.02,68.75 142.02,68.57 141.91,68.45 141.74,68.45 141.63,68.57 141.63,68.75 141.51,68.87 141.35,68.87 141.23,68.75 141.23,68.57 141.11,68.45 140.77,68.45 140.77,68.29 140.89,68.16 140.89,68 140.77,67.88 140.61,67.88 140.48,68.01 140.32,68.01 139.46,67.15 139.46,66.98 139.65,66.8 139.65,66.63 139.54,66.52 139.37,66.52 139.18,66.7 139.02,66.7 138.91,66.6 138.91,65.08 139.03,64.96 139.19,64.96 139.29,64.86 139.29,64.66 139.19,64.57 139.03,64.57 138.91,64.45 138.91,64.17 139.01,64.08 139.14,64.08 139.21,64.01 139.21,63.74 139.14,63.66 139.03,63.66 138.91,63.54 138.91,56.62 139.61,55.93 139.61,54.82 139.72,54.7 139.74,54.7 139.87,54.58 139.87,54.44 139.74,54.31 139.72,54.31 139.61,54.19 139.61,53.45 141.95,51.1 141.95,47.4 142.41,46.94 142.41,45.39 v2(142.5,45.3)
DDR_B_D3_3: length 40.5
  IN1 w0.099: v2(148.5,64.8) 148.73,64.8 148.83,64.9 v1(148.83,65.11) ; v1(143.87,42.31) v2(144.33,42.59)
  IN3 w0.099: v2(148.5,64.8) 148.5,64.57 148.2,64.26 148.2,63.92 148.1,63.83 147.97,63.83 147.87,63.92 147.87,64.26 147.7,64.44 146.64,64.44 146.54,64.34 146.54,63.63 146.44,63.53 146.22,63.53 146.13,63.63 146.13,64.34 146.03,64.44 145.85,64.44 145.73,64.32 145.73,63.95 145.62,63.84 145.02,63.84 144.91,63.73 144.25,63.73 144.01,63.97 144.01,64.33 143.87,64.47 143.44,64.47 143.34,64.37 143.34,63.89 143.22,63.77 142.61,63.77 142.49,63.65 142.49,63.49 142.61,63.37 143.27,63.37 143.39,63.26 143.39,63.09 143.27,62.98 142.68,62.98 142.57,62.86 142.57,62.67 142.68,62.55 142.76,62.55 142.88,62.43 142.88,62.27 142.76,62.15 142.68,62.15 142.57,62.04 142.57,61.9 142.68,61.78 142.86,61.78 142.96,61.69 142.96,61.49 142.86,61.39 142.68,61.39 142.57,61.27 142.57,60.11 142.68,59.99 143.21,59.99 143.32,59.88 143.32,59.71 143.21,59.6 142.68,59.6 142.57,59.48 142.57,59.22 141.81,58.46 141.81,58.31 141.58,58.08 141.58,57.96 141.7,57.85 142.06,57.85 142.17,57.73 142.17,57.57 142.06,57.45 141.7,57.45 141.58,57.33 141.58,56.75 142.05,56.28 142.05,54.56 143.92,52.68 143.92,46.72 144.23,46.42 144.23,44.93 143.99,44.69 143.99,42.21 144.07,42.13 144.58,42.13 144.68,42.23 144.68,42.49 144.58,42.59 v2(144.33,42.59)
DDR_B_D3_4: length 46.1
  IN1 w0.099: v1(142.95,42.31) v2(142.5,41.85) ; v1(150.43,65.76) 150.6,65.76 v2(150.79,65.95)
  IN3 w0.099: v2(142.5,41.85) 141.95,42.82 141.95,44.54 141.69,44.91 141.69,46.6 141.19,47.1 141.19,50.79 138.5,53.48 138.5,55.89 138.16,56.24 138.16,67.83 138.71,68.39 139.38,68.72 140.31,69.65 143.34,69.65 144.48,69.21 150.25,69.21 151.21,68.26 151.43,68.26 151.77,67.92 151.77,67.21 151.34,66.77 151.34,66.49 v2(150.79,65.95)
DDR_B_D3_5: length 45.4
  IN1 w0.099: v2(150.05,65.49) 150.43,65.12 v1(150.43,65.11) ; v1(142.95,42.96) v2(142.5,42.59)
  IN3 w0.099: v2(142.5,42.59) 142.17,42.91 142.17,44.82 141.92,45.08 141.92,46.7 141.45,47.18 141.45,50.9 138.75,53.59 138.75,56 138.41,56.34 138.41,67.73 138.82,68.13 139.15,68.13 140.41,69.4 143.24,69.4 143.68,68.96 150.14,68.96 151.12,67.99 151.32,67.99 151.51,67.8 151.51,67.4 151.11,67.01 151.11,66.59 150.87,66.35 150.73,66.35 150.05,65.68 v2(150.05,65.49)
DDR_B_D3_6: length 40.6
  IN1 w0.099: v2(150.66,67.98) 150.43,67.74 v1(150.43,67.71) ; v1(142.95,44.26) v2(142.5,44.45)
  IN3 w0.099: v2(142.5,44.45) 142.46,44.49 142.46,44.87 142.17,45.16 142.17,46.81 141.7,47.28 141.7,51 139.35,53.34 139.35,53.41 139.24,53.52 139.21,53.52 139.1,53.64 139.1,53.8 139.21,53.92 139.24,53.92 139.35,54.04 139.35,54.2 139.24,54.32 139.15,54.32 139.03,54.43 139.03,54.6 139.15,54.71 139.24,54.71 139.35,54.83 139.35,54.99 139.24,55.11 139.15,55.11 139.03,55.23 139.03,55.39 139.15,55.51 139.24,55.51 139.35,55.62 139.35,55.75 138.66,56.44 138.66,66.7 139.36,67.4 139.36,67.56 139.26,67.66 139.26,67.83 139.38,67.94 139.54,67.94 139.64,67.84 139.8,67.84 139.92,67.96 139.92,68.12 139.82,68.22 139.82,68.39 139.94,68.5 140.1,68.5 140.2,68.4 140.36,68.4 140.48,68.52 140.48,68.68 140.38,68.78 140.38,68.95 140.5,69.06 140.66,69.06 140.76,68.97 140.92,68.97 141.11,69.15 143.08,69.15 143.51,68.71 149.96,68.71 150.66,68.01 v2(150.66,67.98)
DDR_B_D3_7: length 40.3
  IN1 w0.099: v1(143.87,44.91) v2(143.42,45.3) ; v1(148.83,67.71) 148.53,67.71 148.43,67.61 v2(148.43,67.32)
  IN3 w0.099: v2(143.42,45.3) 143.42,46.25 143.16,46.5 143.16,51.61 141.13,53.65 141.13,56.13 140.77,56.48 140.77,57.73 140.75,57.76 140.75,60.51 140.86,60.62 141.14,60.62 141.26,60.74 141.26,60.9 141.14,61.02 140.94,61.02 140.84,61.12 140.84,61.32 140.94,61.42 141.14,61.42 141.26,61.53 141.26,61.7 141.14,61.81 140.74,61.81 140.62,61.93 140.62,62.09 140.74,62.21 141.14,62.21 141.26,62.32 141.26,62.49 141.14,62.6 140.81,62.6 140.7,62.72 140.7,62.88 140.81,63 141.14,63 141.26,63.12 141.26,63.28 141.14,63.4 140.92,63.4 140.82,63.5 140.82,63.69 140.92,63.79 141.14,63.79 141.26,63.91 141.26,64.07 141.14,64.19 140.94,64.19 140.84,64.29 140.84,64.83 140.75,64.92 140.75,65.95 141.13,66.33 141.47,66.33 141.56,66.42 142.03,66.42 142.28,66.17 142.28,66.06 142.4,65.94 142.56,65.94 142.68,66.06 142.68,66.47 142.79,66.59 143.15,66.59 143.27,66.47 143.27,66 143.38,65.89 143.55,65.89 143.66,66 143.66,66.22 143.78,66.33 143.89,66.33 144.21,66.65 144.54,66.65 145.16,67.27 145.41,67.27 145.51,67.17 145.51,67 145.61,66.9 145.81,66.9 145.91,67 145.91,67.13 146.02,67.25 146.3,67.25 146.41,67.13 146.41,66.27 146.53,66.16 146.69,66.16 146.81,66.27 146.81,67.15 146.93,67.27 147.09,67.27 147.21,67.15 147.21,66.62 147.31,66.51 147.49,66.51 147.6,66.62 147.6,66.86 147.73,66.99 148.23,66.99 148.43,67.19 v2(148.43,67.32)
DDR_B_DQS0: length 13.4
  TOP w0.089: UC1.AV47 145.01,46.96 145.17,46.79 v1(145.17,46.7)
  IN1 w0.081: 145.9,49.55 145.9,49.54 145.89,49.53 145.89,49.47 145.78,49.36 145.76,49.36 145.59,49.19 145.59,48.33 145.22,47.95 145.22,47.2 144.92,46.9 144.92,46.7 144.98,46.65 145.12,46.65 v1(145.17,46.7)
  IN1 w0.102: v1(149.63,56.66) 149.63,56.78 149.52,56.88 149.02,56.88 147.69,55.55 147.69,54.77 145.9,52.98 145.9,49.55
DDR_B_DQS1: length 15.2
  IN1 w0.081: v2(144.32,56.98) 144.32,56.96 v1(144.03,56.66)
  IN1 w0.102: v1(146.61,43.61) v2(146.16,43.71)
  IN3 w0.102: v2(146.16,43.71) 145.82,44.05 145.82,45.51 145.74,45.6 145.74,54.05 144.72,55.07 144.42,55.07 144.16,55.32 144.16,56.82 v2(144.32,56.98)
DDR_B_DQS2: length 26.1
  IN1 w0.099: v1(142.41,46.96) 142.51,46.96 142.58,47.03 142.58,48.16
  IN1 w0.102: v1(144.03,66.41) 144.09,66.34 144.09,66.2 143.99,66.1 143.65,66.1 143.04,66.7 142.39,66.7 142.2,66.89 141.58,66.89 141.44,67.03 140.44,67.03 139.8,66.38 139.8,57.92 139.67,57.79 139.67,57.1 139.91,56.86 139.91,56.24 140.42,55.73 140.42,54.85 142.62,52.66 142.62,48.32 142.58,48.28 142.58,48.16
DDR_B_DQS3: length 39.6
  IN1 w0.089: v2(149.29,66.73) 149.29,66.64 149.52,66.41 v1(149.63,66.41)
  IN1 w0.102: v1(143.87,43.61) v2(143.42,43.71)
  IN3 w0.102: v2(149.29,66.73) 149.16,66.61 149.16,66.44 149.23,66.38 149.67,66.38 150.08,66.79 150.08,66.99 149.04,68.03 148.04,68.03 147.51,67.5 144.97,67.5 144.56,67.09 144.08,67.09 143.83,66.84 142.29,66.84 142.02,67.11 142.02,67.57 141.87,67.71 141.66,67.71 141.51,67.57 141.51,67.11 141.25,66.84 140.88,66.84 140.01,65.97 140.01,57.85 139.89,57.73 139.89,56.65 140.62,55.92 140.62,53.43 142.66,51.4 142.66,47.4 142.84,47.22 142.84,46.5 143.04,46.31 143.04,43.56 143.14,43.46 143.32,43.46 143.42,43.56 v2(143.42,43.71)
DDR_B_DQS#0: length 13.4
  IN1 w0.081: v1(144.91,46.31) 144.91,46.45 144.73,46.63 144.73,46.97 145.03,47.27 145.03,48.03 145.41,48.4 145.41,49.27 145.7,49.55
  IN1 w0.102: v1(149.63,57.31) 149.4,57.08 148.94,57.08 147.49,55.63 147.49,54.85 145.7,53.06 145.7,49.55
DDR_B_DQS#1: length 15.3
  IN1 w0.081: v1(144.03,57.31) 143.73,57.01 v2(143.73,56.99)
  IN1 w0.102: v1(145.7,43.61) v2(145.25,43.71)
  IN3 w0.102: v2(143.73,56.99) 143.73,56.91 143.96,56.67 143.96,55.24 144.34,54.86 144.63,54.86 145.53,53.96 145.53,45.51 145.62,45.43 145.62,44.08 v2(145.25,43.71)
DDR_B_DQS#2: length 26.1
  IN1 w0.099: v1(142.41,46.31) 142.41,46.38 142.78,46.74 142.78,48.16
  IN1 w0.102: v1(144.03,65.76) 143.89,65.89 143.56,65.89 142.96,66.5 142.31,66.5 142.12,66.69 141.5,66.69 141.36,66.83 140.53,66.83 140,66.3 140,57.83 139.87,57.71 139.87,57.18 140.11,56.94 140.11,56.33 140.62,55.82 140.62,54.94 142.82,52.74 142.82,48.24 142.78,48.2 142.78,48.16 142.78,48.16
DDR_B_DQS#3: length 39.6
  IN1 w0.089: v1(149.63,65.76) 149.55,65.76 v2(149.27,66.04)
  IN1 w0.102: v1(142.95,43.61) v2(142.5,43.71)
  IN3 w0.102: v2(142.5,43.71) 142.51,43.71 142.65,43.71 142.83,43.89 142.83,46.22 142.64,46.42 142.64,47.14 142.45,47.32 142.45,51.31 140.42,53.35 140.42,55.83 139.69,56.56 139.69,57.81 139.81,57.93 139.81,66.06 140.79,67.04 141.16,67.04 141.31,67.19 141.31,67.65 141.58,67.92 141.96,67.92 142.23,67.65 142.23,67.19 142.37,67.04 143.75,67.04 144,67.3 144.47,67.3 144.88,67.7 147.42,67.7 147.96,68.24 149.13,68.24 150.29,67.08 150.29,66.71 149.76,66.18 149.41,66.18 v2(149.27,66.04)
DDR_B_ODTA: length 3.8
  TOP w0.081: RD30.1 RD29.1 152.36,58.46 152.18,58.28 150.75,58.28 UD2.G2
DDR_B_ODTB: length 3.7
  TOP w0.081: RD32.1 RD31.1 152.33,64.36 152.12,64.15 151.06,64.15 150.75,64.46 UD2.T2
DDR_C_CA0: length 43.3
  TOP w0.089: UC1.R49 133.02,47.78 132.61,47.37 v1(132.61,47.24)
  IN1 w0.081: v2(125.74,59.58) 125.75,59.53 v1(126.08,59.26)
  IN1 w0.099: v1(126.08,63.81) v2(125.68,63.48) ; v2(124.58,61.36) 124.45,61.49 124.31,61.49 124.21,61.39 124.21,61.06 124.31,60.97 124.8,60.97 124.96,60.8 124.96,60.5 124.87,60.4 124.78,60.4 124.7,60.32 124.7,59.86 124.51,59.66 124.51,58.81 124.57,58.74 124.91,58.74 124.98,58.68 124.98,58.54 125.04,58.47 125.04,57.46 124.94,57.36 124.53,57.36 124.43,57.26 124.43,57.12 124.53,57.02 124.94,57.02 125.04,56.92 125.04,56.61 124.71,56.28 124.02,56.28 123.88,56.14 123.88,55.93 123.98,55.83 124.4,55.83 124.5,55.73 124.5,55.53 124.4,55.43 123.98,55.43 123.88,55.33 123.88,55.13 123.98,55.03 124.4,55.03 124.5,54.93 124.5,51.68 125.27,50.91 126.99,50.91 127.32,50.58 129.58,50.58 131.84,48.32 131.84,46.89 131.98,46.75 131.98,46.37 132.05,46.3 132.66,46.3 132.76,46.4 132.76,46.64 132.76,46.64 132.76,46.85 132.69,46.91 132.36,46.91 132.24,47.03 132.24,47.7 132.32,47.78 132.68,47.78 132.78,47.68 132.78,47.4 v1(132.61,47.24)
  IN3 w0.099: v2(125.74,59.58) 125.46,59.3 125.16,59.3 125.04,59.42 125.04,59.97 124.94,60.07 124.79,60.07 124.69,59.97 124.69,59.34 124.59,59.24 123.83,59.24 123.73,59.34 123.73,60.91 123.89,61.07 124.28,61.07 v2(124.58,61.36) 124.58,61.57 124.43,61.71 123.9,61.71 123.73,61.88 123.73,63.58 123.83,63.68 124.24,63.68 124.33,63.58 124.33,63.03 124.43,62.93 124.63,62.93 124.73,63.03 124.73,63.39 125.01,63.66 125.5,63.66 v2(125.68,63.48)
DDR_C_CA1: length 41.2
  IN1 w0.081: v2(125.77,60.23) 125.78,60.15 v1(126.08,59.91)
  IN1 w0.099: v1(133.02,46.63) 133.02,46.42 133.1,46.34 133.35,46.34 133.43,46.25 133.43,46.13 133.33,46.03 133.23,46.03 133.16,45.96 133.16,45.35 133.08,45.27 132.95,45.27 132.85,45.37 132.85,45.95 132.75,46.05 132.44,46.05 132.34,45.95 132.34,45.68 132.27,45.61 132.01,45.61 131.74,45.88 131.74,46.61 131.6,46.75 131.6,48.22 130.28,49.55 130.24,49.55 129.46,50.33 127.21,50.33 126.88,50.66 125.16,50.66 124.25,51.57 124.25,52.13 124.19,52.2 123.7,52.2 123.63,52.27 123.63,52.55 123.73,52.65 124.15,52.65 124.25,52.74 124.25,52.94 124.15,53.04 123.73,53.04 123.63,53.14 123.63,53.34 123.73,53.44 124.15,53.44 124.25,53.54 124.25,53.73 124.15,53.83 123.73,53.83 123.63,53.93 123.63,54.13 123.73,54.23 124.15,54.23 124.25,54.33 124.25,54.53 124.15,54.63 123.73,54.63 123.63,54.73 123.63,56.25 124.19,56.81 124.19,57.52 124.26,57.59 124.69,57.59 124.79,57.69 124.79,58.31 124.72,58.38 124.31,58.38 124.25,58.44 124.25,59.62 123.96,59.91 123.96,62.01 124.06,62.11 124.29,62.11 124.37,62.03 124.37,61.78 124.41,61.74 124.62,61.74 124.7,61.82 124.7,62.13 124.8,62.23 125.12,62.23 125.25,62.1 125.25,61.81 v2(125.08,61.64) ; v1(126.08,63.16) v2(125.68,62.83)
  IN3 w0.099: v2(125.77,60.23) 125.68,60.32 124.87,60.32 124.77,60.42 124.77,60.66 124.87,60.76 125.58,60.76 125.69,60.87 125.69,61.34 125.59,61.44 125.27,61.44 v2(125.08,61.64) 124.92,61.8 124.71,61.8 124.6,61.91 124.6,62.33 124.7,62.43 124.98,62.43 125.08,62.33 125.08,62.1 125.18,62 125.61,62 125.68,62.08 v2(125.68,62.83)
DDR_C_CA2: length 40.4
  TOP w0.089: UC1.U49 133.51,47.94 v1(133.41,47.84)
  IN1 w0.081: v1(131.68,63.81) v2(132.08,63.45) ; v2(132.09,59.49) 131.98,59.5 v1(131.68,59.26)
  IN1 w0.099: v2(131.2,61.63) 131.36,61.47 131.36,61.22 131.16,61.02 130.93,61.02 130.85,61.11 130.85,61.73 130.63,61.94 130.46,61.94 130.01,62.4 129.46,62.4 129.22,62.64 128.36,62.64 127.71,62.25 125.64,62.25 125.49,62.09 125.49,61.89 125.59,61.79 125.73,61.79 125.83,61.69 125.83,61.5 125.73,61.4 125.59,61.4 125.49,61.3 125.49,61.06 125.56,60.99 125.74,60.99 125.84,60.89 125.84,60.66 125.74,60.56 125.3,60.56 125.22,60.49 125.22,60.32 124.96,60.06 124.96,59.74 124.76,59.54 124.76,59.11 124.87,59 125.07,59 125.17,59.1 125.17,59.29 125.27,59.39 125.46,59.39 125.56,59.29 125.56,59.13 125.66,59.04 125.75,59.04 125.81,58.98 125.81,58.66 125.71,58.56 125.6,58.56 125.29,58.25 125.29,56.46 124.75,55.92 124.75,55.41 124.94,55.23 124.94,55.01 124.75,54.83 124.75,51.78 125.37,51.16 127.09,51.16 127.42,50.83 129.7,50.83 132.51,48.02 132.86,48.02 133.02,47.86 133.02,47.03 133.1,46.95 133.26,46.95 133.35,47.04 133.35,47.41 133.5,47.57 133.5,47.75 v1(133.41,47.84)
  IN3 w0.099: v2(132.08,63.45) 132.05,63.48 131.77,63.48 131.69,63.4 131.69,62.11 v2(131.2,61.63) 131.2,61.38 131.72,60.87 131.72,59.91 132.06,59.57 132.06,59.51 v2(132.09,59.49)
DDR_C_CA3: length 38.5
  TOP w0.089: UC1.M45 v1(131.21,46)
  IN1 w0.081: v2(132.13,60.18) 132.13,59.9 132.48,59.54 v1(132.48,59.26) ; v1(132.48,63.81) 132.48,63.16 v2(132.53,63.1)
  IN1 w0.099: v1(131.21,46) 131.1,46.11 131.1,48.06 130.29,48.87 130.13,49.02 130.12,49.03 129.91,49.03 129.1,49.55 128.15,49.67 126.93,49.82 125.9,50.15 124.93,50.15 123.12,51.96 123.12,56.46 123.69,57.03 123.69,59.46 123.46,59.7 123.46,62.23 123.66,62.86 123.95,63.15 124.07,63.24 124.77,63.57 126.22,64.24 126.64,64.4 128.05,64.5 128.18,64.5 129.26,63.86 129.92,63.19 130.66,62.51 130.86,62.38 132.26,61.84 v2(132.28,61.78)
  IN3 w0.099: v2(132.13,60.18) 132.13,61.24 132.15,61.39 v2(132.28,61.78) 132.28,61.85 132.19,61.95 132.07,61.95 131.97,62.05 131.97,62.29 132.08,62.4 132.35,62.4 132.45,62.5 132.45,63.02 v2(132.53,63.1)
DDR_C_CA4: length 38.6
  TOP w0.089: UC1.M47 131.27,47.13 131.24,47.16 131.16,47.2 v1(130.83,47.27)
  IN1 w0.081: v1(133.28,59.26) v2(133.03,59.51) ; v1(133.28,63.81) v2(132.93,63.46)
  IN1 w0.099: v1(130.83,47.27) 130.83,47.97 130.03,48.77 129.85,48.77 129.01,49.32 127.92,49.44 126.87,49.55 125.75,49.9 124.82,49.9 122.87,51.86 122.87,56.53 123.44,57.47 123.44,59.36 123.21,59.59 123.21,62.27 123.44,63 123.86,63.42 124.17,63.57 125.67,64.27 126.02,64.42 126.55,64.62 126.73,64.65 128.18,64.76 128.27,64.73 129.41,64.05 130.54,62.95 130.88,62.66 131.06,62.56 131.42,62.44 131.44,62.44 132.21,62.16 132.43,62.08 132.82,61.75 v2(132.82,61.73)
  IN3 w0.099: v2(133.03,59.51) 133.08,59.58 132.82,61.49 v2(132.82,61.73) 133,61.91 133,62.12 132.9,62.22 132.76,62.22 132.68,62.29 132.68,62.79 132.87,62.98 132.87,63.4 v2(132.93,63.46)
DDR_C_CA5: length 39.9
  TOP w0.089: UC1.R45 133.01,45.98 132.86,45.76 v1(132.6,45.36)
  IN1 w0.081: v2(133.36,62.81) 133.28,62.89 v1(133.28,63.16) ; v1(133.28,59.91) 133.49,60.12 v2(133.55,60.12)
  IN1 w0.099: v2(133.31,61.09) 132.43,60.96 132.38,60.96 132.1,61.23 132.1,61.48 131.89,61.69 131.13,62.02 130.86,62.1 130.62,62.24 130.18,62.58 129.44,62.9 128.33,62.9 127.4,62.5 125.11,62.5 125.09,62.48 124.92,62.48 124.39,62.92 124.07,62.92 123.88,62.73 123.71,62.19 123.71,59.8 123.95,59.57 123.95,56.92 123.37,56.35 123.37,52.06 125.03,50.41 125.99,50.41 126.99,50.08 128.41,49.93 129.05,49.86 130.2,49.29 131.34,48.15 131.34,46.62 131.48,46.48 131.48,45.8 131.92,45.36 v1(132.6,45.36)
  IN3 w0.099: v2(133.36,62.81) 133.34,62.81 133.19,62.66 133.19,62.28 133.28,62.19 133.28,61.62 133.17,61.5 133.17,61.23 v2(133.31,61.09) 133.39,61.17 133.39,61.33 133.45,61.4 133.63,61.4 133.7,61.33 133.7,60.25 133.57,60.12 v2(133.55,60.12)
DDR_C_CKE0: length 32.8
  IN1 w0.081: v1(127.68,63.16) 127.35,63.16 127.28,63.09 v2(127.28,62.83) ; v1(127.68,59.91) v2(127.26,60.04)
  IN1 w0.099: v2(126.88,61.78) 126.92,61.74 127.48,61.74 127.49,61.75 128.44,62.39 129.13,62.39 129.4,62.12 129.95,62.12 130.59,61.48 130.59,60.89 130.06,60.37 130.06,59.12 130.27,58.91 130.74,58.91 130.97,58.68 130.97,58.03 130.96,58.03 130.96,58.01 130.47,57.52 130.06,57.52 129.88,57.34 129.88,56.8 129.96,56.72 130.28,56.72 130.47,56.52 130.47,54.66 130.61,54.53 130.61,53.19 135.67,48.13 135.67,47.91 136.09,47.48 136.09,46.49 135.9,46.3 135.9,46.05 136.07,45.87 136.07,45.36 135.92,45.2 134.5,45.2 134.4,45.3 134.4,45.86 v1(134.27,45.98)
  IN3 w0.099: v2(127.28,62.83) 127.28,62.8 127.28,62.56 127.18,62.46 126.59,62.46 126.49,62.36 126.49,62.22 126.59,62.11 126.8,62.11 126.88,62.04 v2(126.88,61.78) 126.62,61.52 126.62,61.16 126.87,60.91 126.87,60.6 126.78,60.52 126.78,60.37 126.96,60.2 127.11,60.2 v2(127.26,60.04)
DDR_C_CKE1: length 35.6
  IN1 w0.081: v2(129.05,59.32) 129.05,59.34 v1(128.48,59.91) ; v1(128.48,63.2) 128.39,63.29 128.39,63.77 128.5,63.88 v2(128.56,63.88)
  IN1 w0.099: v1(134.9,46.31) 134.84,46.31 134.69,46.17 134.69,46.03 134.76,45.96 135.08,45.96 135.19,45.85 135.19,45.51 135.25,45.45 135.56,45.45 135.62,45.51 135.62,46.36 135.83,46.57 135.83,47.36 135.43,47.77 135.43,48.01 134.12,49.33 134.11,49.33 130.36,53.08 130.36,54.32 130.24,54.44 130.24,56.31 130.07,56.48 129.78,56.48 129.58,56.67 129.58,57.6 129.85,57.87 130.48,57.87 130.71,58.11 130.71,58.13 130.71,58.13 130.71,58.44 130.71,58.44 130.71,58.54 130.58,58.67 130.13,58.67 129.83,58.98 129.83,60.22 129.75,60.3 129.54,60.3 129.48,60.36 129.48,60.62 129.56,60.71 130.04,60.71 130.35,61.02 130.35,61.35 129.84,61.86 129.32,61.86 129.04,62.14 128.57,62.14 v2(128.37,61.93)
  IN3 w0.099: v2(129.05,59.32) 129.58,59.32 129.67,59.42 129.67,59.7 129.58,59.79 128.83,59.79 128.3,60.31 128.3,61.06 128.15,61.21 128.15,61.72 v2(128.37,61.93) 128.37,62.67 128.49,62.8 129.56,62.8 129.66,62.9 129.66,63.13 129.59,63.21 128.5,63.21 128.4,63.31 128.4,63.71 v2(128.56,63.88)
DDR_C_CLK: length 40.7
  IN1 w0.081: v2(130.62,63.36) 130.62,63.34 130.8,63.16 v1(130.88,63.16) ; v1(130.88,59.91) v2(130.48,60.23)
  IN1 w0.102: v1(135.53,46.63) 135.45,46.72 135.18,46.72 135,46.91 135,47.38 134.78,47.59 134.78,48.03 134.64,48.17 134.21,48.17 133.99,48.39 133.99,48.81 133.68,49.12 133.49,49.12 133.42,49.06 133.42,48.95 133.24,48.76 132.85,48.76 132.65,48.97 132.65,49.46 132.74,49.55 132.74,49.7 132.5,49.93 132.03,49.93 131.48,50.48 131.48,50.94 131.35,51.07 130.89,51.07 130.56,51.41 130.56,51.71 130.6,51.75 130.6,51.84 130.22,52.21 129.97,52.21 129.63,51.87 127.81,51.87 127.51,52.17 126,52.17 125.76,52.4 125.76,53.21 125.98,53.43 127.98,53.43 128.17,53.24 128.17,53.08 128.24,53.02 129.55,53.02 129.65,53.12 129.65,53.62 129.58,53.69 129.08,53.69 128.86,53.91 128.86,54.39 129.08,54.61 129.51,54.61 129.66,54.76 129.66,55.84 129.56,55.94 129.27,55.94 129.05,56.16 129.05,57.77 129.57,58.29 129.57,58.6 129.39,58.78 129.39,59.73 129.31,59.81 129.05,59.81 128.77,60.09 128.77,60.55 129.19,60.97 129.19,61.36 v2(129.02,61.53)
  IN3 w0.102: v2(130.48,60.23) 130.51,60.2 130.71,60.2 130.77,60.26 130.77,60.71 130.67,60.81 130.36,60.81 130.09,60.54 130.09,60.36 129.85,60.11 129.23,60.11 129.03,60.32 129.03,60.8 129.23,61 129.23,61.32 v2(129.02,61.53) 129.24,61.76 129.24,62.34 129.46,62.55 129.77,62.55 130.5,61.82 130.64,61.82 130.96,62.14 130.96,62.28 130.7,62.54 130.7,62.95 130.82,63.07 130.82,63.16 v2(130.62,63.36)
DDR_C_CLK#: length 40.7
  IN1 w0.081: v1(131.68,59.91) v2(131.28,60.23) ; v2(131.28,62.83) v1(131.68,63.16)
  IN1 w0.102: v1(135.53,47.29) 135.58,47.24 135.58,47.03 135.48,46.92 135.27,46.92 135.2,46.99 135.2,47.46 134.98,47.68 134.98,48.11 134.72,48.37 134.3,48.37 134.2,48.47 134.2,48.89 133.76,49.33 133.4,49.33 133.22,49.14 133.22,49.03 133.16,48.97 132.93,48.97 132.85,49.05 132.85,49.38 132.94,49.47 132.94,49.78 132.59,50.14 132.11,50.14 131.69,50.56 131.69,51.02 131.43,51.28 130.97,51.28 130.76,51.49 130.76,51.62 130.8,51.66 130.8,51.92 130.31,52.42 129.89,52.42 129.54,52.07 127.9,52.07 127.59,52.37 126.08,52.37 125.97,52.49 125.97,53.12 126.07,53.23 127.9,53.23 127.97,53.16 127.97,53 128.15,52.82 129.63,52.82 129.85,53.04 129.85,53.71 129.66,53.9 129.17,53.9 129.06,54 129.06,54.3 129.17,54.4 129.59,54.4 129.86,54.67 129.86,55.92 129.64,56.15 129.36,56.15 129.26,56.25 129.26,57.68 129.78,58.2 129.78,58.68 129.59,58.87 129.59,59.81 129.39,60.01 129.13,60.01 128.97,60.17 128.97,60.46 129.39,60.88 129.39,61.31 v2(129.62,61.53)
  IN3 w0.102: v2(131.28,60.23) 131.25,60.2 131.03,60.2 130.97,60.26 130.97,60.79 130.75,61.01 130.28,61.01 129.89,60.62 129.89,60.45 129.76,60.32 129.31,60.32 129.23,60.4 129.23,60.72 129.43,60.92 129.43,61.35 v2(129.62,61.53) 129.45,61.7 129.45,62.25 129.54,62.35 129.69,62.35 130.42,61.62 130.73,61.62 131.16,62.05 131.16,62.37 130.91,62.62 130.91,62.86 131.01,62.96 131.15,62.96 v2(131.28,62.83)
DDR_C_CS#0: length 35.5
  IN1 w0.081: v1(127.68,59.26) 127.48,59.42 127.47,59.51 v2(127.48,59.52) ; v1(127.68,63.81) v2(127.21,63.48)
  IN1 w0.099: v2(127.53,61.34) 127.99,61.34 128.2,61.12 128.2,59.81 128.44,59.57 128.44,59.21 128.8,58.85 128.8,58.48 128.58,58.26 128.49,58.26 128.39,58.16 128.39,57.96 128.49,57.86 128.69,57.86 128.8,57.76 128.8,56.92 128.49,56.61 128.49,54.64 127.78,53.94 126.46,53.94 126.36,54.04 126.36,54.35 126.26,54.45 126.06,54.45 125.96,54.35 125.96,54.04 125.86,53.94 125.5,53.94 125.26,53.7 125.26,51.99 125.58,51.66 127.3,51.66 127.63,51.33 129.9,51.33 132.74,48.5 133.45,48.5 134.75,47.2 134.75,46.6 134.51,46.35 134.12,46.35 133.98,46.21 133.98,45.88 134.14,45.72 134.14,45.18 134,45.04 134,44.69 134.17,44.52 134.45,44.52 v1(134.72,44.26)
  IN3 w0.099: v2(127.48,59.52) 127.68,59.52 127.92,59.76 127.92,60.81 127.53,61.2 v2(127.53,61.34) 127.68,61.49 127.68,63.08 127.28,63.48 v2(127.21,63.48)
DDR_C_CS#1: length 35.2
  IN1 w0.081: v1(126.88,59.26) v2(126.48,59.02)
  IN1 w0.099: v2(126.65,64.05) 126.68,63.94 v1(126.88,63.81) ; v1(134.72,42.96) 134.97,43.53 134.97,43.71 134.69,44 134.61,44 134.35,44.26 134.09,44.26 133.75,44.6 133.75,46.4 133.81,46.47 133.81,46.78 133.66,46.94 133.66,47.27 133.74,47.35 133.74,47.87 133.35,48.26 132.62,48.26 129.8,51.08 127.52,51.08 127.19,51.41 125.48,51.41 125,51.88 125,54.59 125.19,54.78 125.19,55.08 125.61,55.5 125.61,55.99 125.76,56.15 125.78,56.15 126.09,56.46 126.09,56.96 126.46,57.33 126.53,57.33 126.75,57.55 126.75,58.07 127.16,58.48 127.16,59.37 126.91,59.62 126.91,60.35 126.79,60.46 126.45,60.46 126.34,60.57 126.34,60.9 126.45,61.01 126.54,61.01 126.6,61.08 126.6,61.35 126.54,61.42 126.16,61.42 126.08,61.34 v2(126.08,61.18)
  IN3 w0.099: v2(126.48,59.02) 126.2,59.02 126.1,59.12 126.1,60.41 126.2,60.51 126.43,60.51 126.52,60.61 126.52,60.74 126.43,60.84 126.16,60.84 126.08,60.92 v2(126.08,61.18) 125.87,61.56 125.87,61.81 126.07,62.98 126.12,63.6 126.57,64.05 v2(126.65,64.05)
DDR_C_D0_0: length 25
  IN1 w0.099: v1(133.28,67.71) 133.33,67.76 134.81,67.76 135.9,66.67 136.6,66.67 137.24,66.03 137.24,59.38 137.29,59.33 137.29,54.99 140.5,51.78 140.5,48.91 140.79,48.62 140.79,47.54 v1(140.54,47.29)
DDR_C_D0_1: length 29.1
  IN1 w0.099: v1(140.54,45.98) 140.54,46.25 140.84,46.55 140.84,46.8 141.24,47.2 141.24,48.82 141,49.06 141,51.99 137.79,55.2 137.79,59.54 137.74,59.59 137.74,66.28 135.76,68.26 132.81,68.26 132.26,67.71 v1(131.68,67.71)
DDR_C_D0_2: length 23.8
  IN1 w0.099: v1(140.54,47.94) 140.54,48.54 140.25,48.83 140.25,51.67 137.04,54.88 137.04,59.23 136.99,59.28 136.99,65.87 136.51,66.35 135.84,66.35 135.16,67.02 134.78,67.02 134.48,67.32 133.87,67.32 133.61,67.06 v1(133.28,67.06)
DDR_C_D0_3: length 22.3
  IN1 w0.081: 138.28,49.45 138.28,49.31 138.7,48.88 138.7,48.55 138.92,48.33 138.92,46.96 139.25,46.63 v1(139.28,46.63)
  IN1 w0.099: v1(131.68,65.11) 132.24,65.11 132.74,64.61 133.12,64.61 133.43,64.3 133.43,64.06 133.55,63.94 133.55,63.17 133.94,62.77 133.94,59.14 133.92,59.12 133.92,57.96 134.4,57.48 134.4,57.22 134.3,57.11 134.3,56.28 134.86,55.71 134.86,54.15 138.28,50.73 138.28,49.45
DDR_C_D0_4: length 28.2
  IN1 w0.099: v1(131.68,67.06) 132.08,67.46 132.39,67.46 132.94,68.01 135.65,68.01 137.49,66.17 137.49,59.49 137.54,59.44 137.54,55.09 140.75,51.88 140.75,48.98 141.02,48.72 141.02,47.39 140.54,46.91 v1(140.54,46.63)
DDR_C_D0_5: length 23.2
  IN1 w0.081: v1(139.28,45.98) 139.57,46.28 139.57,46.34 139.57,46.7 139.44,46.82 139.44,47.1 139.55,47.2 139.55,47.49 139.78,47.73 139.78,48.37 139.33,48.82 139.33,49.16 139.03,49.45
  IN1 w0.099: v1(133.28,65.76) 133.61,65.43 134.28,65.43 134.8,64.91 134.8,64.3 135.39,63.71 135.39,57.24 135.62,57.01 135.62,54.46 139.03,51.05 139.03,49.45
DDR_C_D0_6: length 22.3
  IN1 w0.081: 138.78,49.46 138.78,49.4 139.12,49.06 139.12,48.74 139.57,48.29 139.57,47.83 139.28,47.54 v1(139.28,47.29)
  IN1 w0.099: v1(133.28,65.11) 134.1,65.11 134.39,64.82 134.39,64.82 134.55,64.66 134.55,63.95 134.67,63.83 134.67,62.89 134.49,62.71 134.49,61.52 134.59,61.42 135,61.42 135.1,61.32 135.1,61.12 135,61.02 134.59,61.02 134.49,60.93 134.49,58.9 134.42,58.84 134.42,58.2 134.94,57.68 134.94,57.02 134.81,56.89 134.81,56.48 135.37,55.92 135.37,54.36 138.78,50.94 138.78,49.46
DDR_C_D0_7: length 22.1
  IN1 w0.081: 138.53,49.51 138.53,49.35 138.91,48.97 138.91,48.65 139.28,48.28 v1(139.28,47.94)
  IN1 w0.099: 138.53,49.51 138.53,50.84 135.12,54.25 135.12,55.82 134.56,56.38 134.56,56.99 134.68,57.11 134.68,57.57 134.17,58.08 134.17,58.94 134.18,58.95 134.18,59.03 134.24,59.08 134.24,62.86 134.41,63.04 134.41,63.66 134.3,63.78 134.3,64.56 133.99,64.86 132.82,64.86 132.31,65.36 132.08,65.36 v1(131.68,65.76)
DDR_C_D1_0: length 37.1
  IN1 w0.099: v1(126.08,65.11) v2(125.62,64.84) ; v1(140.21,42.31) v2(139.76,41.85)
  IN3 w0.099: v2(125.62,64.84) 125.51,64.72 125.51,64.07 125.62,63.96 125.95,63.96 126.03,64.03 126.03,64.36 126.17,64.5 128.41,64.5 128.93,63.98 129.99,63.98 130.65,64.65 132.77,64.65 133.52,63.89 133.52,63.19 133.97,62.74 133.97,57.21 134.01,57.17 134.01,53.62 138.12,49.51 138.12,46.92 138.93,46.1 138.93,46.09 138.95,46.07 138.95,44.91 139.17,44.68 139.17,42.44 139.39,42.23 140.23,42.23 140.33,42.12 140.33,41.98 140.25,41.91 139.82,41.91 v2(139.76,41.85)
DDR_C_D1_1: length 39.6
  IN1 w0.099: v1(141.12,42.96) v2(140.67,42.59) ; v1(126.08,67.06) v2(126.39,67.2)
  IN3 w0.099: v2(140.67,42.59) 141.03,42.94 141.03,44.81 141.23,45.01 141.23,46.41 140.59,47.06 140.59,50.54 137.54,53.59 137.54,55.66 137.56,55.67 137.56,66.12 135.82,67.85 134.39,67.85 133.72,68.53 129.15,68.53 128.96,68.73 127.09,68.73 126.78,68.41 126.78,67.59 v2(126.39,67.2)
DDR_C_D1_2: length 36.8
  IN1 w0.099: v1(140.21,42.96) v2(139.76,42.59) ; v2(125.61,66.11) 125.62,66.09 v1(126.08,65.76)
  IN3 w0.099: v2(139.76,42.59) 139.4,42.95 139.4,44.8 139.18,45.03 139.18,46.17 139.16,46.18 139.16,46.2 139.15,46.21 139.15,46.22 138.37,47 138.37,49.62 134.28,53.7 134.28,58.66 134.63,59.01 134.63,59.39 134.24,59.78 134.24,64.22 133.59,64.88 130.55,64.88 129.9,64.23 129.06,64.23 128.55,64.74 127.76,64.74 127.66,64.84 127.66,64.99 127.56,65.09 127.36,65.09 127.26,64.99 127.26,64.84 127.17,64.74 126.97,64.74 126.87,64.84 126.87,65.57 126.81,65.63 126.46,65.63 126.4,65.57 126.4,65.45 126.33,65.39 126.05,65.39 125.98,65.46 125.98,66.05 125.91,66.11 v2(125.61,66.11)
DDR_C_D1_3: length 37.3
  IN1 w0.081: v1(141.12,44.91) v2(140.67,45.3) ; v1(127.68,67.71) v2(128.11,68.03)
  IN3 w0.099: v2(128.11,68.03) 128.11,67.71 128.54,67.29 129.14,67.29 129.24,67.39 129.24,67.84 129.34,67.94 129.54,67.94 129.63,67.84 129.63,67.39 129.73,67.29 130.76,67.29 130.84,67.37 130.84,67.82 130.94,67.92 131.81,67.92 131.93,67.79 131.93,67.23 132.03,67.13 132.23,67.13 132.33,67.23 132.33,67.84 132.43,67.94 133.59,67.94 134.79,66.75 136.16,66.75 137.05,65.86 137.05,55.88 137.04,55.87 137.04,55.36 136.94,55.26 136.82,55.26 136.72,55.16 136.72,54.97 136.82,54.87 136.94,54.87 137.04,54.77 137.04,54.57 136.94,54.47 136.82,54.47 136.72,54.37 136.72,54.17 136.82,54.07 136.94,54.07 137.04,53.98 137.04,53.38 140.09,50.33 140.09,46.9 140.78,46.21 140.78,45.41 v2(140.67,45.3)
DDR_C_D1_4: length 40.1
  IN1 w0.099: v1(141.12,42.31) v2(141.59,42.59) ; v1(126.08,67.71) v2(125.62,68.03)
  IN3 w0.099: v2(141.59,42.59) 141.26,42.91 141.26,43.01 141.26,43.01 141.26,44.59 141.26,44.59 141.26,44.66 141.46,44.87 141.46,46.51 140.84,47.13 140.84,50.64 137.79,53.69 137.79,55.56 137.81,55.57 137.81,66.3 135.95,68.16 134.44,68.16 133.82,68.78 129.32,68.78 129.13,68.98 126.98,68.98 v2(125.62,68.03)
DDR_C_D1_5: length 34.3
  IN1 w0.081: v1(127.68,65.11) v2(128.05,65.13) ; 139.91,44.58 v2(139.76,44.73)
  IN1 w0.099: v1(140.21,44.26) 140.21,44.28 139.91,44.58
  IN3 w0.099: v2(128.05,65.13) 128.24,65.13 128.3,65.19 128.3,65.3 128.39,65.39 128.56,65.39 128.63,65.31 128.63,65.09 128.72,65 129.82,65 129.93,65.11 130.26,65.11 130.36,65.2 130.36,65.43 130.46,65.53 130.66,65.53 130.76,65.43 130.76,65.2 130.86,65.11 133.69,65.11 134.49,64.31 134.49,61.54 134.59,61.44 135,61.44 135.1,61.34 135.1,61.14 135,61.05 134.59,61.05 134.49,60.95 134.49,59.89 134.89,59.49 134.89,58.99 135.25,58.63 135.25,58.08 135.13,57.96 134.7,57.96 134.55,57.81 134.55,56.23 134.7,56.08 134.92,56.08 135.02,55.98 135.02,55.78 134.92,55.68 134.7,55.68 134.6,55.58 134.6,55.38 134.7,55.28 134.92,55.28 135.02,55.18 135.02,54.99 134.92,54.89 134.7,54.89 134.6,54.79 134.6,54.59 134.7,54.49 134.92,54.49 135.02,54.39 135.02,54.19 134.92,54.09 134.7,54.09 134.6,54 134.6,53.74 138.62,49.72 138.62,47.07 139.41,46.28 139.41,45.13 139.64,44.9 139.64,44.85 v2(139.76,44.73)
DDR_C_D1_6: length 37.1
  IN1 w0.081: v1(127.68,67.06) v2(127.39,67.22) ; 140.82,44.58 v2(140.67,44.73)
  IN1 w0.099: v1(141.12,44.26) 141.12,44.28 140.82,44.58
  IN3 w0.099: v2(140.67,44.73) 140.67,44.79 141.01,45.13 141.01,46.32 140.34,46.99 140.34,50.44 137.29,53.48 137.29,55.76 137.3,55.78 137.3,65.98 136.28,67 134.92,67 134.85,67.07 134.85,67.18 134.97,67.3 134.97,67.44 134.83,67.58 134.69,67.58 134.57,67.46 134.43,67.46 133.68,68.21 128.97,68.21 128.69,68.49 127.32,68.49 127.01,68.19 127.01,67.32 127.11,67.22 v2(127.39,67.22)
DDR_C_D1_7: length 34.2
  IN1 w0.081: v1(140.21,44.91) v2(139.74,45.26) ; v2(128.05,66.14) 128.01,66.13 v1(127.68,65.76)
  IN3 w0.099: v2(139.74,45.26) 139.74,46.28 138.87,47.15 138.87,49.83 135.27,53.42 135.27,56.23 135.2,56.31 135.02,56.31 134.8,56.53 134.8,57.49 135.02,57.71 135.44,57.71 135.62,57.89 135.62,59.21 135.52,59.3 135.25,59.3 135.15,59.4 135.15,59.6 135.25,59.7 135.52,59.7 135.62,59.8 135.62,59.92 135.38,60.16 135.38,62.94 135.28,63.04 134.87,63.04 134.77,63.14 134.77,63.34 134.87,63.44 135.28,63.44 135.38,63.54 135.38,63.78 135.29,63.87 134.93,63.87 134.75,64.04 134.75,64.4 134.24,64.91 134.24,65.03 134.35,65.13 134.35,65.27 134.21,65.41 134.07,65.41 133.96,65.3 133.82,65.3 133.68,65.45 133.68,65.59 133.8,65.7 133.8,65.84 133.66,65.98 133.52,65.98 133.37,65.84 133.11,65.84 133.01,65.93 133.01,66.12 132.91,66.22 132.71,66.22 132.61,66.12 132.61,65.93 132.51,65.84 132.33,65.84 132.25,65.76 131.9,65.76 131.85,65.81 128.55,65.81 128.23,66.14 v2(128.05,66.14)
DDR_C_D2_0: length 12.7
  TOP w0.089: v1(136.55,48.25) 136.56,48.25 136.77,48.03 UC1.AB49
  IN1 w0.099: v1(136.55,48.25) 136.55,48.25 136.55,48.4 135.41,49.55 135.41,49.96 131.93,53.44 131.93,54.67 131.86,54.74 131.74,54.74 131.16,55.32 131.16,56.7 131.42,56.97 131.42,57.46 131.68,57.72 v1(131.68,57.96)
DDR_C_D2_1: length 15.7
  IN1 w0.099: v1(136.77,47.29) 136.77,47.56 136.28,48.06 136.28,48.33 135.15,49.46 135.15,49.86 131.68,53.34 131.68,54.48 130.93,55.22 130.93,56.8 131.16,57.02 131.16,57.55 131.43,57.82 131.43,58.08 131.57,58.22 132.03,58.22 132.52,57.73 132.52,57.73 132.61,57.64 132.73,57.64 132.99,57.39 133.2,57.39 v1(133.28,57.31)
DDR_C_D2_2: length 11
  TOP w0.102: UD3.AA9 132.04,55.67 v1(132.11,55.67)
  IN1 w0.081: 137.17,49.55 137.17,49.24 137.87,48.54 137.87,48.1 v1(138.04,47.94)
  IN1 w0.099: v1(132.11,55.67) 132.55,55.67 133.76,54.46 133.76,53.69 137.17,50.27 137.17,49.55
DDR_C_D2_3: length 12.3
  IN1 w0.081: v1(138.04,46.63) 138.04,46.63 138.32,46.63 138.71,47.02 138.71,48.24 138.5,48.46 138.5,48.79 137.92,49.37 137.92,49.5
  IN1 w0.099: 137.92,49.5 137.92,50.59 134.51,54 134.51,55.18 133.84,55.85 133.53,55.85 133.38,56.01 v1(133.28,56.01)
DDR_C_D2_4: length 12.6
  TOP w0.102: UD3.Y9 v1(132.09,56.35)
  IN1 w0.081: v1(138.04,47.29) 138.28,47.53 138.28,48.08 138.08,48.29 138.08,48.62 137.42,49.28 137.42,49.55
  IN1 w0.099: v1(132.09,56.35) 132.63,56.35 132.82,56.16 132.82,55.74 134.01,54.55 134.01,53.79 137.42,50.38 137.42,49.55
DDR_C_D2_5: length 16.7
  IN1 w0.099: v1(136.77,46.63) 136.77,46.92 136.48,47.21 136.48,47.52 136.03,47.98 136.03,48.23 134.9,49.35 134.9,49.75 131.37,53.28 131.37,54.46 130.71,55.13 130.71,56.9 130.9,57.09 130.9,57.61 131.2,57.91 131.2,57.93 131.2,57.93 131.2,58.18 131.47,58.45 132.12,58.45 132.61,57.96 v1(133.28,57.96)
DDR_C_D2_6: length 14
  IN1 w0.099: v1(131.68,57.31) 131.68,56.91 131.38,56.61 131.38,55.41 131.83,54.96 131.99,54.96 132.21,54.74 132.21,53.52 135.66,50.07 135.66,49.62 136.81,48.47 136.81,47.94 137.07,47.68 137.07,46.28 v1(136.77,45.98)
DDR_C_D2_7: length 12.4
  TOP w0.102: v1(133.67,55.42) 133.61,55.36 UD3.AA11
  IN1 w0.081: 137.67,49.53 137.67,49.32 138.29,48.71 138.29,48.37 138.49,48.17 138.49,47.27 138.24,47.01 138.07,47.01 137.78,46.72 137.78,46.42 138.04,46.16 v1(138.04,45.98)
  IN1 w0.099: 137.67,49.53 137.67,50.48 134.26,53.9 134.26,54.84 v1(133.67,55.42)
DDR_C_D3_0: length 25.7
  IN1 w0.081: v2(125.66,58.15) 125.89,58.15 v1(126.08,57.96)
  IN1 w0.099: v1(137.46,42.31) v2(137.01,41.85)
  IN3 w0.099: v2(137.01,41.85) 136.94,41.92 136.45,42.41 136.45,44.58 134.86,46.17 134.86,47 134.79,47.07 134.79,47.09 134.59,47.29 134.59,48.1 132.7,50 132.7,50.57 131.37,51.9 130.79,51.9 129.9,52.8 128.71,52.8 128.34,52.44 126.52,52.44 124.93,54.04 124.93,57.58 125.49,58.15 v2(125.66,58.15)
DDR_C_D3_1: length 23.7
  IN1 w0.081: v1(126.08,57.31) v2(125.62,56.99)
  IN1 w0.099: v1(137.46,42.96) v2(137.01,42.59)
  IN3 w0.099: v2(125.62,56.99) 125.29,56.66 125.29,56.27 125.61,55.95 125.61,55.53 125.21,55.13 125.21,54.1 126.63,52.69 128.22,52.69 128.58,53.05 130,53.05 130.87,52.18 131.45,52.18 132.95,50.68 132.95,50.1 134.82,48.23 134.82,47.38 135.09,47.12 135.09,46.26 136.68,44.67 136.68,42.92 v2(137.01,42.59)
DDR_C_D3_2: length 21.1
  IN1 w0.081: v1(127.68,57.31) v2(128.06,56.88)
  IN1 w0.099: v1(138.38,42.96) v2(137.93,42.59)
  IN3 w0.099: v2(128.06,56.88) 128.08,56.88 128.17,56.79 129.98,56.79 137.51,49.26 137.51,46.88 138.47,45.92 138.47,45.92 138.5,45.89 138.5,44.93 138.47,44.9 138.27,44.7 138.27,42.93 v2(137.93,42.59)
DDR_C_D3_3: length 22.3
  IN1 w0.081: v2(127.99,55.16) 127.96,55.16 v1(127.68,55.36) ; v1(138.38,44.91) v2(137.93,45.3)
  IN3 w0.099: v2(137.93,45.3) 138,45.38 138,45.74 136.99,46.75 136.99,47.1 136.91,47.18 136.71,47.18 136.61,47.28 136.61,47.48 136.75,47.62 136.75,47.73 136.55,47.93 136.55,49.51 131.3,54.76 130.8,54.76 130.7,54.86 130.7,55.35 130.6,55.45 130.41,55.45 130.31,55.35 130.31,54.76 130.21,54.66 130.01,54.66 129.91,54.76 129.91,55.74 129.81,55.84 129.61,55.84 129.51,55.74 129.51,54.77 129.42,54.67 129.22,54.67 129.12,54.77 129.12,55.74 129.02,55.84 128.82,55.84 128.72,55.74 128.72,54.86 128.62,54.76 128.39,54.76 v2(127.99,55.16)
DDR_C_D3_4: length 22.4
  IN1 w0.081: v1(127.68,57.96) 127.73,57.96 v2(128.02,57.63)
  IN1 w0.099: v1(138.38,42.31) v2(138.84,42.59)
  IN3 w0.099: v2(138.84,42.59) 138.5,42.93 138.5,44.61 138.7,44.81 138.7,44.81 138.72,44.83 138.72,45.98 138.7,46 138.7,46.01 137.76,46.94 137.76,49.37 131.49,55.64 131.49,57.05 130.99,57.54 128.66,57.54 128.57,57.63 v2(128.02,57.63)
DDR_C_D3_5: length 21.1
  IN1 w0.081: v2(126.39,55.87) v1(126.08,56.01)
  IN1 w0.099: v1(137.46,44.91) v2(137.01,45.3)
  IN3 w0.099: v2(137.01,45.3) 136.96,45.35 136.96,45.84 136.58,46.22 136.45,46.22 136.33,46.11 136.19,46.11 136.05,46.25 136.05,46.39 136.17,46.5 136.17,46.64 136.02,46.79 135.88,46.79 135.85,46.75 135.71,46.75 135.57,46.89 135.57,47.03 135.63,47.09 135.63,47.29 135.31,47.61 135.31,48.46 134.61,49.16 134.61,49.3 134.75,49.44 134.75,49.58 134.61,49.72 134.47,49.72 134.33,49.58 134.19,49.58 134.05,49.72 134.05,49.86 134.19,50 134.19,50.14 134.05,50.28 133.91,50.28 133.77,50.14 133.63,50.14 133.46,50.31 133.46,50.88 131.61,52.73 131.04,52.73 130.21,53.56 128.27,53.56 127.91,53.2 126.85,53.2 126.18,53.87 126.18,55.09 126.02,55.25 126.02,55.72 126.18,55.87 v2(126.39,55.87)
DDR_C_D3_6: length 20.2
  IN1 w0.081: v1(126.08,55.36) v2(125.62,55.04)
  IN1 w0.099: v1(137.46,44.26) 137.46,44.31 v2(137.01,44.75)
  IN3 w0.099: v2(125.62,55.04) 125.52,55.04 125.45,54.96 125.45,54.73 125.49,54.68 125.85,54.68 125.93,54.61 125.93,54.41 125.86,54.34 125.59,54.34 125.53,54.28 125.53,54.16 126.74,52.94 128.1,52.94 128.47,53.3 130.11,53.3 130.98,52.43 131.55,52.43 133.2,50.78 133.2,50.21 135.06,48.35 135.06,47.51 135.32,47.25 135.32,46.47 135.51,46.28 135.69,46.28 136.02,45.95 136.02,45.65 136.46,45.21 136.64,45.21 136.71,45.15 136.71,44.99 136.95,44.75 v2(137.01,44.75)
DDR_C_D3_7: length 20.3
  IN1 w0.081: v2(137.94,44.78) 138.14,44.58 ; v1(127.68,56.01) v2(127.37,55.87)
  IN1 w0.099: 138.14,44.58 138.38,44.34 v1(138.38,44.26)
  IN3 w0.099: v2(127.37,55.87) 127.37,56.04 127.54,56.21 127.78,56.21 127.88,56.31 127.88,56.43 127.98,56.53 128.18,56.53 128.28,56.43 128.28,56.31 128.37,56.21 128.57,56.21 128.67,56.31 128.67,56.43 128.77,56.53 128.97,56.53 129.07,56.43 129.07,56.31 129.17,56.21 129.37,56.21 129.46,56.31 129.46,56.43 129.56,56.53 129.76,56.53 129.86,56.43 129.86,56.31 129.96,56.21 130.21,56.21 136.8,49.62 136.8,48.04 137.26,47.59 137.26,46.81 138.27,45.79 138.27,45.02 138.03,44.78 v2(137.94,44.78)
DDR_C_DQS0: length 24.7
  IN1 w0.081: 140.22,46.83 140.13,46.74 140.09,46.74 139.91,46.92 v1(139.91,46.96)
  IN1 w0.102: v1(132.48,66.41) 132.48,66.25 132.53,66.2 132.9,66.2 133.17,66.47 134.26,66.47 136.1,64.63 136.1,59.45 136.33,59.22 136.33,54.77 139.74,51.36 139.74,49.3 139.97,49.08 139.97,48.79 140.22,48.54 140.22,46.83
DDR_C_DQS1: length 35.2
  IN1 w0.102: v1(126.88,66.41) v2(126.58,66.08) ; v1(141.12,43.61) v2(140.67,43.71)
  IN3 w0.102: v2(126.58,66.08) 126.78,66.28 126.78,66.55 127.02,66.79 127.65,66.79 127.77,66.9 128.31,66.9 128.91,66.31 131.09,66.31 131.51,66.73 133.94,66.73 136.09,64.58 136.09,60.46 136.34,60.2 136.34,57.16 136.04,56.86 136.04,53.66 139.58,50.12 139.58,47.08 140.31,46.35 140.31,44.07 v2(140.67,43.71)
DDR_C_DQS2: length 13.9
  IN1 w0.081: 136.54,49.39 136.54,49.38 136.54,49.37 136.92,49 137.12,49 137.66,48.45 137.66,47.63 137.73,47.57 137.73,46.94 137.41,46.61 v1(137.41,46.31)
  IN1 w0.102: v1(132.48,56.66) 132.39,56.75 132.14,56.75 131.81,56.43 131.81,55.59 132.01,55.39 132.45,55.39 133.18,54.66 133.18,53.55 136.54,50.19 136.54,49.39
DDR_C_DQS3: length 21.9
  IN1 w0.081: v1(126.88,56.66) v2(126.58,56.99)
  IN1 w0.102: v1(137.46,43.61) v2(137.01,43.71)
  IN3 w0.102: v2(126.58,56.99) 126.83,56.74 126.83,55.54 126.84,55.53 126.84,55.21 126.77,55.14 126.77,54.74 126.69,54.67 126.69,54.08 127.06,53.7 127.65,53.7 128.01,54.06 130.42,54.06 131.05,53.43 131.63,53.43 135.45,49.61 135.45,49.03 135.82,48.66 135.82,47.67 136.01,47.48 136.01,47.12 137.36,45.78 137.36,43.78 137.28,43.7 137.02,43.7 v2(137.01,43.71)
DDR_C_DQS#0: length 24.7
  IN1 w0.081: 140,47.28 139.95,47.23 139.83,47.23 139.66,47.06 139.66,46.86 139.91,46.61 v1(139.91,46.31)
  IN1 w0.102: 140,47.28 140.02,47.3 140.02,48.45 139.77,48.7 139.77,48.99 139.54,49.22 139.54,51.28 136.13,54.69 136.13,59.14 135.9,59.36 135.9,64.54 134.17,66.27 133.26,66.27 132.99,66 132.58,66 132.48,65.9 v1(132.48,65.76)
DDR_C_DQS#1: length 35.2
  IN1 w0.099: v2(127.18,66.09) 127.13,66.09 126.88,65.84 v1(126.88,65.76)
  IN1 w0.102: v1(140.21,43.61) 139.85,43.61 v2(139.76,43.71)
  IN3 w0.102: v2(127.18,66.09) 127.08,66.09 126.98,66.19 126.98,66.46 127.1,66.58 127.74,66.58 127.85,66.7 128.23,66.7 128.82,66.1 131.17,66.1 131.6,66.53 133.85,66.53 135.88,64.49 135.88,60.37 136.14,60.12 136.14,57.25 135.84,56.95 135.84,53.57 139.38,50.04 139.38,46.99 140.1,46.27 140.1,43.99 140.2,43.89 140.2,43.64 140.13,43.57 139.89,43.57 v2(139.76,43.71)
DDR_C_DQS#2: length 13.9
  IN1 w0.081: 136.35,49.3 136.84,48.81 137.04,48.81 137.48,48.37 137.48,47.56 137.54,47.49 137.54,47.1 v1(137.41,46.96)
  IN1 w0.102: 136.35,49.3 136.34,49.32 136.34,50.1 132.98,53.46 132.98,54.57 132.36,55.19 131.93,55.19 131.61,55.5 131.61,56.52 132.05,56.96 132.46,56.96 132.56,57.06 132.56,57.23 v1(132.48,57.31)
DDR_C_DQS#3: length 21.9
  IN1 w0.081: v1(126.88,57.31) v2(127.18,56.98)
  IN1 w0.102: v1(138.38,43.61) v2(137.93,43.71)
  IN3 w0.102: v2(127.18,56.98) 127.03,56.84 127.03,55.62 127.05,55.61 127.05,55.13 126.97,55.05 126.97,54.66 126.89,54.58 126.89,54.16 127.15,53.91 127.57,53.91 127.93,54.27 130.5,54.27 131.14,53.63 131.71,53.63 135.66,49.69 135.66,49.11 136.02,48.75 136.02,47.75 136.21,47.56 136.21,47.21 137.56,45.86 137.56,43.79 137.64,43.71 137.92,43.71 v2(137.93,43.71)
DDR_C_ODTA: length 3.9
  TOP w0.081: 124.85,64.78 124.2,64.78 123.51,65.47 RD33.1 122.66,65.47 RD34.1
  TOP w0.102: 124.85,64.78 125.59,64.78 125.92,64.46 UD3.G2
DDR_C_ODTB: length 3.7
  TOP w0.081: RD35.1 123.27,59.26 RD36.1 123.86,58.65 124.14,58.93 125.48,58.93 125.8,58.61 UD3.T2
DDR_CHA_EN: length 12.2
  TOP w0.089: UC1.CC47 156.79,46.43 v1(157.22,46)
  IN1 w0.081: v2(158.96,44.85) 158.96,45.39 158.74,45.61 158.48,45.61 158.09,46 v1(157.22,46)
  IN3 w0.081: v4(158.74,45.46) 158.96,45.25 v2(158.96,44.85)
  BOTTOM w0.081: RH738.1 157.5,50.5 157.08,50.5 RH740.1 156.18,49.6 156.18,47.3 v3(156.36,47.12) 156.46,47.02 157.15,47.02 157.73,46.44 157.73,46.01 158.28,45.46 v4(158.74,45.46)
DDR_CHB_EN: length 10.8
  TOP w0.089: v1(157.83,45.69) 158.05,45.92 UC1.CF45
  IN1 w0.081: v1(157.83,45.69) 158.16,45.69 158.41,45.44 158.49,45.44 158.63,45.3 158.63,44.98 158.57,44.91 158.57,44.59 158.84,44.32 v2(158.95,44.32)
  IN3 w0.081: v2(158.95,44.32) 159.3,44.68 159.3,44.96 159.24,45.02 159.24,45.32 v4(158.74,45.82)
  BOTTOM w0.081: RH739.1 157.57,49.79 157.01,49.79 RH741.1 v3(156.69,48.48) 156.69,47.77 157.92,46.54 157.92,46.08 158.18,45.82 v4(158.74,45.82)
DDR_COMP_0: length 4.2
  TOP w0.127: 128.83,48.41 128.83,48.11 128.62,47.9 128.62,47.39 128.43,47.2 128.11,47.2 UC1.D47
  TOP w0.305: 128.83,48.41 128.83,48.52 130.02,49.71 RC12.1
DDR_COMP_1: length 5.4
  TOP w0.127: UC1.E46 128.28,46.57 128.65,46.57 129.04,46.96 129.26,46.96 129.39,47.1 129.39,48.2 129.61,48.41 129.89,48.41
  TOP w0.305: RC13.1 130.65,49.17 129.89,48.41
DDR_COMP_2: length 4.4
  TOP w0.127: 128.22,48.41 128.22,47.85 127.99,47.63 127.99,47.51 127.31,46.83 UC1.C47
  TOP w0.305: 128.22,48.41 128.22,48.77 129.26,49.81 RC14.1
DDR_D_CA0: length 43
  IN1 w0.099: v1(111.22,63.81) 110.95,63.81 110.91,63.77 110.91,61.86 v2(110.68,61.63) 110.98,61.33 110.98,60.86 110.91,60.8 110.91,59.57 v1(111.22,59.26) ; v1(135.63,43.61) v2(135.29,43.85)
  IN3 w0.099: v2(110.68,61.63) 110.71,61.6 111.77,61.6 111.96,61.79 112.18,61.79 112.48,62.09 112.78,62.09 113.82,63.13 115.17,63.13 115.38,62.91 116.32,62.91 117.72,61.51 117.72,60.44 117.63,60.35 117.63,56.87 118.42,56.08 118.42,55.62 118.7,55.35 119.95,55.35 124.47,50.82 129.6,50.82 132.9,47.52 132.9,46.27 133.95,45.22 133.95,44.83 134.31,44.47 134.49,44.47 135.11,43.85 v2(135.29,43.85)
DDR_D_CA1: length 41.6
  IN1 w0.099: v1(111.22,63.16) 111.23,63.16 111.67,63.16 111.77,63.05 111.77,62.91 111.67,62.81 111.57,62.81 111.47,62.71 111.47,62.55 111.57,62.45 111.71,62.45 111.84,62.33 111.84,62.15 111.74,62.05 v2(111.64,62.05) 111.64,61.72 111.56,60.82 111.48,60.49 111.33,60.34 111.22,59.92 v1(111.22,59.91) ; v1(135.63,44.26) v2(135.32,44.36)
  IN3 w0.099: v2(111.64,62.05) 111.25,62.05 111.15,62.15 111.15,62.68 111.29,62.81 113.07,62.81 113.62,63.36 115.27,63.36 115.49,63.15 116.42,63.15 117.96,61.61 117.96,60.53 118.48,60.01 118.48,58.69 119.13,58.05 119.13,56.52 124.58,51.07 129.7,51.07 133.14,47.64 133.14,46.4 133.5,46.04 134.25,46.04 134.71,45.57 134.71,44.74 135.1,44.36 v2(135.32,44.36)
DDR_D_CA2: length 41.9
  IN1 w0.099: v1(116.82,59.26) 117.02,59.26 117.13,59.37 117.13,60.43 117.52,60.82 117.52,61.17 v2(117.18,61.52) 116.71,61.98 116.71,62.65 117.1,63.04 117.1,63.6 116.89,63.81 v1(116.82,63.81) ; v1(134.72,43.61) v2(134.22,43.91)
  IN3 w0.099: v2(134.22,43.91) 133.71,44.42 133.71,45.12 132.66,46.17 132.66,47.4 129.49,50.57 123.12,50.57 122.53,51.16 122.53,51.3 122.97,51.74 122.97,51.88 122.83,52.02 122.69,52.02 122.25,51.58 122.11,51.58 121.97,51.72 121.97,51.86 122.41,52.3 122.41,52.44 122.27,52.58 122.13,52.58 121.69,52.14 121.55,52.14 121.41,52.28 121.41,52.42 121.85,52.86 121.85,53 121.71,53.14 121.57,53.14 121.13,52.7 120.99,52.7 120.85,52.84 120.85,52.98 121.29,53.42 121.29,53.56 121.15,53.7 121.01,53.7 120.56,53.26 120.42,53.26 120.2,53.48 120.2,53.62 120.55,53.97 120.55,54.11 120.41,54.25 120.27,54.25 119.92,53.9 119.78,53.9 118.08,55.6 118.08,55.88 116.89,57.07 116.89,60.23 117.49,60.82 117.49,61.21 v2(117.18,61.52)
DDR_D_CA3: length 41.8
  TOP w0.089: UC1.V47 134.54,46.96 v1(134.5,47)
  IN1 w0.081: v2(134.28,46.68) 134.32,46.7 134.45,46.99 v1(134.5,47)
  IN1 w0.099: v1(117.62,63.81) 117.43,63.81 117.37,63.75 117.37,62.93 117.01,62.57 117.01,62.13 117.29,61.85 117.67,61.85 v2(117.95,62.12) 117.95,61.14 117.85,61.05 117.85,60.7 117.37,60.22 117.37,59.51 v1(117.62,59.26)
  IN3 w0.099: v2(117.95,62.12) 118.05,62.12 118.25,61.92 118.25,60.64 118.56,60.32 118.7,60.32 119.17,60.79 119.31,60.79 119.45,60.65 119.45,60.51 118.98,60.04 118.98,59.9 119.24,59.64 119.24,58.91 119.45,58.71 119.54,58.71 119.64,58.61 119.64,58.41 119.54,58.31 119.47,58.31 119.37,58.21 119.37,57.58 119.46,57.49 119.57,57.49 119.68,57.6 119.83,57.6 119.96,57.46 119.96,57.32 119.85,57.21 119.85,56.42 120.21,56.07 120.42,56.07 120.79,56.44 120.93,56.44 121.07,56.3 121.07,56.16 120.7,55.79 120.7,55.64 120.84,55.5 120.98,55.5 121.35,55.88 121.5,55.88 121.64,55.74 121.64,55.6 121.26,55.22 121.26,55.08 121.4,54.94 121.54,54.94 121.92,55.32 122.06,55.32 122.2,55.18 122.2,55.04 121.82,54.66 121.82,54.52 121.96,54.38 122.1,54.38 122.48,54.76 122.62,54.76 122.76,54.62 122.76,54.48 122.38,54.1 122.38,53.96 122.59,53.75 122.73,53.75 123.05,54.07 123.19,54.07 123.33,53.93 123.33,53.79 123.01,53.47 123.01,53.33 123.16,53.19 123.3,53.19 123.61,53.51 123.75,53.51 123.89,53.37 123.89,53.23 123.58,52.91 123.58,52.77 125.02,51.32 129.8,51.32 133.39,47.74 133.39,47.24 133.94,46.68 v2(134.28,46.68)

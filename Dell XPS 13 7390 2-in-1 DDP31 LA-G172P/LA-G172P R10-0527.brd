# Allegro board LA-G172P R10-0527.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V3.3A_CPU_NOA_LA_VAL: length 2.8
  BOTTOM w0.081: JMIPI60.52 122.5,4.63 122.97,4.16 R138.2
VCC1P8A_EN: length 2.9
  TOP w0.081: UC22.4 149.15,16.18 RC226.2 148.81,15.76 v3(148.81,14.71)
VCC_SFR_OC_EN: length 2.2
  TOP w0.081: UC27.4 108.89,49.59 108.94,49.63 RC640.2 109.53,49.35 v3(110.14,48.74)
VCCDSW_EN: length 40.4
  TOP w0.081: CE108.1 211.65,54.14 v5(211.65,54.66) 211.55,54.76 211.55,56.81 UE1.M7 ; v5(177.2,53.5) 177.39,53.69 RC697.1
  IN2 w0.051: v5(211.65,54.66) 210.84,53.85 205.53,53.85 205.25,53.57 202.83,53.57 202.79,53.61 200.43,53.61 200.18,53.36 200.15,53.39 197.06,53.39 196.7,53.75 195.29,53.75 195.11,53.57 193.11,53.57 192.78,53.24 191.69,53.24 191.51,53.05 191.14,52.68 178.47,52.68 177.65,53.5 v5(177.2,53.5)
  BOTTOM w0.081: v5(211.65,54.66) v3(212.05,54.26)
VCCDSW_EN_GPIO: length 109.8
  TOP w0.081: v1(193.57,54.41) 193.42,54.55 180.15,54.55 179.29,53.69 DC1.2 179.25,53.69 RC697.2 ; v1(205.14,9.71) RC657.1 RC651.1 R374.2
  IN1 w0.064: v1(193.57,54.41) 193.57,53.27 193.67,53.17 v2(193.67,52.58) ; v1(205.14,9.71) 205.16,9.71 205.8,10.35 206.94,10.35 v2(207.39,9.9)
  IN2 w0.051: v2(207.16,51.86) 205.82,51.86 205.19,52.5 204.1,52.5 203.89,52.29 200.18,52.29 199.83,52.63 196.74,52.63 196.39,52.98 195.61,52.98 195.43,52.81 193.9,52.81 v2(193.67,52.58)
  IN3 w0.064: v4(208.55,10.39) 207.87,10.39 v2(207.39,9.9) ; v4(219.2,28.96) 220.54,30.3 220.54,34.88 219.12,36.3 216.5,36.3 214.73,38.07 214.73,45.03 216.97,47.27 216.97,51.08 216.72,51.33 213.26,51.33 212.42,52.17 210.75,52.17 209.72,51.14 207.88,51.14 v2(207.16,51.86)
  BOTTOM w0.081: v4(219.2,28.96) 223.84,24.32 v6(223.84,20.67) 223.55,20.39 223.55,16.1 221.94,14.49 215.01,14.49 214.27,13.76 214.27,11.53 213.84,11.1 209.27,11.1 v4(208.55,10.39)
VCCDSW_EN_Q: length 3.1
  TOP w0.081: DC2.2 180.56,51.96 DC1.1 178.99,52.26 RC698.1
VCCF_I: length 5.9
  TOP w0.081: TP76.1 207.8,26.64 206.14,28.31 205.62,28.31 203.86,30.07 USSD1.AC13
VCCFQ_I: length 8.1
  TOP w0.081: USSD1.AB13 203.5,30.69 205.7,28.49 207.75,28.49 209.39,26.85 TP77.1
VCCIN_AUX_CORE_VID: length 5.2
  TOP w0.081: RC624.2 183.39,39.85 v3(183.67,39.56) 183.87,39.37 183.87,37.44 184.12,37.18 UC9.2 RC735.1
VCCIN_AUX_VCCSENSE: length 21.9
  TOP w0.254: PR915.2 141.45,14.53 141.45,14.9 v1(141.96,15.4) 143.16,16.61 144.69,16.61 146.08,18.01 RC685.1
  IN1 w0.254: v1(155.35,15.49) 155.32,15.53 154.66,15.53 153.73,14.61 145.04,14.61 144.23,15.42 141.97,15.42 v1(141.96,15.4)
VCCIN_AUX_VCCSENSE_R: length 13.8
  TOP w0.254: RC685.2 146.08,20.23 145.93,20.38 145.93,20.73 145.93,20.73 v1(145.93,21.11)
  IN1 w0.254: v1(148.44,28.18) 144.56,28.18 143.41,27.03 143.41,23.63 v1(145.93,21.11)
VCCIN_AUX_VCCSENSE_VR: length 1.5
  TOP w0.203: PR915.1 141.57,13.12 142.06,12.63 PU900.16
VCCIN_AUX_VR_PG: length 137.3
  TOP w0.081: v1(142.87,7.04) 142.91,7.09 PU900.9
  IN1 w0.064: v2(203.55,52.93) 203.42,52.81 v1(203.21,52.81) ; v1(142.87,7.04) v2(142.87,6.71) ; v2(207.08,28.91) 207.41,29.23 207.9,29.23 208.15,29.48 208.15,29.96 207.02,31.09 207.02,32.75 206.91,32.86 206.91,38.44 209.65,41.18 211.89,41.18 212.42,41.72 212.42,45.39 211.84,45.97 211.84,49.33 212.48,49.98 212.48,53.24 v2(212.56,53.32) 212.77,53.53 v1(212.95,53.53)
  IN2 w0.051: v2(203.55,52.93) 203.58,52.96 205.29,52.96 205.72,53.39 212.49,53.39 v2(212.56,53.32) ; v2(142.87,6.71) 142.87,6.71 144.07,5.51 152.87,5.51 154.38,4 173.4,4 174.77,5.37 177.36,5.37 177.64,5.65 177.64,6.41 176.99,7.06 176.99,9.61 170.94,15.67 170.94,17.89 171.18,18.13 172.31,18.13 172.54,17.91 172.54,17.44 173.25,16.72 174.84,16.72 176.59,18.48 188.79,18.48 192.31,21.99 192.31,22.36 192.09,22.58 191.68,22.58 191.53,22.73 v2(191.53,22.74)
  IN3 w0.064: v2(191.53,22.74) 191.53,22.99 192.29,23.75 192.29,23.88 196.53,28.12 202.04,28.12 202.21,28.29 206.42,28.29 207.04,28.91 v2(207.08,28.91)
VCCIN_AUX_VSSSENSE: length 22.4
  TOP w0.254: RC686.1 145.51,18.26 144.43,17.18 142.97,17.18 v1(141.48,15.69) 140.94,15.15 140.94,14.53 PR916.2
  IN1 w0.254: v1(155.35,16.1) 155.29,16.04 154.44,16.04 153.52,15.11 145.25,15.11 144.44,15.92 141.71,15.92 v1(141.48,15.69)
VCCIN_AUX_VSSSENSE_R: length 13.8
  TOP w0.254: UC1.BD9 v1(147.52,28.56) ; v1(145.51,21.01) RC686.2
  IN1 w0.254: v1(145.51,21.01) 143.04,23.48 143.04,27.21 144.39,28.56 v1(147.52,28.56)
VCCIN_AUX_VSSSENSE_VR: length 1.7
  TOP w0.203: PU900.17 141.66,12.5 140.81,13.35 PR916.1
VCCIN_SENSE: length 39.2
  TOP w0.254: PR1122.1 102.34,42.9 103.11,43.66 109.16,43.66 v5(110.7,42.12) 111.27,41.55 121.5,41.55 122.31,40.74 PR1119.2
  BOTTOM w0.254: v5(110.7,42.12) 111.59,41.24 123.53,41.24 123.9,40.86 123.9,39.96 124.34,39.52 RC683.2
VCCIN_SENSE_R: length 8.3
  IN1 w0.254: v1(128.65,32.33) 128.34,32.64 v2(128.34,32.84)
  IN3 w0.254: v2(128.34,32.84) 128.34,33.35 124.54,37.14 v4(124.54,38.93)
VCCIN_SENSE_VR: length 2.8
  TOP w0.203: PU1100.6 99.21,44.3 99.33,44.17 99.33,43.23 99.66,42.9 PR1122.2
VCCK_I: length 6.2
  TOP w0.081: TP86.1 206.08,50.2 206.08,46.69 USSD1.C17
VCCST_EN: length 88.2
  TOP w0.081: v1(140.08,15.16) 137.99,15.16 137.72,15.43 UC13.4 ; v5(183.99,28.91) 184.03,28.94 184.03,29.59 184.82,30.38 184.82,31.15 183.68,32.29 183.68,32.99 183.2,33.46 183.2,34.76 183.49,35.05 184.47,35.05 184.87,35.45 184.87,35.57 185.56,36.27 185.56,37.24 185.77,37.44 RC627.2
  IN1 w0.064: v2(143.99,6.27) 143.82,6.44 143.82,7.56 143.12,8.25 143.12,12.76 140.72,15.16 v1(140.08,15.16)
  IN2 w0.051: v5(183.99,28.91) 183.69,28.6 182.79,28.6 182.48,28.28 181.5,28.28 179.8,26.58 179.8,23.34 178.47,22.01 172.79,22.01 170.17,19.39 170.17,15.35 171.77,13.75 171.77,6.76 170.02,5.01 153.58,5.01 152.93,5.66 144.6,5.66 v2(143.99,6.27)
  BOTTOM w0.081: v5(183.99,28.91) v3(184.92,28.91)
VCCST_OVERRIDE: length 55.5
  TOP w0.081: v1(157.31,23.02) 157.9,23.61 157.9,24.87 158.08,25.06 158.08,25.3 157.79,25.6 UC1.CE4 ; v1(180.69,12.1) 180.69,13 181.31,13.62 183.85,13.62 186.27,16.04 186.27,16.96 187.96,18.65 189.48,18.65 190.55,19.72 190.55,22.02 v3(190.01,22.56) 189.6,22.56 186.62,25.54 RH584.1
  IN1 w0.064: v1(157.31,23.02) 157.31,23.01 157.19,22.9 157.19,21.69 157.01,21.5 157.01,20.13 158.96,18.18 160.56,18.18 161.92,16.82 163.04,16.82 166.16,13.7 168.08,13.7 169.09,12.69 172.78,12.69 173.37,12.1 v1(180.69,12.1)
VCCST_OVERRIDE_R: length 5.3
  TOP w0.081: RC615.1 185.86,27.53 QM1.5 187.36,27.53 187.56,27.33 187.56,26.63 187.89,26.3 RH586.2 RH584.2 187.21,25.62 v3(187.88,24.94)
VCCST_PWRGD: length 5.5
  TOP w0.081: UE8.4 171.59,20.56 171.36,20.8 RH587.2 CC649.1 RH588.1 170.82,19.48 RC647.1 169.9,18.55 169.9,17.5 v3(170.02,17.37)
VCCST_PWRGD_CPU: length 17.9
  TOP w0.081: RH587.1 169.83,21.21 169.83,22.52 169.77,22.58 ; UC1.CF2 158.08,24.59 158.08,23.42 157.67,23 v1(157.66,23)
  TOP w0.089: 169.77,22.58 169.53,22.82 v5(168.87,22.82)
  IN1 w0.064: v1(157.66,23) 157.53,22.87 v2(157.53,22.56)
  IN3 w0.064: v2(157.53,22.56) 157.97,22.11 168.16,22.11 v5(168.87,22.82)
  BOTTOM w0.081: v3(169.23,23.18) v5(168.87,22.82)
VCCSTG_EN: length 145
  TOP w0.081: RC640.1 110.12,50.09 v5(109.44,50.76) ; UC12.4 133.73,19.56 134.66,20.49 141.15,20.49 v1(141.35,20.29) ; v1(152.78,17.75) 153.22,17.75 RC634.2 RC636.2
  IN1 w0.064: v2(152.21,17.34) 152.62,17.75 v1(152.78,17.75) ; v1(141.35,20.29) 141.49,20.43 v2(145.82,20.43)
  IN2 w0.051: v5(104.45,4.57) 104.65,4.37 106.92,4.37 107.34,3.95 108.93,3.95 109.64,4.66 112.69,4.66 114.33,6.3 114.33,9.63 116.42,11.71 130.67,11.71 135.96,17 135.96,20.64 136.35,21.02 138.43,21.02 138.58,20.88 145.37,20.88 v2(145.82,20.43)
  IN3 w0.064: v2(152.21,17.34) 151.76,17.79 151.65,17.79 150.74,18.7 150.74,19.03 150.19,19.58 149.86,19.58 149.39,20.05 146.2,20.05 v2(145.82,20.43)
  BOTTOM w0.081: v5(104.45,4.57) 104.45,5.2 105.94,6.69 105.94,9.68 105.57,10.06 105.57,17.5 106.74,18.67 106.74,24.26 103.83,27.17 99.9,27.17 94.22,32.85 94.22,41.59 95.7,43.07 100.65,43.07 105.51,47.93 v3(105.51,48.8) 105.51,50.68 105.59,50.76 v5(109.44,50.76)
VCCSTG_EN_MIPI: length 2.3
  TOP w0.081: v3(153.64,16.36) 153.84,16.56 153.84,17.13 RC634.1 153.57,17.52 UC11.4
VCCSTG_EN_R: length 3.8
  TOP w0.081: UC10.4 152.45,19.31 v3(152.69,19.55) 153.27,19.55 RC636.1 153.85,19.66 RC701.1 154.41,19.55 UC11.3
VCCSTPWRGOOD_TCSS: length 54.4
  TOP w0.081: v1(181.06,12.1) 181.06,13.11 181.39,13.44 183.93,13.44 186.45,15.96 186.45,16.88 188.04,18.47 189.56,18.47 190.73,19.64 190.73,23.69 v3(189.85,24.57) RH586.1 ; UC1.CE3 157.71,25.11 157.71,23.81 v1(157.31,23.4)
  IN1 w0.064: v1(157.31,23.4) 157.31,23.39 157.03,23.11 157.03,21.76 156.84,21.57 156.84,20.06 158.89,18.02 160.49,18.02 161.85,16.65 162.97,16.65 166.09,13.53 168.01,13.53 169.02,12.52 172.72,12.52 173.4,11.83 180.8,11.83 v1(181.06,12.1)
VDD: length 33.1
  TOP w0.203: v1(81.36,15.22) 81.36,13.88 PC229.2
  TOP w0.254: PR219.1 84.03,10.59 84.3,10.32 84.42,10.32 84.68,10.07 v1(84.68,9.38) ; v5(80.31,22.83) 80.49,22.66 PR207.2
  IN1 w0.254: v5(80.31,22.83) 82.07,22.83 83,21.91 83,19.82 82.52,19.34 81.57,19.34 80.77,18.54 80.77,15.81 v1(81.36,15.22) ; v2(84.42,9.61) 84.46,9.61 v1(84.68,9.38)
  IN2 w0.254: v5(80.31,22.83) 82.39,22.83 84.79,20.43 84.79,12.02 84.42,11.64 v2(84.42,9.61)
  BOTTOM w0.081: v5(80.31,22.83) v6(80.31,23.39)
VDD18: length 1.7
  TOP w0.203: PU1100.11 100.92,47.36 101.26,47.02 PC1108.1
VDD_I: length 5
  TOP w0.081: TP78.1 210.05,31.62 208.5,30.07 USSD1.AC18
VDDQ_I: length 5.5
  TOP w0.081: USSD1.C16 205.9,51.35 TP79.1
VIN_AUX:
  vias: v1(130.97,8.04) v1(131.41,8.04) v1(131.86,8.04) v1(132.3,8.04) v1(133.51,8.74) v1(133.95,8.74) v1(134.4,8.74) v1(134.84,8.74) v1(135.54,10.13) v1(135.99,10.13) v1(136.43,10.13) v1(136.88,10.13) v5(138.72,9.88) v5(139.16,10.26) v5(139.61,9.82) v5(140.24,10.77) v5(140.24,9.82) v5(140.88,10.77) v5(140.88,9.82) v5(141.51,10.77) v5(141.51,9.82) v6(133.32,11.53)
VSSIN_SENSE: length 38.3
  TOP w0.254: PR1126.2 122.4,41.38 121.71,42.06 111.68,42.06 v5(111.16,42.58) 109.57,44.17 102.83,44.17 102.08,43.42 101.22,43.42 100.97,43.66 PR1124.1
  BOTTOM w0.254: RC684.2 124.54,41.24 124.04,41.74 112,41.74 v5(111.16,42.58)
VSSIN_SENSE_R: length 9.8
  IN1 w0.254: v2(129.28,32.79) v1(129.28,32.33)
  IN3 w0.254: v4(125.1,38.84) 125.1,37.3 129.03,33.37 129.03,33.04 v2(129.28,32.79)
  BOTTOM w0.254: RC684.1 124.68,40.13 125.1,39.71 v4(125.1,38.84)
VSSIN_SENSE_VR: length 1.7
  TOP w0.203: PU1100.7 99.61,44.67 99.84,44.44 PR1124.2
3.3_VCCST_OVERRIDE: length 7.8
  TOP w0.081: RC617.2 187.26,31.6 187.26,30.29 187.04,30.07 UC7.2 186.15,30.07 185.32,29.24 185.32,27.15 v3(185.77,26.71) 185.95,26.88 QM1.6
32KHZ_OUT: length 10.5
  TOP w0.081: UE1.F3 208.38,61.65 207.61,61.65 207.41,61.85 207.41,62.14 207.13,62.42 206.17,62.42 205.18,63.41 203.55,63.41 203.26,63.12 202.88,63.12 202.69,62.93 202.69,62.66 CE105.1 202.1,62.07 201.67,61.64 v3(200.12,61.64)
+BATT:
  vias: v5(48.76,5.69) v5(49.16,6.1) v5(49.19,5.24) v5(49.53,6.55) v5(49.55,4.78) v5(50.07,6.75) v5(50.11,4.65) v5(50.64,6.63) v5(50.72,4.77) v5(51.23,5.68) v5(51.65,6.45) v5(51.65,7.24) v5(51.73,5.01) v5(52.03,4.25) v5(52.18,5.71) v5(52.42,7.23) v5(52.44,6.45) v5(52.76,5.1) v5(53.04,4.3) v5(53.84,4.67) v5(101.14,22.15) v5(101.57,22.6) v5(101.56,21.74) v5(102.14,22.39) v5(102.14,21.82) v5(102.46,22.96) v5(102.72,22.4) v5(102.72,21.83) v5(102.72,21.27) v5(102.72,20.69) v5(103.03,22.96) v5(103.28,22.4) v5(103.28,21.83) v5(103.28,21.27) v5(103.28,20.69) v5(103.6,22.96) v5(103.84,22.4) v5(103.84,21.83) v5(103.84,21.27) v5(103.84,20.69) v6(76.74,12.93) v6(94.14,20.29) v6(99.98,3.97)
+CAM_PWR: length 1
  BOTTOM w0.102: v5(168.32,83.04) 167.98,83.38 v6(167.46,83.38)
  vias: v1(167.53,79.25) v1(169.58,72.36) v1(169.9,72.36) v1(170.21,72.36) v5(168.89,83.04) v6(168.12,81.03) v6(168.99,82.5)
+CHG_VIN_20V:
  vias: v1(10.89,14.53) v1(11.15,14.77) v1(11.15,14.32) v1(11.34,14.01) v1(11.4,14.58) v1(11.53,14.2) v1(11.72,14.39) v1(275.86,11.33) v1(276.18,11.33) v2(10.19,13.24) v2(10.34,13.9) v2(10.63,13.53) v2(10.61,12.99) v2(10.76,14.07) v2(11.15,13.5) v2(11.15,12.99) v2(276.44,11.58) v2(276.44,11.01) v5(32.87,4.94) v5(32.87,4.37) v5(32.87,3.8) v5(32.9,3.22) v5(33.4,5.32) v5(33.4,4.75) v5(33.4,4.18) v5(33.4,3.61) v5(74.54,7.76) v5(74.54,7.18) v5(75.12,7.76) v5(75.12,7.18) v5(75.65,7.44) v5(75.65,6.86) v5(76.23,7.44) v5(76.23,6.86) v5(129.45,4.19) v5(129.45,3.55) v5(130.02,4.19) v5(130.02,3.55) v5(130.59,4.19) v5(130.59,3.55) v5(131.16,4.19) v5(131.16,3.55) v5(131.73,4.19) v5(131.73,3.55) v5(132.3,4.19) v5(132.3,3.55) v5(147.37,4.53) v5(147.92,4.53) v5(148.51,4.53) v5(149.07,4.55) v5(149.63,4.55) v5(150.21,4.55) v5(175.36,5.01) v5(175.36,4.43) v5(175.91,5.01) v5(175.91,4.43) v5(176.5,5.01) v5(176.5,4.43) v5(197.66,4.01) v5(197.66,3.43) v5(198.22,4.01) v5(198.22,3.43) v5(198.8,4.01) v5(198.8,3.43) v5(276.94,12.41) v5(276.94,11.84) v5(276.94,11.27) v5(277.45,12.09) v5(277.45,11.52) v6(134.27,3.59) v6(173.39,3.34) v6(196.31,4.35)
+EC_DEBUG_VCC: length 2.9
  TOP w0.127: v6(229.71,1.37) 229.52,1.56 RE200.1
  TOP w0.254: JDEG1.1 230.04,3.31 229.52,2.79 RE200.1
+INV_PWR_SRC: length 42.7
  IN1 w0.254: v5(125.46,82.36) 125.13,82.03 125.13,81.28 126.33,80.08 v1(126.33,79.34)
  IN1 w1.524: 100.78,66.89 103.05,66.89 104.06,67.89 104.06,69.2 103.46,69.8
  IN2 w1.524: 101.86,72.68 99.47,72.68 98.39,71.6 ; 103.68,72.83 104.98,74.14 119.64,74.14 122.75,77.25 122.75,78.99 124.99,81.23
  BOTTOM w0.102: v6(125.45,84.48) 125.45,83.22 v5(125.74,82.93) ; v6(124.54,82.84) 124.54,83.49 v6(123.69,84.34)
  vias: v1(91.23,67.04) v1(91.22,66.66) v1(91.54,67.04) v1(91.52,66.66) v1(99.04,66.98) v1(99.04,66.68) v1(99.34,66.98) v1(99.34,66.68) v2(102.77,71.14) v2(103,70.76) v2(103.25,71.13) v5(97.51,70.46) v5(98.08,70.46) v5(98.65,70.46) v5(125.17,82.93)
+INV_PWR_SRC_R: length 1.4
  TOP w0.081: Q15.6 102.88,66.41 v3(103.64,66.41)
+LCDVDD: length 25.8
  IN1 w0.254: v2(124.73,77.46) 124.75,77.47 124.75,78.29 v1(125.19,78.74)
  IN2 w1.016: 124.3,76.62 124.06,76.62 120.21,72.76 107.69,72.76 107.03,72.11
  BOTTOM w0.102: v4(124.35,77.19) 124.62,76.92 125.23,76.92 125.65,76.49 v6(125.65,75.65) ; R658.1 123.98,75.94 v6(123.97,75.93)
  BOTTOM w0.127: DV12.2 v6(129.55,84.94)
  vias: v1(106.2,70.97) v1(106.71,70.97) v2(106.24,71.35) v2(106.75,71.35) v2(124.73,77.01) v4(124.38,77.48) v5(126.92,82.64) v5(127.49,82.64)
+PECI_VREF: length 2.5
  TOP w0.254: v5(215.5,59.91) 215.15,59.56 UE1.J11
  BOTTOM w0.102: v5(215.5,59.91) v3(215.5,60.55)
  BOTTOM w0.254: v5(215.5,59.91) 215.16,59.57 CE56.1 RE147.1
+RTC_CELL_VBAT: length 0.8
  TOP w0.254: v5(208.25,66.66) 207.9,66.3 UE1.A2
  vias: v3(207.86,67.07)
+RTCBATT: length 19.3
  TOP w0.102: 52.12,11.17 52.1,11.17 51.7,10.77 51.7,9.37 v3(52.18,8.89)
  TOP w0.508: QRTC1.2 37.4,11.39 v1(37.4,10.9)
  IN1 w0.508: v1(37.4,10.9) 37.6,10.69 41.2,10.69 42.3,11.78 v1(51.79,11.78)
+RTCVCC: length 95
  TOP w0.508: v1(189.17,19.23) 189.12,19.28 187.77,19.28 185.69,17.2 185.69,16.28 183.61,14.2 182.52,14.2 182.01,14.71 R5768.1 C1040.1 180.84,15.21 Q349.1 179.05,13.42 R2751.1
  IN1 w0.508: v2(193.63,22.19) 193.63,20.84 191.88,19.09 189.31,19.09 v1(189.17,19.23)
  IN2 w0.508: v2(182.86,30.39) 183.9,30.39 184.26,30.02 185.15,30.02 186.49,28.68 186.49,27.49 190.25,23.73 193.12,23.73 193.63,23.22 v2(193.63,22.19)
  IN3 w0.508: v4(188.06,50.77) 188.06,50.39 189.82,48.63 189.82,47.19 190.62,46.39 190.62,42.32 187.55,39.24 187.55,35.87 186.92,35.24 184.03,35.24 183.46,34.67 183.46,33.72 184.09,33.08 184.09,32.4 183.99,32.3 182.86,31.17 v2(182.86,30.39)
  BOTTOM w0.508: RC696.2 179.12,40.66 178.83,40.95 178.83,41.58 177.72,42.69 177.72,45.99 176.97,46.75 176.97,47.39 ; 176.97,47.39 176.97,48.96 182.18,54.17 185.59,54.17 188.06,51.71 v4(188.06,50.77) ; 176.97,47.39 176.22,47.39 v3(175.17,46.33) RH64.2
+RTCVCC_R: length 293.6
  TOP w0.356: RH572.1 179.47,50.96 179.92,50.51 180.76,50.51 181.64,51.4 v1(181.64,53) ; RE184.1 v5(201.09,64.49)
  TOP w0.508: RTCR1.1 51.25,13.07 RTCD6.1 RTCD4.1 50.1,9.85 v1(50.83,9.12)
  IN1 w0.508: v5(210.34,69.91) 210.34,70.65 208.82,72.17 205.08,72.17 204.57,71.66 204.57,69.54 203.02,67.99 202.32,67.99 202.01,67.69 202.01,66.89 201.09,65.96 v5(201.09,64.49) 201.52,64.06 201.52,63.41 202.67,62.25 202.67,58.25 202.04,57.62 202.04,54.89 202.01,54.85 v2(202.01,54.81) ; v2(181.28,53.75) 181.64,53.4 v1(181.64,53) ; v1(50.83,9.12) 54.96,9.12 59.41,4.67 v2(59.85,4.67)
  IN2 w0.508: v2(202.01,54.81) 201.64,54.44 199.81,54.44 198.82,55.43 194.46,55.43 193.95,54.93 193.28,54.93 192.43,54.07 191.35,54.07 191.16,53.89 190.99,53.72 181.32,53.72 v2(181.28,53.75) ; v5(177.22,5.83) 172.67,5.83 172.15,6.35 172.15,13.92 170.56,15.51 170.56,19.02 173.17,21.63 183.11,21.63 185.58,24.1 185.58,26.2 184.62,27.16 184.62,28.21 v2(184.88,28.47)
  IN3 w0.254: v4(180.65,54.22) 180.79,54.08 180.96,54.08 v2(181.28,53.75)
  IN3 w0.508: v2(59.85,4.67) 60.47,4.67 61.22,5.42 71.66,5.42 73.27,3.81 88.4,3.81 90.08,2.13 97.63,2.13 98.07,1.69 138.08,1.69 138.86,2.46 177.15,2.46 177.58,2.89 177.58,4.7 177.22,5.06 v5(177.22,5.83) ; v2(202.01,54.81) 201.2,54 199.72,54 198.98,53.26 197.54,53.26 195.99,51.71 195.05,51.71 193.58,50.25 193.58,45.99 193.55,45.96 193.55,36.65 191.97,35.06 191.97,33.07 187.37,28.47 v2(184.88,28.47)
  BOTTOM w0.356: RH573.1 169.9,50.82 170.25,51.18 v3(174.66,51.18) 177.6,51.18 v4(180.65,54.22)
  BOTTOM w0.508: v5(201.09,64.49) 204.14,64.49 204.56,64.91 205.95,64.91 206.43,65.39 RE106.1
+SD_VDD1: length 32.7
  IN2 w1.016: 283.05,44.05 276.44,44.05 274.58,45.91 274.58,50.38
  BOTTOM w1.016: 283.05,25.69 283.05,27.47 284.78,29.2 284.78,42.54 v6(284.33,42.99) 284.33,43.83
  vias: v1(279.81,23.78) v1(279.81,23.47) v2(283.18,23.34) v2(283.18,22.83) v2(284.13,44.38) v2(284.63,44.38) v4(282.99,24.67) v4(283.31,24.67) v4(284.12,44.82) v4(284.45,44.82) v5(274.25,51.71) v5(274.25,51.08)
+SD_VDD2: length 17.4
  IN3 w0.762: 285.74,38.33 285.47,38.61 285.47,40.71
  BOTTOM w0.762: 283.15,23.94 283.54,23.94 284.21,24.6 v6(284.21,26.07) 284.21,26.31 286.86,28.97 286.86,29.5 287.24,29.88 287.24,36.8 287.17,36.88
  vias: v1(280.31,23.9) v1(280.32,23.6) v1(288.96,40.27) v1(288.96,39.91) v1(290.07,44.61) v1(290.07,44.26) v1(290.35,42.39) v1(290.35,42.01) v2(282.36,23.9) v2(282.86,23.91) v2(284.86,41.35) v2(285.31,41.38) v4(282.23,24.23) v4(282.54,24.23) v4(286.23,37.82) v4(286.46,37.59)
+SSD_PWR2:
  vias: v6(185.14,13.5)
+SSD_PWR2P: length 15
  TOP w0.254: v1(195.13,4.72) PC1506.1 195.13,4.28 195.35,4.06 195.86,4.06 196.35,4.55 R1141.2
  IN1 w0.254: v1(195.13,4.72) 186.23,4.72 185.58,5.37 185.58,7.72 v1(186.15,8.29)
  vias: v6(182.4,7.85)
+SSD_PWR3:
  vias: v3(213.71,43.15)
+SSD_PWR3P: length 13.6
  TOP w0.127: 215.9,39.37 v6(213.34,39.37)
  IN1 w0.254: v1(212.16,28.28) 211.76,28.69 211.76,30.19 v1(212.24,30.67) 213.14,31.57 213.14,34.78 215.16,36.79 v1(216.14,36.79)
+SSD_PWR_3:
  vias: v5(198.3,43.27) v5(198.3,42.47) v5(198.3,41.67) v5(198.3,40.87) v5(203.1,43.27) v5(203.1,42.47) v5(203.1,41.67) v5(203.1,40.87) v5(210.28,46.01) v5(210.28,45.44) v5(210.85,46.01) v5(210.85,45.44) v6(199.87,41.63)
+SSD_PWR_3_R:
  vias: v3(215.81,46.52)
+TBT_VBUS_L:
  vias: v5(5.94,15.78) v5(5.94,15.22) v5(5.94,14.65) v5(6.51,15.78) v5(6.51,15.22) v5(6.51,14.65) v5(7.08,14.64) v5(8.53,63.86) v5(8.53,61.3) v5(9.34,54.99) v5(9.35,54.42) v5(9.34,53.85) v5(10.19,61.19) v5(10.26,63.73) v5(10.83,63.92) v5(10.76,61.19) v6(3.84,16.8) v6(5.87,13.94)
+TBT_VBUS_L_PD:
  vias: v1(4.48,18.77) v1(4.48,18.45) v1(4.8,18.77) v1(4.8,18.45) v1(6.22,17.4) v1(7.18,17.4) v1(9.94,18.81) v1(10.18,18.52) v1(13.75,14.9) v1(13.72,14.04) v1(13.88,14.51) v1(13.94,13.84) v1(14,15.15) v1(14.09,14.75) v1(14.13,14.26) v1(14.33,14.99) v1(14.34,14.5) v1(14.58,14.74) v5(7.03,18.67) v5(7.43,19.08) v5(7.43,18.27) v5(7.83,18.67) v5(7.83,17.87) v5(8.24,18.27) v5(9.52,18.6) v6(8.22,17.44)
+TBT_VBUS_R: length 3.6
  BOTTOM w0.102: v5(282.99,62.9) v6(282.99,63.47) ; v5(282.42,62.9) 282.42,62.08 v6(282.29,61.95) ; v6(280.77,62.65) 281.02,62.65 v5(281.27,62.9)
  BOTTOM w0.381: CT315.2 283.79,75.09 v5(284.28,75.09) ; CT316.2 284.18,72.62 v5(284.27,72.53)
  vias: v1(267.23,14.16) v1(267.23,13.85) v1(267.23,13.53) v1(267.61,14.16) v1(267.61,13.85) v1(267.61,13.53) v1(268.69,13.59) v1(269.07,13.59) v1(269.45,13.59) v1(270.47,13.59) v1(270.85,13.59) v1(271.23,13.59) v5(265.2,15.86) v5(265.52,16.43) v5(265.77,15.86) v5(266.09,16.43) v5(266.34,15.86) v5(266.66,16.43) v5(266.91,15.86) v5(281.78,72.49) v5(281.85,62.9) v5(282.04,74.78) v5(282.33,72.66) v5(282.49,75.16)
+TBT_VBUS_R_PD:
  vias: v1(268.69,15.29) v1(269.07,15.29) v1(269.45,15.29) v1(270.47,15.29) v1(270.85,15.29) v1(271.23,15.29) v1(276.37,16.22) v1(276.37,15.9) v1(276.37,15.58) v1(276.69,16.22) v1(276.69,15.9) v1(276.69,15.58) v1(277.01,15.9) v1(277.01,15.58) v1(276.98,10.45) v1(276.98,10.15) v1(277.71,10.31) v1(278.02,10.63) v1(278.02,10.31) v1(278.34,10.63) v1(278.34,10.31) v1(278.66,10.63) v1(278.66,10.31) v2(276.32,15.21) v2(276.58,14.77) v2(276.83,15.21) v2(277.08,14.77) v2(277.34,15.21) v2(277.4,15.72) v2(277.59,9.5) v2(277.65,14.77) v2(277.78,9.94) v2(278.1,9.5) v2(278.29,9.94) v2(278.54,11.02) v2(278.61,9.5) v2(278.8,9.94) v6(267.55,15.21)
+VNN_BYPASS: length 13.1
  IN1 w0.254: v1(165.16,40.36) 164.89,40.63 v2(164.88,40.63)
  IN3 w0.254: v4(165.24,40.44) 165.23,40.45 165.23,40.47 165.08,40.63 164.88,40.63 v2(164.88,40.63)
  BOTTOM w0.254: v4(165.24,40.44) 166.54,40.44 166.91,40.08 v3(167.71,40.08) 168.55,40.08 169.34,40.87 175.8,40.87 176.11,41.18 RC648.2
+VR_CAP: length 18.3
  TOP w0.127: v3(204.18,59.21) 204.78,58.61 204.78,58.45 v1(204.97,58.27)
  TOP w0.254: v1(204.97,58.27) 205.01,58.27 206,59.26 206.8,59.26 UE1.J1
  IN1 w0.254: v1(204.97,58.27) 204.97,58.6 205.07,58.7 205.07,60.67 v2(205.38,60.98) ; v2(214.19,64.05) 214.3,64.15 v1(214.3,64.36)
  IN2 w0.254: v2(214.19,64.05) 214.13,63.99 214.13,62.83 212.93,61.63 211,61.63 210.5,61.13 209.41,61.13 208.98,61.56 207.56,61.56 207.26,61.26 205.67,61.26 v2(205.38,60.98)
A#: length 5.8
  TOP w0.254: PU600.1 85.63,6.96 PD600.2 85.6,8.25 PD602.2 85.6,8.27 PD601.2 86.45,9.52 PR606.2 PR607.2
AC_DIS: length 179.3
  IN1 w0.064: v1(89.25,10.18) 88.36,10.18 v2(88.26,10.29) ; v1(215.9,60.36) 216.03,60.22 v2(216.03,59.94)
  IN2 w0.051: v2(88.26,10.29) 87.99,10.55 87.99,18.43 89.66,20.09 89.66,47.15 91.95,49.45 98.86,49.45 101.77,52.35 108.05,52.35 109.01,53.31 113.11,53.31 114.1,54.3 115.35,54.3 115.56,54.52 118.36,54.52 119.25,53.63 127.78,53.63 128.06,53.91 128.97,53.91 129.85,54.79 135.21,54.79 135.23,54.77 136.56,54.77 137.42,53.91 143.16,53.91 143.93,54.68 144.65,54.68 144.96,54.37 145.56,54.37 146.01,54.82 149.12,54.82 150.03,53.91 155.93,53.91 156.43,53.4 163.54,53.4 165.96,55.83 165.96,56.03 166.86,56.93 166.86,58.29 167.57,59 171.32,59 172.21,59.89 175.79,59.89 175.99,60.09 177.49,60.09 177.69,59.89 179.75,59.89 180.62,59.02 182.1,59.02 183.21,57.9 187.99,57.9 188.24,57.9 189.17,56.98 190.83,56.98 192.71,58.87 192.89,58.87 200.2,58.87 201.08,57.98 207.39,57.98 207.96,58.55 208.85,58.55 209.41,57.98 210.7,57.98 210.94,57.74 211.66,57.74 212.34,58.42 213.72,58.42 214.25,58.95 214.25,59.53 215.03,60.31 215.67,60.31 v2(216.03,59.94)
AC_DISC#: length 309.5
  TOP w0.081: v1(104.89,6.37) 104.82,6.37 v3(103.82,7.37) 102.48,8.71 95.4,8.71 94.86,9.24 PR100.2 ; UE1.E13 217.95,62.76 v1(218.23,62.48)
  IN1 w0.064: v2(268.74,9.98) 268.13,10.59 267.51,10.59 266.38,11.71 265.68,11.71 264.47,12.93 263.41,12.93 262.71,13.63 v2(262.71,15.32) ; v2(218.49,62.1) 218.49,62.23 v1(218.23,62.48) ; v1(104.89,6.37) v2(104.89,2.97)
  IN2 w0.051: v2(262.71,15.32) 262.71,15.01 261.93,14.23 258.88,14.23 257.84,13.19 249.32,13.19 249.18,13.05 230.06,13.05 223.01,20.11 223.01,23.15 222.56,23.59 222.56,24.78 221.49,25.86 220.97,25.86 220.73,26.1 220.73,26.75 221.69,27.71 221.69,37.41 220.95,38.16 220.95,42.45 220.05,43.36 220.05,44.79 220.95,45.69 220.95,54.53 219.9,55.58 219.9,60.68 v2(218.49,62.1) ; v2(268.74,9.98) 267.75,8.99 267.05,8.99 263.14,5.08 252.8,5.08 251.19,6.69 249.28,6.69 247.33,4.74 235.23,4.74 234.51,4.01 227.68,4.01 220.63,11.06 215.33,11.06 212.29,14.1 212.29,16.51 211.72,17.08 195.9,17.08 195.17,17.82 177.13,17.82 175.9,16.58 175.9,12.86 179.56,9.2 179.56,5.11 176.96,2.51 153.62,2.51 152.93,3.2 133.42,3.2 132.66,2.44 105.42,2.44 v2(104.89,2.97)
AC_PRESENT: length 58.7
  TOP w0.081: UE1.K8 213.01,58.44 v1(213.01,57.69) ; RH297.1 RH312.2 165.75,50.68 165.49,50.42 165.49,50.04 165.28,49.83 165.28,49.15 165.51,48.92 v1(165.59,48.92)
  IN1 w0.064: v1(213.01,57.69) 213.14,57.57 213.14,56.77 212.59,56.22 v2(212.59,55.71) ; v1(165.59,48.92) 165.37,48.92 v2(165.28,48.83)
  IN2 w0.051: v2(165.28,48.83) 165.29,48.84 165.32,48.84 165.45,48.72 166.15,48.72 167.52,50.09 171.72,50.09 175.9,54.27 180.5,54.27 180.52,54.29 190.81,54.29 190.94,54.42 190.94,54.42 191.13,54.61 192.21,54.61 193.5,55.9 194.8,55.9 194.84,55.87 201.7,55.87 202.66,54.9 202.95,54.9 203.36,54.49 203.36,54.16 203.5,54.02 205.06,54.02 205.34,54.3 210.08,54.3 211.48,55.71 v2(212.59,55.71)
AC_PRESENT_R: length 4.8
  TOP w0.081: UC1.DE46 167.43,46.51 166.97,46.96 166.74,46.96 166.55,47.15 166.55,48.34 165.58,49.32 165.58,49.78 RH312.1
ACAV_IN: length 198.7
  TOP w0.081: v6(88.85,13.88) 88.21,13.24 87.22,13.24 86.8,12.83 PR225.1
  TOP w0.254: v1(86.58,10) 86.58,10.6 PQ205.1 ; PQ205.1 85.47,11.06 85.37,10.96 PR219.2 ; PQ205.1 86.12,11.61 85.75,11.98 PR220.1 86.12,12.53 86.33,12.73 PR225.1
  IN1 w0.064: v1(211.9,64.36) v2(211.9,64.7)
  IN1 w0.254: v2(85.51,9.79) 85.66,9.64 86.21,9.64 86.57,10 v1(86.58,10)
  IN2 w0.051: v2(85.51,9.79) 86.48,10.76 86.48,20.09 88.73,22.34 88.73,48.37 90.72,50.36 96.9,50.36 97.33,50.78 97.33,62.34 98.05,63.07 102.57,63.07 103.3,63.8 103.3,67.77 104.75,69.22 108.09,69.22 109.21,70.34 125.91,70.34 126.08,70.17 135.53,70.17 136.37,69.33 138.47,69.33 139.01,69.87 143.54,69.87 144.35,69.05 149.29,69.05 149.59,69.35 154.18,69.35 155.24,70.41 160.38,70.41 160.96,69.83 163.66,69.83 164.44,69.05 167.36,69.05 172.33,64.07 175.19,64.07 175.51,64.38 177.71,64.38 178.43,63.67 189.35,63.67 189.79,64.11 193.31,64.11 193.85,63.56 194.75,62.66 197.74,62.66 198.1,62.3 203.14,62.3 205.29,64.45 206.96,64.45 v2(207.06,64.55) 207.3,64.55 208.57,65.82 210.96,65.82 211.68,65.1 211.68,64.92 v2(211.9,64.7)
  IN3 w0.064: v4(206.76,64.25) v2(207.06,64.55)
ACC1_INT1#: length 89.2
  TOP w0.081: JUFC1.29 156.3,83.66 155.28,82.64 v5(154.62,82.64) ; RC738.1 183.75,40.85 v1(183.56,40.85)
  IN1 w0.064: v5(154.62,82.64) 154.81,82.84 155.73,82.84 155.92,82.66 155.92,81.99 155.8,81.87 155.8,81.09 154.99,80.27 154.99,79.26 v1(155.77,78.48) ; v1(183.56,40.85) 180.27,40.85 179.37,41.76 175.02,41.76 174.51,41.24 v2(173.96,41.24) 173.56,41.24 v1(173.46,41.15)
  IN3 w0.064: v2(173.96,41.24) 172.57,42.63 171.32,42.63 171.01,42.32 170.56,42.32 170.28,42.04 168.24,42.04 168,42.28 168,42.84 167.67,43.17 167.67,43.6 167.46,43.81 166.28,43.81 166.02,44.06 166.02,46.68 166.34,47 166.34,47.41 168.27,49.35 168.27,49.8 169.26,50.79 173.11,50.79 174.29,51.96 174.29,53.07 175.02,53.8 175.02,55.62 173.26,57.38 172.6,57.38 170.81,59.18 170.81,63.17 170.12,63.86 170.12,66.5 167.07,69.56 166.49,70.13 166.49,72.03 166.09,72.43 165.68,72.43 162.72,75.39 160.5,75.39 160.13,75.02 159.24,75.02 158.87,75.39 157.58,75.39 157.45,75.26 v4(156.74,75.26)
  BOTTOM w0.081: v4(156.74,75.26) v3(154.31,77.69) 153.5,78.5 153.5,81.91 154.24,82.64 v5(154.62,82.64)
ACC1_INT2#: length 91.6
  TOP w0.081: JUFC1.30 155.9,83.72 155.38,83.2 v5(154.53,83.2) ; v3(184.17,43.65) 184.18,43.65 RC739.1 RC742.2 184.18,42.04 v1(183.94,41.79)
  IN1 w0.064: v2(173.84,40.75) 174.23,40.75 174.64,41.15 v1(174.76,41.15) 175.2,41.59 179.28,41.59 180.28,40.59 181.83,40.59 182.12,40.3 183.4,40.3 183.82,40.72 183.82,41.67 v1(183.94,41.79) ; v5(154.53,83.2) 154.72,83.01 155.8,83.01 156.08,82.73 156.08,81.92 155.97,81.81 155.97,80.89 156.35,80.51 156.35,80.04 v1(155.76,79.44)
  IN3 w0.064: v2(173.84,40.75) 173.06,40.75 172.62,41.19 172.62,42.2 172.35,42.48 171.38,42.48 171.07,42.17 170.63,42.17 170.34,41.88 167.64,41.88 165.83,43.69 165.83,46.71 166.17,47.05 166.17,47.48 168.11,49.42 168.11,49.86 169.19,50.95 173.04,50.95 174.12,52.03 174.12,53.14 174.85,53.87 174.85,55.56 173.19,57.22 172.53,57.22 170.64,59.11 170.64,63.1 169.95,63.78 169.95,66.44 166.9,69.49 166.33,70.06 166.33,71.96 166.02,72.26 165.62,72.26 162.66,75.22 160.57,75.22 160.2,74.85 159.17,74.85 158.8,75.22 157.77,75.22 157.42,74.88 156.64,74.88 v4(156.43,75.09)
  BOTTOM w0.081: v5(154.53,83.2) 153.32,81.99 153.32,78.2 156.43,75.09 v4(156.43,75.09)
ACC2_INT#: length 114
  TOP w0.081: JIO1.41 255.65,6.93 v5(255.3,7.28)
  TOP w0.089: v1(175.48,41.31) 175.01,41.31 174.91,41.41 174.38,41.41 UC1.DV36
  IN1 w0.064: v1(175.48,41.31) 175.67,41.31 176.07,40.92 176.74,40.92 177.06,40.6 177.58,40.6 178.42,39.76 178.42,39.3 178.78,38.94 179.46,38.94 180.44,39.92 181.24,39.92 181.49,39.67 181.49,38.99 181.71,38.77 181.99,38.77 182.15,38.61 182.15,37.91 181.88,37.63 181.12,37.63 v2(180.97,37.49)
  IN2 w0.051: v2(180.97,37.49) 181.66,36.8 185.27,36.8 190.85,31.22 190.85,28.56 191.02,28.4 207.89,28.4 208.6,27.68 209.86,27.68 211.06,26.49 211.06,24.85 212.34,23.57 212.34,22.41 211.87,21.94 211.87,20.34 215.67,16.54 215.67,15.99 218.54,13.12 221.44,13.12 228.44,6.12 231.58,6.12 231.9,6.44 232.56,6.44 233.94,7.82 247.46,7.82 248.31,8.67 248.52,8.88 252.17,8.88 253.77,7.28 v5(255.3,7.28)
  IN3 w0.064: v2(180.97,37.49) 180.97,36.83 v4(180.87,36.73)
  BOTTOM w0.081: v4(180.87,36.73) 182.71,36.73 v3(182.85,36.87) 183.13,37.15 RC740.1 RC743.2
ADCIN1_L_PD: length 6.4
  TOP w0.081: v3(10.29,13.53) 9.53,14.3 RPD92.2 9.5,14.77 RPD91.1 9.33,15.39 9.33,16.64 10.68,17.99 10.81,17.99 UPD1.6
ADCIN1_R_PD: length 5.5
  TOP w0.081: UPD2.6 277.61,14.15 277.45,13.99 v3(277.22,13.99) 277.05,14.15 275.07,14.15 274.28,13.36 RPD101.1 RPD102.2
ADCIN2_L_PD: length 3.7
  TOP w0.081: UPD1.10 11.62,16.53 11.62,16.47 10.63,15.48 10.23,15.48 RPD90.2 RPD100.1
ADCIN2_R_PD: length 6.6
  TOP w0.081: v1(276.89,8.39) RPD89.1 ; UPD2.10 v1(277.64,12.55)
  IN1 w0.064: v1(276.89,8.39) 276.83,8.46 276.83,9.18 276.58,9.43 276.58,9.88 276.7,10.01 276.7,10.64 276.83,10.77 277.4,10.77 277.9,11.26 277.9,12.3 v1(277.64,12.55)
ALLSYS_PWRGD: length 14.9
  TOP w0.081: D474.2 D475.2 ; D474.2 204.35,52.81 D438.2 202.79,54.08 202.5,53.78 RE464.1 RE457.1 ; D474.2 205.3,53.2 205.3,54.71 v5(205.56,54.96) 205.43,55.09 RE1.1 204.27,55.68 RE448.2 203.51,55.85 v3(203.38,55.98)
  BOTTOM w0.081: v5(205.56,54.96) 205.56,56.32 205.01,56.87 203.5,56.87 LED1.1
ALLSYS_PWRGD_R: length 3.2
  TOP w0.081: RE93.1 202.8,55.29 202.14,55.29 v3(202.14,55.29) 202.14,55.05 202.15,55.03 RE464.2 201.22,54.37 201.2,54.34 QE18.6
ALS_ALERT#: length 110.2
  IN1 w0.064: v2(195.88,68.09) 196.25,68.09 197.5,66.85 197.5,65.36 197.32,65.18 197.32,60.55 197.2,60.43 197.2,59.58 197.78,59 197.78,56.55 196.29,55.06 196.02,55.06 v2(195.6,54.64) ; v2(184.89,31.39) 184.11,31.39 183.81,31.09 183.62,31.09 183.36,30.84 183.36,30.08 182.23,28.94 180.16,28.94 177.73,31.36 174.16,31.36 v1(173.46,30.67)
  IN3 w0.064: v2(195.88,68.09) 195.31,67.52 190.31,67.52 189.57,68.26 179,68.26 178.03,69.23 176.09,69.23 175.72,69.6 175.72,70.31 170.92,75.11 170.92,77.97 167.33,81.56 158.81,81.56 v4(157.7,80.45) ; v2(184.89,31.39) 184.89,31.39 186.69,31.39 188.95,33.65 188.95,35.87 189.18,36.1 189.75,36.1 190.16,36.51 190.16,40.37 191.71,41.92 191.71,47.85 191.27,48.28 191.27,51.37 193.12,53.22 195.08,53.22 195.6,53.74 v2(195.6,54.64)
  BOTTOM w0.081: v3(155.9,81.58) 156.29,81.19 156.97,81.19 v4(157.7,80.45) R6157.1
ALS_ALERT#_R: length 8.2
  TOP w0.081: v5(156.69,81.66) 156.69,82.7 157.5,83.51 JUFC1.26
  IN1 w0.064: v1(157.03,77.57) 156.6,78 156.6,81.01 156.64,81.05 156.64,81.62 v5(156.69,81.66)
  BOTTOM w0.081: R6118.2 157.3,81.44 156.9,81.44 v5(156.69,81.66)
ALW_PWRGD_3V_5V: length 93.1
  TOP w0.081: v1(175.06,17.5) R6204.1 ; R6204.1 RC702.2 RC703.2 175.06,14.98 v3(175.33,14.72) ; R6204.1 174.91,16.86 174.78,17 174.53,17 174.38,16.84 174.38,16.72 174.26,16.6 UC2.2 ; D438.1 204.29,53.58 v1(204.08,53.58)
  IN1 w0.064: v1(204.08,53.58) 203.59,53.58 v2(202.77,54.41) ; v2(180.4,53.31) 180.4,53.49 v1(180.56,53.65) ; v1(175.06,17.5) 174.8,17.5 v2(174.74,17.44)
  IN2 w0.051: v2(174.74,17.44) 174.74,17.33 174.29,16.88 173.31,16.88 172.69,17.5 172.69,17.84 176.1,21.25 183.26,21.25 185.96,23.95 185.96,26.36 185.18,27.14 v2(185.18,27.91) ; v2(180.4,53.31) 180.7,53.01 191.04,53.01 191.2,53.17 191.38,53.35 191.57,53.54 192.65,53.54 193.49,54.38 194.29,54.38 194.39,54.48 195.02,54.48 195.44,54.06 196.82,54.06 197.19,53.69 200.09,53.69 200.3,53.91 201.86,53.91 202.36,54.41 v2(202.77,54.41)
  IN3 w0.064: v2(185.18,27.91) 185.47,27.91 185.5,27.94 187.77,27.94 190.91,31.09 192.18,31.09 192.44,31.34 192.44,32.04 192.35,32.12 192.35,34.9 193.94,36.49 193.94,45.8 193.97,45.83 193.97,50.09 195.16,51.28 196.1,51.28 197.7,52.87 199.14,52.87 199.88,53.61 201.57,53.61 202.36,54.41 v2(202.77,54.41)
ALWON: length 378.6
  TOP w0.081: RE417.1 263.75,11.65 262.18,11.65 261.84,11.99 261.84,19.91 v1(261.27,20.48) ; v5(210.85,66.65) 210.3,66.09 UE1.A5
  TOP w0.254: v5(87.19,58.9) RE312.1 87.16,58.27 RE305.1
  IN1 w0.064: v5(20.8,9.5) 21.05,9.24 21.05,4.55 22.07,3.53 23.53,3.53 24.8,2.26 26.39,2.26 26.97,2.84 v1(26.97,3.45) ; v2(102.78,64.26) 96.58,64.26 95.6,63.28 95.6,62.97 91.54,58.9 v5(87.19,58.9) ; v2(260.89,20.48) v1(261.27,20.48)
  IN2 w0.051: v2(229.43,23.23) 229.43,23.23 229.8,22.86 229.8,21.93 229.63,21.77 229.63,19.35 231.1,17.88 233.12,17.88 233.95,18.71 235.33,18.71 v2(235.49,18.87) ; v5(210.85,66.65) 210.82,66.65 210.67,66.8 208.9,66.8 207.5,65.4 205.52,65.4 203.03,62.91 198.35,62.91 197.99,63.27 195,63.27 193.85,64.43 193.71,64.56 189.38,64.56 189.1,64.28 178.46,64.28 177.77,64.97 175.44,64.97 175,64.53 172.52,64.53 165.31,71.74 160.35,71.74 159.48,70.88 155.06,70.88 153.99,69.81 149.37,69.81 149.07,69.51 144.54,69.51 143.72,70.33 138.82,70.33 138.28,69.79 136.56,69.79 135.72,70.63 126.27,70.63 126.09,70.8 109.02,70.8 107.9,69.68 104.56,69.68 103.64,68.76 102.94,68.76 101.99,67.81 101.99,65.05 v2(102.78,64.26)
  IN3 w0.064: v5(210.85,66.65) 213.96,66.65 215.42,68.11 217.53,68.11 219.91,65.73 219.91,63.48 220.45,62.94 220.45,61.18 221.09,60.54 221.09,47.65 217.37,43.93 217.37,40.36 217.84,39.89 217.84,38.77 218,38.61 220.08,38.61 222.85,35.84 222.85,35.69 222.85,35.69 222.85,29.54 223.2,29.2 223.2,27.91 224.28,26.83 226.18,26.83 228.48,24.53 228.48,23.34 228.75,23.08 229.28,23.08 v2(229.43,23.23) ; v2(235.49,18.87) 235.64,18.72 235.99,18.72 236.66,19.39 240.25,19.39 240.31,19.36 241.29,19.17 241.34,19.15 242.03,18.46 257.58,18.46 259.61,20.48 v2(260.89,20.48)
  BOTTOM w0.081: v5(87.19,58.9) 84.11,58.9 82.16,60.85 77.88,60.85 77.65,60.62 74.45,60.62 71.72,57.89 71.72,32.04 68.64,28.96 v3(68.64,28.64) 67.72,27.72 67.72,20.39 65.53,18.2 56.66,18.2 54.18,15.72 46.84,15.72 43.39,12.28 33.42,12.28 30.29,9.15 21.15,9.15 v5(20.8,9.5)
ALWON_3VALW: length 70.3
  TOP w0.254: v1(84.57,58.82) 83.68,57.93 PU300.15
  IN1 w0.254: v1(86.52,7.84) 87.45,7.84 88.39,8.78 88.39,9.44 88.16,9.68 87.78,9.68 87.65,9.81 v2(87.37,9.81) ; v2(89.19,21.47) 89.45,21.73 89.45,47.41 94.84,52.81 95.91,52.81 96.21,53.1 96.21,54.57 95.97,54.81 94.61,54.81 93.69,55.73 93.69,57.74 92.79,58.64 88.09,58.64 87.76,58.3 86.98,58.3 86.41,58.86 v1(86.41,59.19) 85.85,59.19 85.49,58.82 v1(84.57,58.82)
  IN2 w0.254: v2(87.37,9.81) 87.37,19.65 v2(89.19,21.47)
ALWON_5VALW: length 3.7
  TOP w0.254: PU400.15 24.09,5.19 24.35,4.93 25.63,4.93 26.14,4.41 CE413.1 26.96,4.36 RE405.2
ALWON_5VALWB: length 5.4
  TOP w0.081: RE417.2 266.94,9.8 266.22,10.51 v3(265.91,10.51)
  TOP w0.254: RE417.2 267.3,9.38 267.69,9 267.69,8.72 CE429.1 268.28,8.19 269.1,7.37 PU401.15
AUD_PWR_EN: length 214.8
  TOP w0.081: v1(47.95,16.34) 47.5,16.79 47.2,16.79 v3(46.87,17.12) 46.16,17.83 R232.2 R600.2 ; v1(66.31,15.01) 66.31,16.97 67,17.66 67.35,17.66 67.6,17.42 UC25.3
  IN1 w0.064: v2(29.37,10.01) 29.37,10.64 28.35,11.66 25.03,11.66 20.39,16.3 20.39,18.25 19.99,18.65 19.99,23.14 19.95,23.17 19.95,25.16 18.71,26.4 v1(17.93,26.4) ; v1(45.71,16.67) 46.04,16.34 v1(47.95,16.34) 48.94,16.34 49.91,17.31 50.93,17.31 51.31,16.93 v5(54.64,16.93) 57.6,16.93 58.64,17.96 59.08,17.96 59.73,17.31 60.43,17.31 60.5,17.25 61.15,17.25 63.39,15.01 v1(66.31,15.01) 67.34,15.01 71.07,11.28 72.94,11.28 74.1,10.12 76.74,10.12 78.24,8.62 79.92,8.62 80.49,8.05 v2(82.43,8.05)
  IN1 w0.081: v2(157.07,46.46) 157.07,46.39 157.15,46.31 v1(157.42,46.31)
  IN2 w0.051: v2(157.07,46.46) 156.21,47.31 155.73,47.31 155.65,47.23 155.08,47.23 154.85,47.23 154.66,47.41 148.16,47.41 148.02,47.27 143.27,47.27 143.09,47.45 138.28,47.45 137.98,47.15 135.8,47.15 135.19,47.76 127.09,47.76 125.81,46.48 122.79,46.48 119.76,43.45 115.12,43.45 112.03,46.54 104.61,46.54 103.7,45.63 102.4,45.63 100.18,43.41 97.77,43.41 95.9,41.54 95.9,39.03 96.67,38.26 96.67,29.07 97.06,28.68 97.06,24.57 96.22,23.73 96.22,12.93 90.51,7.21 83.97,7.21 83.13,8.05 v2(82.43,8.05)
  IN3 w0.064: v4(31.08,10.51) 29.88,10.51 v2(29.37,10.01)
  BOTTOM w0.081: v4(31.08,10.51) 31.27,10.51 33.22,12.46 43.32,12.46 46.76,15.9 53.62,15.9 v5(54.64,16.93)
AUX_EN_WOWL: length 47.7
  TOP w0.081: v3(172.57,63.31) 172.59,63.31 173.99,61.91 R617.2 174.63,62.46 RE322.1 175.09,62.18 D23.3 175.09,59.55 v1(175.07,59.54)
  IN1 w0.064: v2(209.05,63.08) 209.05,63.2 v1(208.7,63.56) ; v1(175.07,59.54) 175.42,59.54 176.59,60.71 176.59,62.52 v2(175.9,63.22)
  IN2 w0.051: v2(175.9,63.22) 176.08,63.04 177.37,63.04 178,62.4 181.37,62.4 181.95,61.82 189.22,61.82 190.31,62.91 191.68,62.91 193.15,61.44 197.09,61.44 197.89,60.65 200.98,60.65 201.06,60.73 203.27,60.73 204.72,62.18 206.43,62.18 206.6,62.36 207.57,62.36 208.32,63.11 209.03,63.11 v2(209.05,63.08)
B: length 4
  TOP w0.254: PU600.2 87.81,6.46 87.96,6.61 87.96,7.11 87.45,7.62 PR608.2 87.78,7.89 88.63,8.74 PR601.2
B+: length 32.6
  TOP w0.254: v1(121.29,72.67) 104.39,72.67 103.65,71.92 v1(103.65,71.65)
  TOP w0.508: PR603.1 81.62,9.23 v1(81.49,9.09) ; PR218.2 88.35,23.34 89.89,23.34 90.27,22.96
  IN1 w0.254: v1(103.65,71.65) 103.61,71.61 101.75,71.61 v2(100.85,70.71) ; v2(121.64,73.05) 121.64,73.01 v1(121.29,72.67)
  IN1 w0.508: v1(81.49,9.09) 81.97,9.09 v2(82.05,9.17)
  IN3 w0.254: v2(121.64,73.05) 121.64,73.43 122.1,73.89 v4(122.1,79.14)
  vias: v1(98.82,68.51) v1(98.82,68.22) v1(99.19,68.52) v1(99.19,68.21) v2(99.58,68.72) v2(99.81,68.31) v2(100.16,68.72) v5(31.85,8.29) v5(31.85,7.72) v5(31.85,7.15) v5(32.42,8.29) v5(32.42,7.72) v5(32.42,7.15) v5(32.99,8.29) v5(32.99,7.72) v5(32.99,7.15) v5(33.56,8.29) v5(33.56,7.72) v5(33.56,7.15) v5(84.17,44.3) v5(84.17,43.66) v5(84.81,44.3) v5(84.81,43.66) v5(85.44,44.3) v5(85.44,43.66) v5(86.13,62.51) v5(86.1,61.92) v5(86.1,61.34) v5(86.08,44.3) v5(86.08,43.66) v5(86.15,60.76) v5(86.68,62.51) v5(86.66,61.92) v5(86.66,61.34) v5(86.71,60.76) v5(86.71,44.3) v5(87.24,61.9) v5(87.24,61.31) v5(87.27,62.48) v5(87.29,60.73) v5(89.83,56.97) v5(89.81,56.39) v5(89.81,55.8) v5(89.86,55.22) v5(90.39,56.97) v5(90.37,56.39) v5(90.37,55.8) v5(90.42,55.22) v5(90.77,45.44) v5(90.77,44.68) v5(90.77,43.92) v5(90.81,42.95) v5(90.84,42.39) v5(90.84,41.76) v5(90.84,41.18) v5(90.84,40.55) v5(90.84,39.91) v5(90.8,39.28) v5(90.77,38.71) v5(90.77,38.14) v5(90.77,37.57) v5(90.84,25.12) v5(90.84,24.48) v5(90.98,56.95) v5(90.95,56.36) v5(90.95,55.78) v5(91,55.19) v5(91.03,32.61) v5(91.03,31.98) v5(91.03,31.34) v5(91.03,30.71) v5(91.03,30.07) v5(91.35,25.44) v5(91.35,24.8) v5(91.54,32.93) v5(91.54,32.29) v5(91.54,31.66) v5(91.54,31.02) v5(91.54,30.39) v5(128.24,8.61) v5(128.24,7.59) v5(128.24,7.02) v5(128.56,8.1) v5(128.81,8.61) v5(128.81,7.59) v5(128.81,7.02) v5(129.13,8.1) v5(129.38,8.61) v5(129.38,7.59) v5(129.38,7.02) v5(129.7,8.1) v5(129.95,8.61) v5(129.95,7.59) v5(129.95,7.02) v5(173.29,9.24) v5(173.27,8.66) v5(173.27,8.08) v5(173.31,7.49) v5(173.29,6.91) v5(173.84,9.24) v5(173.83,8.66) v5(173.83,8.08) v5(173.84,6.91) v5(173.87,7.49) v5(174.43,9.22) v5(174.42,8.63) v5(174.42,8.05) v5(174.43,6.88) v5(174.45,7.47) v5(174.99,9.27) v5(174.98,8.69) v5(174.98,8.1) v5(175.01,7.49) v5(174.99,6.91) v5(202.66,7.59) v5(202.66,7.02) v5(203.23,7.59) v5(203.23,7.02) v5(217.33,21.3) v5(217.53,20.77) v5(217.9,21.3) v5(218.07,20.64) v5(218.38,20.15) v5(218.47,22.83) v5(218.47,22.26) v5(218.47,21.69) v5(218.47,21.12) v5(259.62,8.55) v5(259.62,7.91) v5(260.13,8.8) v5(260.13,8.23) v5(260.13,7.66) v5(260.7,8.8) v5(260.7,8.23) v5(260.7,7.66) v5(262.29,8.67) v5(262.29,8.1) v6(164.82,15.59)
B+_FLAG: length 188.2
  TOP w0.254: 84.03,4.32 84.03,3.95 v1(84.58,3.4) ; 84.03,4.32 84.92,4.32 86.56,5.96 PU600.3 87.93,5.96 88.67,6.69 PR600.2 ; 84.03,4.32 82.25,6.1 PQ600.1
  IN1 w0.064: v1(84.58,3.4) 88.06,3.4 89.47,4.81 89.89,4.81 93.36,8.29 96.48,8.29 97.05,7.72 99.05,7.72 99.92,6.86 105.51,6.86 106.75,5.61 107.5,5.61 108.39,6.5 109.47,6.5 109.81,6.16 110.21,6.16 110.73,5.64 118.9,5.64 121.08,3.46 126.52,3.46 128.4,5.35 132.57,5.35 134.5,3.41 159.37,3.41 159.93,2.86 204.67,2.86 v2(205.16,3.35) ; v2(250.87,5.12) 250.96,5.12 251.45,5.61 v1(251.45,5.63)
  IN2 w0.051: v2(250.87,5.12) 250.4,5.12 248.28,3 237.97,3 237.24,2.27 226.97,2.27 223.72,5.52 221.29,5.52 221.06,5.29 218.24,5.29 216.3,3.35 v2(205.16,3.35)
BAT1_LED#: length 135.5
  TOP w0.081: JIO1.21 249.65,6.47 249.46,6.66 249.21,6.66 248.52,7.35 243.01,7.35 241.25,9.12 v3(241.25,11.28) 241.25,13.9 240.83,14.31 240.83,15.6 240.53,15.9 240.41,15.9 240.15,16.16 v1(240.15,16.19) ; QZ20.3 196.77,15.72 v5(195.96,16.53)
  IN1 w0.064: v1(214.3,63.56) 214.39,63.56 v2(214.59,63.36) ; v1(240.15,16.19) 240.15,16.52 239.9,16.76 239.47,16.76 239.01,17.23 230.83,17.23 229.71,18.34 228.96,20.15 228.96,21.16 228.46,21.67 228.46,23.96 227.6,24.81 v2(227.47,24.81)
  IN2 w0.051: v2(222.86,29.02) 222.37,28.54 222.37,27.33 222.24,27.2 222.24,25.82 223.36,24.7 v2(223.36,23.95)
  IN3 w0.064: v2(223.36,23.95) 223.36,24.04 v4(222.77,24.64) ; v2(227.47,24.81) 227.47,25.31 226.11,26.67 224.21,26.67 222.86,28.01 v2(222.86,29.02) 222.69,29.2 222.69,35.62 222.68,35.62 222.68,35.77 220.01,38.44 217.4,38.44 216.87,38.96 216.87,44.14 220.59,47.86 220.59,60.3 220.12,60.77 218.92,61.98 218.92,62.39 217.92,63.39 216.57,63.39 216.42,63.24 214.7,63.24 v2(214.59,63.36) 214.59,63.68 v4(214.6,63.69)
  BOTTOM w0.081: v5(195.96,16.53) 196.96,15.53 201.3,15.53 202.81,17.04 212.21,17.04 213.35,15.91 213.35,15.08 213.66,14.77 214.17,14.77 214.49,15.1 221.09,15.1 222.78,16.79 222.78,24.62 v4(222.77,24.64)
BAT1_LED#_Q: length 2.2
  TOP w0.081: QZ20.2 198.48,16.36 198.5,16.37 198.5,16.42 198.78,16.7 QE25.1
BAT2_LED#: length 8.1
  TOP w0.081: RE492.1 v1(220.68,64.92)
  IN1 w0.064: v2(220.66,64.48) 220.68,64.5 v1(220.68,64.92) ; v1(215.1,63.56) v2(215.1,63.99)
  IN2 w0.051: v2(218.98,63.19) 218.98,63.53 219.94,64.48 v2(220.66,64.48)
  IN3 w0.064: v2(218.98,63.19) 218.61,63.56 216.5,63.56 216.35,63.41 215.51,63.41 v4(215.23,63.69) 215.23,63.85 v2(215.1,63.99)
BAT2_W_LED#: length 99.4
  TOP w0.081: v1(221.28,64.47) 221.26,64.48 RE492.2
  IN1 w0.064: v1(221.28,64.47) 221.48,64.26 221.48,43.57 220.77,42.86 220.77,27.33 223.92,24.19 223.92,23.36 224.34,22.94 224.34,17.52 228.95,12.91 231.86,12.91 232.3,12.47 238.8,12.47 239.25,12.02 244.78,12.02 247.28,14.52 254.71,14.52 257.63,11.6 257.63,10.59 257.29,10.25 257.29,8.07 256.52,7.29 256.52,6.95 256.14,6.58 251.2,6.58 v1(250.25,5.63)
BAT_3V3: length 15.6
  TOP w0.254: v5(34.51,7.92) 34.51,8.8 35.28,9.56 v6(36.42,9.56) 37.51,9.56 PR110.1
  IN1 w0.254: v1(42.22,3.84) 41.18,4.88 41.18,7.59 40.82,7.95 34.54,7.95 v5(34.51,7.92)
BATBTN#: length 280.2
  TOP w0.081: UE1.B5 209.98,65.47 209.98,67.5 v1(209.87,67.61) 209.87,67.98 RE137.1 ; v1(240.5,16.19) 241.02,15.67 241.02,14.39 241.54,13.86 v3(241.54,9.75) 241.54,9.08 243.09,7.54 248.6,7.54 249.29,6.85 250.6,6.85 250.85,6.6 JIO1.25
  IN1 w0.064: v2(228.82,23.48) 228.82,22.7 228.62,22.51 228.62,21.74 229.13,21.23 229.13,20.18 229.85,18.44 230.9,17.39 239.08,17.39 239.54,16.93 239.97,16.93 240.5,16.4 v1(240.5,16.19) ; v2(87.12,8.68) 86.9,8.46 86.23,8.46 85.94,8.17 83.99,8.17 v1(83.89,8.26) ; v2(210.07,68.22) 210.22,68.07 210.22,67.83 210.01,67.61 v1(209.87,67.61)
  IN2 w0.051: v2(87.12,8.68) 87.3,8.49 87.94,8.49 89.2,9.75 89.2,10.78 92.04,13.62 92.04,43.06 91.57,43.53 91.57,45.73 93.02,47.18 97.73,47.18 98.26,47.72 99.8,47.72 102.7,50.62 104.82,50.62 105.19,50.25 115.17,50.25 116.35,51.44 127.66,51.44 127.77,51.32 130.41,51.32 130.42,51.31 130.67,51.31 130.81,51.46 131.1,51.75 138.83,51.75 138.86,51.78 154.93,51.78 155.46,51.24 158.86,51.24 159.44,50.66 165.18,50.66 168.27,53.74 168.27,54.54 168.54,54.82 171.04,54.82 172.31,56.08 172.31,56.58 173.01,57.28 174.71,57.28 174.86,57.43 176.29,57.43 178.1,55.61 191.65,55.61 v2(192.84,56.81)
  IN3 w0.064: v2(192.84,56.81) 193.2,56.81 193.32,56.93 193.32,61.91 193.63,62.22 194.23,62.22 194.95,62.94 196.91,62.94 197.39,63.42 199.74,63.42 200.51,64.19 200.51,64.43 201.71,65.63 203.49,65.63 203.93,66.07 205.92,66.07 207.68,67.83 209.05,67.83 209.31,67.57 209.99,67.57 210.23,67.81 210.23,68.06 v2(210.07,68.22) 210.81,68.22 211.46,68.87 212.95,68.87 214.31,70.23 218.3,70.23 219.61,68.92 220.37,68.92 222.69,66.6 222.69,45.48 221.73,44.52 221.73,38.37 223.18,36.92 223.18,30.12 228.65,24.66 228.65,23.65 v2(228.82,23.48)
BATT_LED#_LV1: length 85.6
  TOP w0.081: v1(237.49,15.29) 237.49,15.16 v3(238.72,13.93) 239.17,13.49 239.17,8.45 241.58,6.03 241.58,5.07 242.52,4.12 245.67,4.12 246.65,5.1 JIO1.11
  IN1 w0.064: v1(237.49,15.29) 236.88,15.91 230.16,15.91 227.4,18.67 227.4,21.39 227.12,21.67 227.12,22.2 227.24,22.32 227.24,24.03 226.79,24.48 v2(226.79,24.69) ; v1(215.9,61.96) 215.9,62.28 v2(215.82,62.36)
  IN3 w0.064: v2(215.82,62.36) 215.87,62.31 v4(215.87,62.04) 216.2,62.04 216.92,61.32 218.88,61.32 219.87,60.33 220.1,60.1 220.1,48.06 216.38,44.34 216.38,38.76 217.19,37.95 219.81,37.95 222.19,35.57 222.19,35.42 222.19,35.41 222.19,27.98 225.48,24.69 v2(226.79,24.69)
BATT_LED#_LV2: length 89.2
  TOP w0.081: v1(237.08,15.22) 237.08,15.09 v3(237.52,14.64) 238.98,13.18 238.98,8.37 241.4,5.96 241.4,4.99 242.45,3.94 246.25,3.94 247.25,4.94 JIO1.13 ; v1(214.7,61.02) 214.73,61.02 214.73,61.01 214.71,61 UE1.G10
  IN1 w0.064: v2(226.37,25.06) 226.45,24.97 226.45,24.54 227.08,23.92 227.08,22.39 226.96,22.26 226.96,21.6 227.23,21.32 227.23,18.6 230.09,15.74 236.56,15.74 v1(237.08,15.22) ; v2(214.85,61.57) 214.7,61.42 v1(214.7,61.02)
  IN3 w0.064: v2(226.37,25.06) 225.35,25.06 222.36,28.05 222.36,35.48 222.35,35.49 222.35,35.63 219.88,38.11 217.26,38.11 216.54,38.83 216.54,44.27 220.26,47.99 220.26,60.17 220.03,60.39 219.68,60.75 218.92,61.51 217.45,61.51 216.1,62.86 215.17,62.86 214.85,62.54 v4(214.85,62.04) v2(214.85,61.57)
BATT_LED#_LV3: length 92.1
  TOP w0.081: JIO1.15 247.85,6.34 247.39,6.81 242.78,6.81 240.08,9.51 240.08,14.42 v3(239.94,14.56) 239.8,14.56 239.17,15.19 v1(239.17,15.22)
  IN1 w0.064: v1(211.1,64.36) v2(211.1,64.03) ; v1(239.17,15.22) 239.03,15.36 238.02,15.36 237.31,16.07 230.23,16.07 227.56,18.74 227.56,21.46 227.29,21.73 227.29,22.12 227.41,22.24 227.41,24.16 227.13,24.43 227.13,25.03 v2(226.92,25.25)
  IN3 w0.064: v2(226.92,25.25) 225.69,26.48 224.16,26.48 222.52,28.12 222.52,35.55 222.52,35.55 222.52,35.7 219.94,38.28 217.33,38.28 216.71,38.9 216.71,44.21 220.43,47.93 220.43,60.24 219.84,60.82 219.84,60.82 218.99,61.67 217.61,61.67 216.26,63.02 214.45,63.02 213.84,63.63 213.84,64.24 213.71,64.36 212.08,64.36 211.75,64.03 v2(211.1,64.03) 210.41,64.72 v4(210.41,64.91)
BATT_LED#_LV4: length 93.7
  TOP w0.081: JIO1.17 248.45,6.56 248.02,6.99 242.86,6.99 240.26,9.59 240.26,14.65 239.69,15.22 v1(239.52,15.22) ; v5(208.29,59.21) 207.93,59.56 UE1.J2
  IN1 w0.064: v2(227.62,21.98) 227.62,21.63 227.73,21.53 227.73,18.8 230.29,16.24 237.37,16.24 238.05,15.56 239.25,15.56 239.52,15.28 v1(239.52,15.22)
  IN3 w0.064: v5(208.29,59.21) 208.29,60.08 208.57,60.36 209.39,60.36 209.5,60.47 211.17,60.47 211.83,59.81 213.77,59.81 214.03,59.55 216.73,59.55 217.27,60.09 218.4,60.09 218.94,59.55 218.94,52.55 218.33,51.94 218.33,51.09 218.16,50.91 218.16,47.76 215.22,44.82 215.22,38.28 216.71,36.79 219.33,36.79 221.03,35.09 221.03,33.74 221.04,33.73 221.04,27.5 225.57,22.97 226.84,22.97 227.24,22.57 227.24,22.48 227.62,22.1 v2(227.62,21.98)
  BOTTOM w0.081: RE97.2 208.08,59.42 v5(208.29,59.21) v3(208.64,58.85)
BATT_LED#_LV5: length 78.8
  TOP w0.081: RE96.2 218.6,55.35 218.47,55.22 v1(218.22,55.22) 217.49,55.95 217.49,56.37 UE1.M13 ; v1(240.55,15.48) 240.45,15.38 240.45,14.19 240.95,13.69 v3(240.95,13.56) 240.95,9.16 242.94,7.17 248.45,7.17 249.05,6.57 JIO1.19
  IN1 w0.064: v2(228.57,19.79) 228.87,19.49 228.87,19.47 229.4,18.19 230.69,16.9 238.83,16.9 240.06,15.67 240.36,15.67 v1(240.55,15.48) ; v2(217.77,51.41) 218.04,51.67 218.04,54.82 218.22,55 v1(218.22,55.22)
  IN3 w0.064: v2(228.57,19.79) 228.54,19.81 228.54,19.9 227.05,21.4 227.05,22.02 226.82,22.25 225.82,22.25 220.71,27.36 220.71,33.17 220.7,33.18 220.7,34.95 219.19,36.46 216.57,36.46 214.89,38.14 214.89,44.96 217.13,47.2 217.13,50.77 v2(217.77,51.41)
BC_CLK_ECE1117: length 96.6
  TOP w0.081: v1(244.29,15.43) 244.56,15.16 246.84,15.16 246.9,15.1 246.9,14.18 247.62,13.46 v3(247.62,13.24) 247.73,13.13 247.95,13.13 248.03,13.05 254.74,13.05 255.37,12.43 257.34,12.43 257.45,12.31 257.45,10.7 258.69,9.46 258.69,7.88 258.47,7.65 258.47,6.83 258.05,6.41 JIO1.49 ; UE1.D13 216.77,63.63 217.58,63.63 v5(217.9,63.96)
  IN1 w0.064: v2(227.8,24.14) 228.04,24.14 228.29,23.89 228.29,20.84 228.22,20.77 228.22,19.62 228.4,19.44 228.62,19.44 228.77,19.29 229.26,18.09 230.62,16.73 238.02,16.73 238.41,16.34 239.16,16.34 240.04,15.46 240.17,15.46 240.63,15 242.09,15 242.52,15.43 v1(244.29,15.43)
  IN2 w0.051: v2(227.8,24.14) 227.8,25.33 226.08,27.05 226.08,27.49 224.38,29.2 223.93,29.2 222.37,30.76 222.37,38.98 221.61,39.74 221.61,65.58 221.41,65.78 218.9,65.78 217.9,64.78 v5(217.9,63.96)
BC_DAT_ECE1117: length 97.9
  TOP w0.081: v1(244.71,15.43) 244.76,15.47 v3(245.9,15.47) 246.03,15.35 246.91,15.35 247.08,15.18 247.08,14.25 248.1,13.23 254.82,13.23 255.44,12.61 257.41,12.61 257.64,12.39 257.64,10.77 258.88,9.53 258.88,7.8 258.65,7.58 JIO1.51
  IN1 w0.064: v2(227.96,23.66) 228.13,23.49 228.13,21.02 228.06,20.95 228.06,18.94 230.43,16.57 237.95,16.57 238.34,16.17 239.09,16.17 239.97,15.3 240.1,15.3 240.56,14.83 242.16,14.83 242.48,15.15 244.43,15.15 v1(244.71,15.43) ; v2(216.15,63.87) 216.14,63.85 216.14,63.8 v1(215.9,63.56)
  IN2 w0.051: v2(227.96,23.66) 228.14,23.84 228.14,25.21 226.23,27.11 226.23,27.56 224.44,29.35 224,29.35 222.52,30.82 222.52,39.04 221.76,39.8 221.76,65.64 221.47,65.94 218.84,65.94 216.77,63.87 v2(216.15,63.87)
  IN3 w0.064: v2(216.15,63.87) 216.1,63.82 216,63.82 v4(215.87,63.69)

# Allegro board LA-G172P R10-0527.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VS_AUDIO on TOP (solid shape): 23.4,13.18 23.4,11.23 22.94,10.77 22.64,10.77 22,10.13 21.05,10.13 20.86,10.32 20.86,11.47 21.31,11.91 21.31,13.22 21.51,13.42 23.16,13.42
+5VS_AUDIO on BOTTOM (solid shape): 25.56,11.53 25.56,10.07 25.24,9.75 24.61,9.75 24.35,10.01 21.18,10.01 20.92,10.26 20.92,11.02 21.69,11.78 25.31,11.78
+5VS_AUDIO on BOTTOM (solid shape): 39.53,16.55 40.1,16.55 40.93,15.72 40.93,14.26 39.47,12.8 37.62,12.8 37.31,13.12 37.31,14.9 37.37,14.9 37.75,15.28 37.75,16.29 38.13,16.67 39.4,16.67
+5VS_AUDIO on BOTTOM (solid shape): 163.93,76.63 163.93,75.32 163.93,74.88 163.85,74.8 162.99,74.8 162.8,74.99 162.8,75.93 162.75,75.97 162.07,75.97 161.99,76.05 161.99,76.75 162.05,76.81 163.75,76.81
+5VS_AUDIO on IN2 (solid shape): 40.8,16.55 40.8,16.17 40.74,16.1 38.07,16.1 38.01,16.17 38.01,16.48 38.13,16.61 40.74,16.61
+5VS_AUDIO on TOP: 41.5,15.98 41.5,13.56 41.43,13.5 39.47,13.5 39.15,13.82 39.15,15.34 38.83,15.66 38.26,15.66 38.01,15.91 38.01,16.61 38.39,16.99 38.77,16.99 39.2,17.42 39.2,19.01 39.21,19.02 40.42,19.02 40.61,18.83 40.61,16.86
+5VS_AUDIO_R on TOP: 43.85,16.29 42.7,16.29 42.32,15.91 42.32,13.24 42.46,13.1 44.04,13.1 44.29,13.35 44.29,13.84 44.23,13.91 44.23,14.88 43.91,15.2 43.91,16.23
+5VS_FAN1 on TOP (solid shape): 68.68,6.07 68.68,4.61 65.76,1.69 63.34,1.69 63.15,1.88 63.15,3.16 63.23,3.24 63.58,3.24 63.62,3.2 63.62,3.08 63.62,2.3 63.81,2 64.17,2.05 64.2,2.06 64.45,1.97 64.7,2.06 64.73,2.05 65.09,2 65.28,2.3 65.28,2.36 66.96,4.04 66.96,6.07 67.09,6.2 68.55,6.2
+5VS_R on TOP: 94.32,6.17 96.37,6.17 96.41,6.13 96.41,4.53 96.23,4.34 94.65,4.34 94.24,4.76 94.24,6.09
+8.4V_BATT+ on TOP (solid shape): 94.23,20.94 95.54,20.94 95.68,20.8 95.68,18.87 95.55,18.74 94.43,18.74 93.67,17.98 91.1,17.98 91.1,17.98 90.06,17.98 89.87,18.18 89.87,19.95 91.12,21.19 91.65,21.19 91.66,21.18 91.66,20.48 91.88,20.27 92.21,20.27 92.43,20.48 92.43,21.19 92.45,21.22 93.95,21.22
+DVDD on TOP (solid shape): 30.86,11.82 30.86,10.74 30.93,10.67 32.63,10.67 32.71,10.59 32.71,10.08 32.63,10.01 32.18,10.01 32.04,10.14 31.22,10.14 31.08,10.01 29.55,10.01 29.53,10.02 29.53,10.37 29.55,10.39 29.88,10.39 30.07,10.58 30.07,11.66 30.27,11.86 30.82,11.86
+PVDD on TOP (solid shape): 27.36,16.92 27.36,16.76 27.32,16.72 26.5,16.72 25.62,15.85 25.62,15.09 25.75,14.96 27.28,14.96 27.34,14.9 27.34,14.74 27.29,14.69 26.36,14.69 26.19,14.52 26.19,13.56 26.19,12.93 25.5,12.23 23.85,12.23 23.72,12.36 23.72,15.21 23.59,15.34 23.59,16.74 23.83,16.98 27.3,16.98
+VBATT on TOP (solid shape): 100.76,21.31 100.76,16.39 100.51,16.15 99.64,16.15 99.2,16.58 96.39,16.58 96.18,16.79 96.18,20.72 96.67,21.21 99.54,21.21 99.77,21.44 100.63,21.44
+VCC1.05_OUT_FET on TOP (solid shape): 156.41,24.95 156.44,24.95 156.45,24.94 156.53,24.92 156.62,24.93 156.65,24.94 156.79,24.8 156.79,24.36 156.73,24.31 156.33,24.31 156.06,24.58 155.39,24.58 155.28,24.47 155.22,24.47 155.09,24.34 155.09,24.28 155.04,24.23 154.88,24.23 154.85,24.26 154.85,25.2 154.87,25.22 156.14,25.22
+VCC1.05_OUT_FET on BOTTOM (solid shape): 149.37,21.51 149.37,20.5 149.3,20.44 148.17,20.44 147.73,19.99 147.62,19.99 147.02,20.59 147.02,20.84 148.04,21.86 149.03,21.86
+VCC1.05_OUT_FET on IN1 (solid shape): 149.92,22.32 149.92,21.7 149.87,21.65 149.26,21.65 149.08,21.47 149.08,20.44 149.04,20.4 148.07,20.4 147.96,20.51 147.96,22.16 148.24,22.45 149.8,22.45
+VCC1.05_OUT_FET on TOP: 135.24,15.27 135.24,17.77 135.4,17.93 137.97,17.93 138.09,17.81 138.09,16.25 137.92,16.08 136.75,16.08 136.62,15.95 136.62,15.44 135.86,14.68 135.86,14.12 135.78,14.04 134.51,14.04 134.42,14.12 134.42,14.45
+VCC1.05_OUT_FET on TOP: 134.16,18.41 134.59,18.41 135.07,17.92 135.08,17.92 135.08,16.01 135.03,15.97 134.13,15.97 134.05,16.05 134.05,18.29
+VCC1.05_OUT_FET on TOP: 133.36,18.25 133.36,17.21 133.53,17.04 133.84,17.04 133.93,16.95 133.93,15.94 133.73,15.74 132.78,15.74 132.69,15.65 132.69,14.56 132.6,14.47 131.43,14.47 131.43,18.18 131.63,18.37 133.24,18.37
+VCC1.05_OUT_FET on BOTTOM: 133.85,18.55 135.59,18.55 135.82,18.33 135.82,17.63 135.27,17.09 133.9,17.09 133.66,17.32 133.66,18.37
+VCC1.05_OUT_FET on IN1: 155.23,24.91 155.43,24.71 155.43,23.71 154.58,22.86 152.96,22.86 152.81,23.01 152.81,24.17 153.27,24.63 154.42,24.63 154.7,24.91
+VCC1.05_OUT_PCH on TOP: 167.8,39.24 168.92,39.24 169.05,39.11 169.05,37.83 168.97,37.75 167.9,37.75 167.73,37.92 167.73,39.16
+VCC1P8A on TOP: 149.2,28.47 151.29,28.47 151.36,28.4 151.36,27.9 151.19,27.72 149.23,27.72 149.08,27.87 149.08,28.35
+VCC1P8A on TOP: 151.56,21.14 151.91,21.49 153.49,21.49 153.65,21.65 153.65,22.37 154.75,23.47 154.75,25.25 154.66,25.33 152.46,25.33 152.34,25.21 152.34,23.06 151.91,22.63 149.04,22.63 148.84,22.42 148.84,21.05 148.96,20.93 149.66,20.93 149.87,21.14
+VCC1P8A on IN1: 149.17,27.29 150.77,27.29 150.99,27.07 150.99,26.7 151.62,26.07 151.62,25.65 152.54,24.73 154.37,24.73 154.49,24.85 154.49,25.27 154.12,25.63 154.12,27.14 153.96,27.31 152.75,27.31 151.51,28.54 149.12,28.54 149.03,28.45 149.03,27.43
+VCC1P8A_R on TOP (solid shape): 148.12,22.27 148.12,20.98 148.09,20.96 148.01,20.9 147.95,20.81 147.93,20.79 147.91,20.66 147.93,20.56 147.93,20.48 148.06,20.34 148.15,20.34 148.24,20.33 148.34,20.34 148.47,20.34 148.67,20.14 148.67,19.89 148.58,19.8 147.07,19.8 147.01,19.86 147.01,20.22 147.44,20.66 147.44,21.42 147.36,21.5 146.81,21.5 146.78,21.53 146.78,22.26 146.85,22.33 148.05,22.33
+VCC3V3_TBT_L_LDO on BOTTOM: 10.64,27.51 11.03,27.9 11.2,27.9 11.21,27.91 11.24,27.88 11.56,27.88 11.97,27.47 12.29,27.47 12.61,27.15 13.1,27.15 14.07,28.12 14.3,28.12 14.6,27.82 14.6,27.63 13.81,26.83 13.81,26.14 14,25.94 14,25.67 13.72,25.38 13.27,25.38 11.66,27 11.12,27 10.64,27.48
+VCC3V3_TBT_R_LDO on TOP (solid shape): 277.65,8.48 277.65,7.72 277.69,7.68 277.69,7.67 277.71,7.67 277.78,7.59 277.78,7.4 276.83,7.4 276.7,7.53 276.7,7.97 276.77,8.04 277.08,8.04 277.15,8.1 277.17,8.1 277.17,8.13 277.21,8.16 277.21,8.55 277.27,8.61 277.53,8.61
+VCC3V3_TBT_R_LDO on TOP (solid shape): 276.88,14 276.97,13.77 277.2,13.66 277.2,13.36 277.45,13.11 278.78,13.11 278.85,13.04 278.85,12.85 278.78,12.79 276.94,12.79 276.37,13.36 276.05,13.36 275.99,13.43 275.99,13.93 276.05,14
+VCC_SFR_OC on TOP: 106.69,46.73 108.17,46.73 108.24,46.66 108.24,44.86 108.16,44.78 106.76,44.78 106.62,44.92 106.62,46.66
+VCC_SFR_OC on TOP: 158.18,50.37 159.77,50.37 159.82,50.31 159.82,49.87 159.39,49.44 159.39,48.49 159.18,48.28 159.18,48.15 159.08,48.05 159.08,47.91 159.24,47.75 159.44,47.75 159.66,47.97 160.2,47.97 160.34,47.83 160.34,44.61 160.16,44.43 159.17,44.43 158.97,44.22 158.97,43.44 158.72,43.2 158.45,43.2 158.33,43.08 158.33,42.79 158.72,42.4 158.72,42.07 158.61,41.96 157.88,41.96 157.8,42.04 157.8,45.19 158.06,45.45 158.74,45.45 158.85,45.57 158.85,47.03 158.54,47.35 158.54,47.85 158.1,48.29 158.1,50.29
+VCC_SFR_OC on IN2: 107.88,45.55 107.97,45.46 107.97,43.87 107.88,43.78 106.46,43.78 106.32,43.92 106.32,45.48 106.39,45.55
+VCC_SFR_OC on IN2: 155.61,46.71 156.37,46.71 156.94,46.14 158.2,46.14 158.86,45.49 158.86,43.56 158.84,43.54 158.84,42.96 158.66,42.77 156.24,42.77 155.1,43.92 155.1,46.2
+VCCA_CLKLDO_1P8 on TOP (solid shape): 179.71,36.1 179.71,35.11 179.38,34.78 179.38,32.38 178.34,31.34 177.01,31.34 176.78,31.11 174.36,31.11 174.23,31.24 174.23,31.42 174.37,31.56 176.07,31.56 176.49,31.98 177.64,31.98 178.12,32.46 178.12,35.75 178.16,35.79 178.72,35.79 179.1,36.17 179.65,36.17
+VCCIN on TOP: 160.14,28.75 160.14,28.47 160.01,28.34 157.45,28.34 156.79,27.68 151.68,27.68 151.33,28.04 151.33,29.69 151.63,30 159.63,30 159.76,29.87 159.76,28.98 159.84,28.9 159.99,28.9
+VCCIN on TOP: 155.93,40.54 156.36,40.11 156.36,39.52 156.64,39.24 157.98,39.24 158.34,39.6 164.05,39.6 164.18,39.72 164.18,40.23 164.05,40.36 164,40.36 164,41.46 163.85,41.62 157.45,41.62 157.31,41.76 156.5,41.76 156.36,41.62 156.08,41.62 156,41.69 155.62,41.69 155.58,41.65 155.58,41.62 153.89,41.62 153.59,41.31 153.59,40.66 153.72,40.54
+VCCIN on TOP: 133.4,21.58 132.72,22.27 112.39,22.27 112.22,22.44 112.22,39.4 112.43,39.6 115.04,39.6 115.43,39.21 115.43,38.11 115.44,38.11 115.54,38.01 122.13,38.01 122.23,38.11 122.23,38.39 122.32,38.48 122.68,38.48 122.8,38.6 122.8,38.96 122.89,39.05 124.25,39.05 124.38,39.18 125.55,39.18 125.67,39.3 125.82,39.3 125.95,39.43 129.81,39.43 131.32,39.43 131.57,39.18 131.57,31.17 131.82,30.92 131.83,30.92 132.35,30.4 133.46,30.4 133.98,30.92 137.29,30.92 137.37,30.83 137.88,30.38 137.88,28.79 137.13,28.04 137.13,27.34 137.32,27.15 137.83,27.15 137.88,27.1 137.88,23.98 136.43,22.53 136.43,21.77 136.24,21.58 ; 6 cut-outs
+VCCIN on BOTTOM: outline of 226 points within 111.14,22.02 166.3,41.53
+VCCIN on IN1: outline of 368 points within 111.86,22.01 164.42,42.02
+VCCIN on VCC: 111.45,21.44 110.97,21.92 110.97,41.14 111.58,41.76 120.42,41.76 123.16,44.5 126.72,44.5 127.07,44.85 127.07,45.44 127.07,45.44 154.12,45.44 154.58,44.98 154.58,43.65 156.02,42.22 158.8,42.22 159.58,43 159.58,45.26 159.76,45.44 169.66,45.44 170.02,45.08 170.02,42.9 169.96,42.71 170.02,42.53 170.02,30.96 160.44,30.96 159.74,30.25 159.74,28.47 158.67,27.41 152.17,27.41 151.35,28.22 151.35,31.52 150.39,32.49 141.14,32.49 138.22,29.56 135.28,29.56 134.46,30.38 134.46,30.89 134.13,31.22 132.12,31.22 132,31.09 131.82,31.09 131.67,30.94 131.67,29.46 135.63,25.5 137.79,25.5 138.27,25.01 138.27,21.8 137.91,21.44
+VCCIN on IN2: outline of 183 points within 111.79,22.07 165.84,45.28
+VCCIN_AUX on TOP (solid shape): outline of 3885 points within 150.74,6.64 172.89,30.03
+VCCIN_AUX on TOP: 143.85,27.8 143.85,27.8 143.62,27.8 143.23,28.19 143.23,29.84 143.4,30.02 146.63,30.02 146.81,29.84 146.81,28.55 146.93,28.42 146.93,28.41 147.02,28.32 147.02,28 146.82,27.8
+VCCIN_AUX on TOP: 132.56,29.95 132.79,29.72 133.51,29.72 133.63,29.84 134.02,29.84 134.13,29.73 134.31,29.73 134.37,29.79 134.37,30.85 134.23,30.99 132.48,30.99 132.2,30.71 132.2,30.3
+VCCIN_AUX on TOP: 139.65,24.45 142.31,24.45 142.41,24.35 142.41,23.99 142.31,23.89 142.31,21.83 142.18,21.71 139.63,21.71 139.55,21.79 139.55,24.35
+VCCIN_AUX on VCC: 151.46,6.58 150.85,7.19 150.85,14.22 151.71,15.09 156.54,15.09 157.32,15.87 157.32,20.78 156.67,21.44 139.14,21.44 138.78,21.8 138.78,25.22 138,26.01 135.84,26.01 132.18,29.67 132.18,30.91 132.23,30.96 134.03,30.96 134.21,30.78 134.21,30.27 135.17,29.31 138.32,29.31 141.25,32.23 150.28,32.23 151.1,31.42 151.1,28.11 152.06,27.15 158.77,27.15 159.99,28.37 159.99,30.15 160.55,30.71 170.02,30.71 170.02,12.06 172.56,9.52 172.56,6.94 172.2,6.58
+VCCIN_AUX on IN2: outline of 269 points within 132.38,6.43 170.2,32.18
+VCCIO_OUT on TOP: 137.32,27.91 139.48,27.91 139.73,27.66 139.73,24.74 139.42,24.42 139.42,22.71 139.22,22.52 137.95,22.52 137.89,22.45 137.89,21.25 137.89,21.25 137.89,20.97 137.79,20.87 136.61,20.87 136.56,20.92 136.56,22.39 138.08,23.91 138.08,27.28 138.02,27.34 137.32,27.34 137.26,27.41 137.26,27.85
+VCCPRIM_1P8 on BOTTOM (solid shape): 183.87,33.44 183.87,32.74 183.67,32.55 182.09,32.55 181.96,32.68 181.96,33.5 182.02,33.56 183.74,33.56
+VCCPRIM_1P8 on IN1 (solid shape): 183.42,32.61 183.42,32.36 180.98,32.36 180.98,32.77 181.52,33.31 182.72,33.31
+VCCPRIM_1P8 on IN2 (solid shape): outline of 317 points within 166.05,30.57 182.9,38.77
+VCCPRIM_1P8 on IN3 (solid shape): 183.74,32.87 183.74,32.55 183.36,32.17 181.2,32.17 181.05,32.32 181.05,32.53 182.02,33.5 183.1,33.5
+VCCPRIM_1P8 on TOP: 169.07,31.17 168.88,30.98 166.15,30.98 166.08,31.05 166.08,34.11 166.09,34.12 166.09,34.93 166.17,35.01 166.68,35.01 166.85,34.84 166.85,34.6 166.97,34.48 168.94,34.48 169.07,34.35
+VCCPRTC_3P3 on BOTTOM: 176.66,39.98 177.72,39.98 177.82,40.08 178.47,40.08 178.53,40.02 178.53,39.45 178.44,39.36 177.88,39.36 177.76,39.47 169.1,39.47 168.96,39.61 168.96,40.16 169.36,40.56 176.08,40.56
+VCCST_CPU on TOP (solid shape): 156.17,24.25 156.17,22.85 155.62,22.3 155.62,20.59 155.53,20.5 155.24,20.5 155.19,20.5 155.1,20.58 155.1,22.47 155.73,23.11 155.73,24.31 155.8,24.37 156.04,24.37
+VCCST_CPU on IN1: 155.52,21.56 155.58,21.51 155.58,19.97 155.2,19.59 155.19,19.59 154.71,19.11 150.51,19.11 149.61,18.21 141.29,18.21 140.27,17.18 139.49,17.18 139.29,17.38 139.29,18.38 140.13,19.21 141.43,19.21 141.88,19.66 149.77,19.66 150.45,20.34 154.72,20.34 154.97,20.59 154.97,21.53 155,21.56
+VCCST_R on TOP (solid shape): 135.51,20.14 135.51,19.14 135.76,18.9 136.94,18.9 137.26,18.58 137.26,18.13 137.13,18.01 135.16,18.01 134.61,18.56 134.39,18.56 133.89,19.06 133.89,19.52 134.54,20.17 135.48,20.17
+VCCSTG_CPU on TOP (solid shape): 155.55,24.33 155.55,23.09 154.93,22.47 154.93,20.61 154.88,20.56 154.46,20.56 154.42,20.6 154.42,22.91 154.89,23.38 154.89,23.91 155.19,24.21 155.19,24.28 155.2,24.3 155.26,24.37 155.52,24.37
+VCCSTG_CPU on TOP: 129.38,18.63 130.19,18.63 130.28,18.55 130.28,17.71 130.09,17.52 129.45,17.52 128.59,16.67 127.73,16.67 123.44,12.39 123.44,6.93 122.91,6.39 121.83,6.39 121.57,6.64 121.57,13.12 126.47,18.01 128.79,18.01 129.36,18.59 129.36,18.61
+VCCSTG_CPU on IN1: 122.21,7.28 123.41,7.28 123.54,7.15 123.54,6.89 123.1,6.45 122.21,6.45 122.08,6.58 122.08,7.15
+VCCSTG_CPU on IN1: 155.71,22.74 155.83,22.62 155.83,22.16 155.57,21.9 155.57,21.9 155.34,21.67 155.08,21.67 154.89,21.49 154.89,20.66 154.81,20.58 154.41,20.58 154.41,20.58 153.42,20.58 153.19,20.8 153.19,21.42 153.6,21.82 153.62,21.82 154.53,22.74
+VCCSTG_CPU on IN2: 122.18,6.73 121.67,7.24 121.67,8.18 125.56,12.08 131.78,12.08 136.65,16.94 136.65,18.63 138.02,20 149.17,20 151.98,22.81 155.86,22.81 155.94,22.73 155.94,21.75 155.8,21.61 154.39,21.61 154.38,21.6 152.48,21.6 147.99,17.11 138.93,17.11 138.93,17.08 131.75,9.89 126.6,9.89 123.44,6.73
+VCCSTG_OUT on TOP: 130.16,40.35 132.53,40.35 132.87,40.69 132.87,40.99 133,41.12 133.57,41.12 133.58,41.11 136.2,41.11 136.73,40.58 136.73,40.57 136.88,40.42 136.88,40.04 136.75,39.92 136.75,39.92 136.56,39.72 131.3,39.72 131.15,39.88 129.74,39.88 129.28,39.42 128.35,39.42 128.28,39.5 128.28,40.91 128.49,41.12 129.95,41.12 130.07,41.01 130.07,40.44
+VCCSTG_OUT on BOTTOM: 132.43,39.34 132.18,39.6 132.18,40.36 132.3,40.49 133,40.49 133.52,41.01 134.17,41.01 134.22,40.96 134.22,40.59 134.28,40.52 134.92,40.52 135.07,40.68 136.43,40.68 136.75,40.36 136.75,39.72 136.37,39.34
+VCCSTG_R on TOP (solid shape): 131.36,17.49 131.36,16 131.27,15.91 130.5,15.91 130.07,15.48 129.58,15.48 129.13,15.94 129.13,16.97 129.41,17.25 130.41,17.25 130.78,17.63 131.22,17.63
+VDDQ_MEM on BOTTOM (solid shape): outline of 349 points within 104.17,53.57 170.59,71.54
+VDDQ_MEM on TOP: outline of 153 points within 147.64,51.3 167.3,58.44
+VDDQ_MEM on TOP: outline of 162 points within 130.46,52.09 146.05,68.99
+VDDQ_MEM on TOP: 157.11,64.96 157.08,65 157.08,65.05 156.86,65.38 156.54,65.15 156.54,65.11 156.29,65.11 156.28,65.15 156.13,65.36 155.88,65.35 155.86,65.34 155.27,65.34 155.26,65.35 154.02,65.35 153.17,64.5 151.5,64.5 151.23,64.73 150.96,64.5 150.94,64.5 150.84,64.6 150.66,64.6 150.38,64.73 150.16,64.51 150.15,64.47 149.9,64.47 149.89,64.51 149.63,64.73 149.36,64.51 149.35,64.47 148.77,64.47 148.45,64.79 148.45,65.14 148.2,65.39 147.79,65.39 147.65,65.53 147.65,68 147.82,68.18 147.85,68.15 148.05,68.09 148.23,68.18 148.62,68.18 148.83,68.09 149.03,68.18 149.42,68.18 149.63,68.09 149.83,68.18 150.22,68.18 150.43,68.09 150.63,68.18 151.02,68.18 151.23,68.09 151.43,68.18 155.72,68.18 155.79,68.11 159.31,68.11 159.49,67.92 159.49,66.18 159.29,65.98 158.31,65.98 158.13,65.8 158.13,65.59 157.88,65.34 157.88,65.15 157.69,64.96 ; 1 cut-out
+VDDQ_MEM on TOP: outline of 126 points within 107.6,50.2 128.94,59.34
+VDDQ_MEM on TOP: outline of 211 points within 105.44,58.58 166.26,71.88
+VDDQ_MEM on TOP: 123.79,68.2 124.01,68.09 124.23,68.2 124.59,68.2 124.81,68.09 125.03,68.2 125.39,68.2 125.61,68.09 125.83,68.2 126.19,68.2 126.4,68.09 126.62,68.18 127,68.18 127.16,68.09 127.34,68.12 127.37,68.13 128.56,68.13 128.68,68.01 128.68,66.1 128.57,65.98 128.3,65.98 128.18,65.86 128.18,65.06 128.11,65 124.37,65 124.24,65.12 123.59,65.12 123.45,65.27 123.43,65.25 121.52,65.25 120.9,64.63 120.33,64.63 119.99,64.29 119.59,64.29 119.51,64.33 119.49,64.41 119.28,64.73 118.96,64.52 118.95,64.48 118.87,64.48 118.75,64.6 118.66,64.6 118.38,64.73 118.15,64.52 118.15,64.48 117.9,64.48 117.89,64.52 117.62,64.73 117.35,64.52 117.35,64.48 117.1,64.48 117.09,64.52 116.82,64.73 116.55,64.52 116.55,64.48 116.3,64.48 116.29,64.52 116.24,64.62 116.16,64.69 116.14,64.71 116.14,64.86 116.16,64.88 116.3,65.11 116.16,65.34 116.14,65.36 116.14,65.43 115.63,65.94 115.63,68 115.77,68.14 115.86,68.14 116.07,68.09 116.25,68.21 116.6,68.21 116.82,68.09 117.04,68.2 117.4,68.2 117.62,68.09 117.84,68.2 ; 1 cut-out
+VDDQ_MEM on VCC: outline of 86 points within 105.38,52.68 164.94,68.3
+VSS_PLL on TOP: 203.61,61.14 205.37,61.14 205.57,60.94 207.2,60.94 207.28,61.03 207.28,61.26 206.96,61.59 205.91,61.59 205.24,62.25 203.56,62.25 203.51,62.2 203.51,61.24
AGND on GND1: 34.75,16.48 34.69,16.54 34.58,16.6 34.45,16.6 34.38,16.67 32.72,16.67 32.61,16.79 32.61,18.49 32.21,18.9 27.68,18.9 27.27,18.49 27.27,17.17 27.22,17.12 26.07,17.12 26.07,17.22 25.86,17.44 23.7,17.44 23.59,17.54 23.59,23.83 19.91,27.51 19.91,52.06 22.7,54.86 22.7,61.29 14.93,69.06 9.85,69.06 9.75,69.17 9.75,71.2 9.35,71.6 7.26,71.6 5.25,73.61 5.25,75.64 5.66,76.05 9.35,76.05 9.47,76.03 9.62,75.98 9.72,75.93 9.83,75.83 9.96,75.71 10.2,75.6 10.5,75.54 11.13,75.54 11.26,75.5 21.1,65.67 21.1,65.6 21.4,64.59 22.02,63.74 23.78,62.01 24.23,61.57 24.23,56.51 24.73,56 24.73,54.4 24.48,54.14 22.02,51.74 21.32,50.71 21.07,49.48 21.07,42.97 21.43,38.79 22.5,34.72 22.5,31.88 21.5,30.88 21.5,28.06 23.1,26.45 27.48,26.45 27.62,26.3 32.59,22.21 38.44,19.55 38.58,19.42 38.58,16.48
AGND on GND2: 24.73,54.4 24.48,54.14 22.02,51.74 21.32,50.71 21.07,49.48 21.07,42.97 21.43,38.79 22.5,34.72 22.5,31.88 21.5,30.88 21.5,28.06 23.1,26.45 27.48,26.45 27.62,26.3 32.59,22.21 38.44,19.55 38.58,19.42 38.58,16.48 34.75,16.48 34.69,16.54 34.58,16.6 34.45,16.6 34.38,16.67 32.72,16.67 32.61,16.79 32.61,18.49 32.21,18.9 27.68,18.9 27.27,18.49 27.27,17.17 27.22,17.12 26.07,17.12 26.07,17.22 25.86,17.44 23.7,17.44 23.59,17.54 23.59,23.83 19.91,27.51 19.91,52.06 22.7,54.86 22.7,61.29 14.93,69.06 9.85,69.06 9.75,69.17 9.75,71.2 9.35,71.6 7.26,71.6 5.25,73.61 5.25,75.64 5.66,76.05 9.15,76.05 9.42,76.04 9.53,76.02 9.64,75.98 9.71,75.94 9.78,75.88 9.83,75.83 9.92,75.76 10.02,75.69 10.17,75.62 10.32,75.57 10.49,75.54 10.57,75.54 11.14,75.54 11.2,75.53 11.25,75.51 11.3,75.47 11.35,75.42 21.1,65.67 21.1,65.6 21.4,64.59 22.02,63.74 23.78,62.01 24.23,61.57 24.23,56.51 24.73,56
AGND on VCC: 34.75,16.48 34.69,16.54 34.58,16.6 34.45,16.6 34.38,16.67 32.72,16.67 32.61,16.79 32.61,18.49 32.21,18.9 27.68,18.9 27.27,18.49 27.27,17.17 27.22,17.12 26.07,17.12 26.07,17.22 25.86,17.44 23.7,17.44 23.59,17.54 23.59,23.83 19.91,27.51 19.91,52.06 22.7,54.86 22.7,61.29 14.93,69.06 9.85,69.06 9.75,69.17 9.75,71.2 9.35,71.6 7.26,71.6 5.25,73.61 5.25,75.64 5.65,76.03 9.35,76.03 9.35,76.03 9.53,76.03 10.07,75.66 10.72,75.53 11.24,75.53 21.1,65.67 21.1,65.6 21.4,64.59 22.02,63.74 23.78,62.01 24.23,61.57 24.23,56.51 24.73,56 24.73,54.43 22.02,51.78 21.9,51.65 21.79,51.51 21.26,50.57 21.07,49.51 21.07,47.93 21.07,42.97 21.43,38.79 22.5,34.72 22.5,31.88 21.5,30.88 21.5,28.06 23.1,26.45 27.48,26.45 27.62,26.3 32.59,22.21 38.44,19.55 38.58,19.42 38.58,16.48
AGND on GND3: 24.73,54.4 24.48,54.14 22.02,51.74 21.32,50.71 21.07,49.48 21.07,42.97 21.43,38.79 22.5,34.72 22.5,31.88 21.5,30.88 21.5,28.06 23.1,26.45 27.48,26.45 27.62,26.3 32.59,22.21 38.44,19.55 38.58,19.42 38.58,16.48 34.75,16.48 34.69,16.54 34.58,16.6 34.45,16.6 34.38,16.67 32.72,16.67 32.61,16.79 32.61,18.49 32.21,18.9 27.68,18.9 27.27,18.49 27.27,17.17 27.22,17.12 26.07,17.12 26.07,17.22 25.86,17.44 23.7,17.44 23.59,17.54 23.59,23.83 19.91,27.51 19.91,52.06 22.7,54.86 22.7,61.29 14.93,69.06 9.85,69.06 9.75,69.17 9.75,71.2 9.35,71.6 7.26,71.6 5.25,73.61 5.25,75.64 5.66,76.05 9.37,76.05 9.5,76.03 9.6,75.99 9.69,75.95 9.75,75.9 9.87,75.8 9.99,75.71 10.1,75.65 10.21,75.6 10.34,75.56 10.45,75.54 10.52,75.53 11.23,75.53 21.1,65.67 21.1,65.6 21.4,64.59 22.02,63.74 23.78,62.01 24.23,61.57 24.23,56.51 24.73,56
AGND on GND4: 24.73,54.4 24.48,54.14 22.02,51.74 21.32,50.71 21.07,49.48 21.07,42.97 21.43,38.79 22.5,34.72 22.5,31.88 21.5,30.88 21.5,28.06 23.1,26.45 27.48,26.45 27.62,26.3 32.59,22.21 38.44,19.55 38.58,19.42 38.58,16.48 34.75,16.48 34.69,16.54 34.58,16.6 34.45,16.6 34.38,16.67 32.72,16.67 32.61,16.79 32.61,18.49 32.21,18.9 27.68,18.9 27.27,18.49 27.27,17.17 27.22,17.12 26.07,17.12 26.07,17.22 25.86,17.44 23.7,17.44 23.59,17.54 23.59,23.83 19.91,27.51 19.91,52.06 22.7,54.86 22.7,61.29 14.93,69.06 9.85,69.06 9.75,69.17 9.75,71.2 9.35,71.6 7.26,71.6 5.25,73.61 5.25,75.64 5.66,76.05 9.29,76.05 9.29,76.05 9.46,76.03 9.59,76 9.67,75.96 9.73,75.92 9.88,75.79 9.99,75.71 10.14,75.63 10.29,75.57 10.41,75.55 10.52,75.54 11.23,75.54 21.1,65.67 21.1,65.6 21.4,64.59 22.02,63.74 23.78,62.01 24.23,61.57 24.23,56.51 24.73,56
DV12S on TOP (solid shape): 280.73,25 280.73,24.19 280.77,24.15 280.77,23.68 281.08,23.37 281.08,21.89 281.51,21.47 281.51,21.2 281.39,21.09 280.86,21.09 280.77,21.18 280.26,21.18 280.19,21.25 280.19,21.56 280.55,21.92 280.55,24.04 280.5,24.09 280.5,25 280.54,25.04 280.69,25.04
DV12S on TOP (solid shape): 279.12,24.99 279.12,23.91 278.29,23.09 278.29,22.9 278.04,22.64 278.04,22.53 277.98,22.48 277.6,22.48 277.51,22.57 277.51,22.83 277.72,23.04 277.72,23.66 277.78,23.72 278.48,23.72 278.86,24.1 278.86,24.99 278.92,25.06 279.05,25.06
DV33_18 on TOP (solid shape): 283.34,25.67 283.82,25.67 283.88,25.61 283.88,25.17 283.81,25.1 283.12,25.1 282.81,25.41 282.57,25.41 282.48,25.5 281.67,25.5 281.61,25.56 281.61,25.7 281.66,25.75 282.47,25.75 282.61,25.89 283.12,25.89
GND on TOP (solid shape): 62.69,14.16 61.25,14.16 61.18,14.23 61.18,14.75 61.3,14.87 62.69,14.87
GND on TOP (solid shape): 16.8,2.45 16.8,1.81 16.67,1.69 15.02,1.69 14.96,1.75 14.96,2.39 15.08,2.51 16.73,2.51
GND on TOP (solid shape): 18.21,40.58 18.21,39.75 18.12,39.66 17.27,39.66 16.91,40.01 16.91,40.58 17.02,40.68 18.11,40.68
GND on TOP (solid shape): 79.57,29.77 79.57,28.5 79.39,28.32 73.58,28.32 73.48,28.42 73.48,29.64 73.86,30.02 79.32,30.02
GND on TOP (solid shape): 156.9,22.25 156.9,20.6 156.86,20.56 155.78,20.56 155.73,20.61 155.73,22.26 155.76,22.29 156.86,22.29
GND on TOP (solid shape): 187.93,7.15 187.93,6.2 187.87,6.13 183.29,6.13 183.17,6.26 183.17,7.15 183.23,7.21 187.87,7.21
GND on TOP (solid shape): 200.63,7.28 200.63,6.77 200.57,6.7 199.04,6.7 198.98,6.77 198.98,7.28 199.04,7.34 200.57,7.34
GND on TOP (solid shape): 215.11,38.45 215.11,36.36 215.04,36.3 214.41,36.3 214.35,36.36 214.35,38.45 214.41,38.52 215.04,38.52
GND on TOP (solid shape): 219.23,38.45 219.23,36.36 219.17,36.3 218.6,36.3 218.54,36.36 218.54,38.45 218.6,38.52 219.17,38.52
GND on TOP (solid shape): 79.75,23.87 79.75,23.09 79.6,22.93 75.64,22.93 75.6,22.97 75.6,23.87 75.66,23.93 79.7,23.93
GND on TOP (solid shape): 100.15,25.98 100.15,22.07 99.41,21.33 97.99,21.33 97.84,21.49 97.84,24.33 97.99,24.48 97.99,26.08 98.06,26.16 99.97,26.16
GND on TOP (solid shape): 202.36,19.94 202.36,19.37 202.3,19.31 199.44,19.31 199.38,19.37 199.38,20.01 199.44,20.07 202.24,20.07
GND on TOP (solid shape): 249.21,11.74 249.21,11.27 249.14,11.2 247.53,11.2 247.28,11.46 246.67,11.46 246.58,11.55 246.58,12.16 246.65,12.23 248.71,12.23
GND on TOP (solid shape): 285.27,65.25 285.27,64.3 285.97,63.6 285.97,62.58 285.4,62.01 284.32,62.01 284.2,62.14 284.2,65.31 284.26,65.38 285.15,65.38
GND on TOP (solid shape): 21.05,34.2 6.85,34.2 6.85,34.8 20.45,34.8 20.45,51.2 7.45,51.2 7.45,34.8 6.85,34.8 6.85,51.8 21.05,51.8
GND on TOP (solid shape): 152.86,52.9 152.86,52.16 152.79,52.09 149.63,52.09 149.51,52.21 149.51,52.65 149.84,52.98 152.78,52.98
GND on TOP (solid shape): 202.43,24.71 202.43,24.13 202.32,24.03 199.42,24.03 199.38,24.07 199.38,24.72 199.44,24.78 202.36,24.78
GND on TOP (solid shape): 269.78,24.17 269.78,23.79 269.91,23.66 269.91,23.09 269.65,22.83 269.15,22.83 269.02,22.96 269.02,24.04 269.21,24.23 269.72,24.23
GND on TOP (solid shape): 284.73,19.34 284.73,19.03 284.65,18.95 284.55,18.95 284.19,18.95 282.32,18.95 282.29,18.98 282.29,19.37 284.7,19.37
GND on TOP (solid shape): 291.6,20.1 272.6,20.1 272.6,20.7 291,20.7 291,43.1 273.2,43.1 273.2,20.7 272.6,20.7 272.6,43.7 291.6,43.7
GND on TOP (solid shape): 87.9,28.37 87.9,24.28 87.73,24.1 86.34,24.1 85.77,24.67 85.77,28.34 85.85,28.42 87.27,28.42 87.29,28.45 87.83,28.45
GND on TOP (solid shape): 140.11,52.41 140.11,51.42 140,51.31 139.88,51.31 139.27,51.92 136.19,51.92 136.19,51.92 135.79,51.92 135.73,51.98 135.73,52.99 135.8,53.06 139.46,53.06
GND on TOP (solid shape): 15.37,73.14 15.66,72.94 15.98,72.79 15.98,72.51 14.93,71.46 13.86,71.46 13.81,71.5 13.81,72.11 14.85,73.14
GND on TOP (solid shape): 275.89,13.38 276.01,13.26 276.33,13.26 276.59,13 276.59,12.45 276.52,12.39 274.39,12.39 274.34,12.44 274.34,13.22 275.13,14.01 275.89,14.01
GND on TOP (solid shape): 213.02,43.76 213.02,41.92 212.85,41.76 210.77,41.76 210.67,41.86 210.67,42.52 210.6,42.59 210.39,42.59 210.01,42.97 210.01,43.79 210.09,43.86 212.91,43.86
GND on TOP (solid shape): 244.95,12.06 244.95,11.34 244.84,11.23 243.46,11.23 243.26,11.03 242.87,11.03 242.64,11.26 242.64,11.9 242.92,12.18 244.83,12.18
GND on TOP (solid shape): 59.01,19.97 59.01,19.41 59.12,19.3 59.36,19.3 61.47,19.3 61.57,19.2 61.57,18.86 61.47,18.76 60.18,18.76 60.18,18.77 58.65,18.77 58.3,19.11 58.3,19.83 58.48,20.01 58.97,20.01
GND on TOP (solid shape): 201.47,43.04 201.47,40.99 201.74,40.72 202.77,40.72 202.92,40.57 202.92,40.15 202.77,39.99 198.41,39.99 198.37,40.03 198.37,40.45 198.91,40.99 199.76,40.99 199.91,41.14 199.91,43.03 200.07,43.19 201.33,43.19
GND on TOP (solid shape): 127.76,49.04 127.76,48.23 127.97,48.02 127.97,47.87 127.83,47.73 127.76,47.73 127.55,47.52 127.55,47.3 127.38,47.13 125.15,47.13 124.38,47.9 124.38,48.98 124.57,49.17 127.63,49.17
GND on TOP (solid shape): 257.31,12.25 257.31,11.27 257.27,11.23 256.84,11.23 256.77,11.3 255.9,11.3 255.84,11.24 255.41,11.24 255.35,11.3 253.62,11.3 253.55,11.23 253.48,11.23 253.48,11.23 253.13,11.23 253.03,11.33 253.03,11.61 253.7,12.28 257.28,12.28
GND on TOP (solid shape): 273.58,13.08 273.59,13.08 273.59,11.89 274.13,11.89 274.24,11.78 274.24,11.15 274.05,10.96 269.1,10.96 268.7,10.56 268,10.56 267.94,10.62 267.94,11.58 268.22,11.86 272.73,11.86 272.98,12.11 272.98,13.65 273.58,13.65
GND on TOP (solid shape): 23.09,22.8 23.17,22.79 23.26,22.8 23.27,22.81 23.4,22.81 23.4,20.83 22.78,20.83 22.78,21.46 22.19,21.46 22.19,22.17 22.78,22.17 22.78,22.7 22.83,22.75 22.88,22.81 23.08,22.81
GND on TOP (solid shape): 160.6,50.89 160.6,50.42 160.57,50.39 159.89,50.39 159.81,50.47 158.14,50.47 158.08,50.41 157.74,50.75 157.71,50.86 157.81,50.92 160.56,50.92
GND on TOP (solid shape): 14.69,43.95 16.39,43.95 16.42,43.93 16.42,43.55 16.28,43.41 14.1,43.41 14.05,43.46 14.05,43.55 14.05,43.6 14.05,43.95 14.05,44 14.05,44.06 14.12,44.13 14.51,44.13
GND on TOP (solid shape): 122.17,29.79 122.17,29.64 122.32,29.64 122.35,29.61 124.05,29.61 124.15,29.51 124.15,28.98 124.42,28.71 124.42,28.42 124.3,28.31 122.23,28.31 121.84,27.91 115.79,27.91 115.74,27.96 115.74,29.28 115.69,29.34 115.53,29.34 115.4,29.46 115.4,29.84 115.5,29.95 122.02,29.95
GND on TOP (solid shape): 150.53,13.62 150.53,7.16 151.15,6.54 153.01,6.54 153.19,6.36 153.19,5.23 153.08,5.12 149.53,5.12 149.37,5.28 149.37,6.33 149.24,6.47 148.28,6.47 148.04,6.7 148.04,12.55 147.16,13.44 147.16,13.56 147.16,13.63 147.29,13.75 150.4,13.75
GND on TOP (solid shape): 222.51,39.61 222.79,39.54 223.07,39.61 223.08,39.62 223.19,39.62 223.19,7.32 217.17,1.3 152.86,1.3 152.86,2.1 216.83,2.1 222.39,7.66 222.39,39.62 222.5,39.62
GND on TOP (solid shape): 149.98,1.9 149.97,1.89 149.94,1.7 149.97,1.51 149.98,1.5 149.98,1.3 142.85,1.3 142.85,1.58 142.86,1.7 142.85,1.82 142.85,2.1 149.98,2.1
GND on TOP (solid shape): 281.42,7.21 281.66,7.1 281.89,7.21 282.67,7.21 282.86,7.02 283.75,7.02 283.81,6.96 283.81,6.45 283.69,6.32 280.32,6.32 280.26,6.39 280.26,7.15 280.32,7.21
GND on TOP (solid shape): 111.96,40.17 111.96,33.67 112.08,33.55 112.08,32.51 111.96,32.39 111.96,24.68 112.03,24.6 112.03,22.89 112.01,22.87 111.52,22.87 111.36,23.02 111.36,23.73 111.2,23.9 110.09,23.9 109.58,24.41 108,24.41 107.93,24.48 107.93,25.18 109.28,26.53 109.28,40.07 109.57,40.36 111.77,40.36
GND on TOP (solid shape): 282.68,36.09 282.69,36.09 282.78,36 282.79,36 282.86,35.92 285.46,35.92 285.7,35.69 285.7,34.57 286.26,34.02 286.26,33.24 286.08,33.06 285.04,33.06 284.95,33.15 284.95,34.06 284.73,34.28 283.57,34.28 282.38,35.47 282.03,35.47 281.94,35.56 281.94,36.16 282,36.21 282.56,36.21
GND on TOP (solid shape): 139.49,59.14 139.67,59.14 139.76,59.05 139.76,57.84 139.81,57.79 139.82,57.74 139.77,57.71 139.72,57.71 139.62,57.7 139.53,57.66 139.48,57.66 139.45,57.7 139.44,57.71 139.44,57.82 138.95,58.31 138.95,59.13 138.95,59.14 139.48,59.14
GND on TOP (solid shape): 150.03,74.01 150.02,74 149.94,73.7 150.02,73.4 150.03,73.39 150.03,73.3 142.77,73.3 142.77,73.4 142.78,73.41 142.86,73.7 142.78,73.99 142.77,74 142.77,74.09 150.03,74.09
GND on TOP (solid shape): 9.81,13.5 10.04,13.5 10.05,13.46 10.29,13.28 10.54,13.46 10.55,13.5 10.89,13.5 11.91,12.48 14.26,12.48 14.45,12.29 14.45,11.66 14.38,11.59 9.38,11.59 8.87,12.1 6.83,12.1 6.51,12.42 6.51,14.07 6.64,14.2 9.11,14.2
GND on TOP (solid shape): 144.55,52.7 144.55,52.27 144.56,52.27 144.56,52.26 145.24,52.26 145.24,52.26 145.66,52.26 145.93,52 146.35,52 146.49,51.85 146.49,51.27 146.39,51.17 145.12,51.17 145.12,51.31 145.13,51.31 145.13,51.81 144.55,51.81 144.55,51.17 142.54,51.17 142.27,51.44 142.27,52.71 142.28,52.72 142.77,52.72 142.78,52.71 142.79,52.71 142.79,52.09 142.9,51.99 143.7,51.99 143.82,52.1 143.82,52.71 143.85,52.74 144.5,52.74
GND on TOP (solid shape): 141.82,9.39 141.82,9.04 141.68,8.9 140.73,8.9 140.53,8.69 140.53,7.62 140.25,7.34 140.25,5.48 139.58,4.81 137.96,4.81 137.72,4.58 137.19,4.58 137,4.38 137,3.79 137.04,3.75 137.46,3.75 137.53,3.68 137.53,3.32 137.44,3.22 132.91,3.22 132.69,3.43 132.69,7.47 132.84,7.62 135.71,7.62 135.96,7.87 135.96,8.19 136.35,8.57 139.2,8.57 140.09,9.46 141.75,9.46
GND on TOP (solid shape): 288.36,14.45 288.36,13.05 288.11,12.81 287.88,12.81 287.88,12.94 286.92,12.94 286.88,12.99 286.86,13.1 286.95,13.16 287.46,13.16 287.46,13.95 286.95,13.95 286.86,14.01 286.88,14.12 286.92,14.16 287.29,14.16 287.29,14.68 287.67,14.68 287.7,14.71 288.1,14.71
GND on TOP (solid shape): 88.03,54.51 88.06,54.51 88.13,54.44 88.13,46.86 87.85,46.58 85.23,46.58 83.05,46.58 82.8,46.84 76.8,46.84 76.27,46.3 76.27,43.31 75.97,43 74.19,43 74.12,43.07 74.12,48.29 74.65,48.82 83.56,48.82 83.79,48.59 83.79,47.78 84.04,47.52 84.55,47.52 84.75,47.72 84.76,47.72 84.76,47.73 84.78,47.75 84.78,48.61 84.93,48.77 85.36,48.77 85.54,48.95 85.57,48.95 85.57,48.97 86.51,49.91 86.51,54.46 86.58,54.53 88.01,54.53
GND on TOP (solid shape): 78.01,73.97 78,73.96 77.94,73.7 78,73.44 78.01,73.43 78.01,73.3 70.44,73.3 70.44,9.39 77.73,2.1 139.99,2.1 139.99,2.09 139.84,1.7 139.99,1.31 139.99,1.3 77.4,1.3 69.64,9.06 69.64,74.1 78.01,74.1
GND on TOP (solid shape): 90.27,69.65 94.27,69.65 96.16,74.1 140.01,74.1 139.84,73.7 140.01,73.3 96.69,73.3 94.8,68.85 89.74,68.85 87.85,73.3 80.84,73.3 81.01,73.7 80.84,74.1 88.38,74.1
GND on TOP (solid shape): 270.83,4.85 270.83,2.26 270.5,1.93 265.2,1.93 264.88,2.24 264.88,2.96 268.19,2.96 268.19,2.02 269.06,2.02 269.06,2.96 268.83,2.96 268.83,4.13 268.83,4.15 268.82,4.19 268.8,4.23 268.78,4.26 268.75,4.3 268.72,4.32 268.68,4.34 268.64,4.35 268.6,4.36 268.55,4.35 268.51,4.34 268.48,4.32 268.44,4.3 268.41,4.26 268.39,4.23 268.38,4.19 268.37,4.15 268.37,4.13 268.37,2.96 264.88,2.96 264.88,4.64 265.06,4.82 267.45,4.82 267.63,5 270.68,5
GND on TOP (solid shape): 14.12,44.16 14.5,44.16 14.69,43.96 16.58,43.96 16.67,43.9 16.65,43.79 16.26,43.4 14.15,43.4 14.07,43.43 14.05,43.51 14.04,43.62 13.99,43.71 13.96,43.78 13.99,43.85 14.05,43.97 14.04,44.1 14.02,44.13 14.08,44.19
GND on TOP (solid shape): 178.83,20.08 178.83,19.68 178.7,19.55 178.66,19.55 178.6,19.57 178.53,19.58 178.15,19.58 177.99,19.54 177.88,19.42 175.95,19.42 175.85,19.48 175.87,19.59 176.01,19.73 176.05,19.7 176.14,19.64 176.25,19.62 176.63,19.62 176.79,19.67 176.9,19.78 177.21,19.78 177.64,20.21 178.7,20.21
GND on TOP (solid shape): 154.15,22.73 154.26,22.75 154.32,22.66 154.32,20.5 152.63,20.5 152.33,20.19 150.89,20.19 150.64,19.94 150.46,19.94 150.46,19.76 150.36,19.66 150.36,19.44 150.14,19.23 150.14,18.69 150.11,18.6 150.09,18.51 150.09,18.49 150.04,18.44 149.93,18.55 149.93,20.73 150,20.82 150.02,20.93 150.04,21.01 150.12,21.04 151.6,21.04 151.95,21.39 153.53,21.39 153.75,21.61 153.75,22.33
GND on TOP (solid shape): 152.89,17.28 152.89,17.15 152.97,17.05 152.97,16.71 152.71,16.45 152.71,15.94 152.02,15.94 151.92,16 151.94,16.11 151.94,16.15 152.06,16.26 152.1,16.42 152.1,16.8 152.07,16.94 151.98,17.05 151.94,17.11 151.95,17.18 151.98,17.25 152,17.33 152.09,17.41 152.75,17.41
GND on TOP (solid shape): 174.05,58.19 174.23,58.19 174.34,58.07 174.5,58.03 174.88,58.03 174.97,58.04 175.05,58.09 175.16,58.09 175.21,58 175.21,57.65 175.3,57.57 175.32,57.45 175.23,57.39 174.16,57.39 174.05,57.37 173.98,57.46 173.98,57.76 173.34,57.76 173.34,58.44 173.8,58.44
GND on TOP (solid shape): 195.95,74.35 196.52,73.62 197.4,73.35 197.84,73.35 198.03,72.87 198.1,72.35 198.1,72.05 197.5,72.05 196.93,71.82 196.7,71.25 196.7,70.15 192.5,70.15 192.5,74.35
GND on TOP (solid shape): 100.1,35.08 100.07,35.05 100.07,33.6 99.98,33.37 100.07,33.15 100.07,33.09 100.32,32.84 101.68,32.84 101.69,32.83 101.95,32.83 101.97,32.84 102.11,32.84 102.55,32.4 102.85,32.4 103.3,32.84 105.47,32.84 105.82,32.49 105.82,32.1 105.7,31.98 105.54,31.98 105.48,31.91 105.48,31.37 103.78,29.67 102.41,29.67 102.31,29.56 102.31,28.04 102.25,27.99 100.45,27.99 99.92,28.52 97.78,28.52 97.45,28.85 94.66,28.85 94.58,28.93 94.58,30.35 94.61,30.38 97.56,30.38 97.68,30.5 97.68,33.3 97.84,33.45 97.86,33.45 97.99,33.58 97.99,35.23 98.09,35.33 99.84,35.33
GND on TOP (solid shape): 179.1,55.9 192.7,55.9 192.7,69.65 196.97,69.65 197.2,69.43 197.5,69.35 197.8,69.35 198.1,69.43 198.33,69.65 202.75,69.65 202.75,74.1 223.19,74.1 223.19,42.41 223.02,42.41 223.01,42.41 222.79,42.46 222.57,42.41 222.56,42.41 222.39,42.41 222.39,73.3 203.55,73.3 203.55,68.85 193.5,68.85 193.5,55.1 178.3,55.1 178.3,73.3 152.81,73.3 152.81,73.48 152.82,73.48 152.86,73.7 152.82,73.92 152.81,73.93 152.81,74.1 179.1,74.1
GND on TOP (solid shape): 155.19,19.76 155.19,19.37 155.15,19.34 155.15,18.74 154.65,18.24 154.65,17.92 154.61,17.84 154.51,17.83 154.31,17.83 154.17,17.7 154.16,17.67 153.79,17.66 153.79,19.39 153.91,19.52 154.01,19.52 154.01,19.38 154.27,19.38 154.27,19.16 154.18,19.07 154.15,18.95 154.15,18.8 154.41,18.54 154.66,18.8 154.66,18.95 154.63,19.07 154.55,19.16 154.55,19.38 154.59,19.38 154.59,19.94 155.01,19.94
GND on TOP (solid shape): 149.64,20.25 149.64,18.43 150.4,17.67 151.39,17.67 151.43,17.65 151.44,17.6 151.4,17.54 151.37,17.5 151.34,17.5 151.01,17.16 151.01,17.07 150.89,16.96 150.84,16.8 150.84,16.42 150.85,16.37 150.88,16.27 150.78,16.17 150.7,16.14 150.62,16.18 150.55,16.26 150.45,16.3 150.44,16.3 150.32,16.42 150.11,16.42 150.11,16.43 149.3,16.43 149.3,17.21 149.38,17.3 149.41,17.42 149.41,17.52 149.4,17.59 149.37,17.65 149.33,17.7 149.37,17.79 149.39,17.79 149.52,17.92 149.52,19.62 149.4,19.74 148.98,19.74 148.85,19.87 148.85,20.24 148.98,20.37 148.99,20.38 149.52,20.38
GND on TOP (solid shape): 0.82,56.7 1.28,55.57 2.42,55.1 3.42,55.1 4.55,55.57 5.01,56.7 5.91,56.7 5.91,52.35 5.33,50.94 3.91,50.35 2.37,50.35 2,50.72 1.5,50.85 0.95,50.85 0.95,51.75 0.83,52.23 0.5,52.59 0.5,56.7
GND on TOP (solid shape): 3.42,75.3 5.18,74.57 5.91,72.8 5.91,68.47 5.01,68.47 4.52,69.55 3.42,70 2.42,70 1.31,69.55 0.82,68.47 0.5,68.47 0.5,71.51 0.83,71.87 0.95,72.35 0.95,73.26 1.75,73.49 2.1,74.25 2.1,75.3
GND on TOP (solid shape): 151.27,30 151.36,29.94 151.34,29.83 151.24,29.73 151.24,28.56 151.07,28.56 151,28.59 150.97,28.66 150.73,28.88 150.49,28.66 150.45,28.59 150.39,28.56 150.16,28.56 150.09,28.59 150.05,28.66 150.02,28.77 149.94,28.85 149.94,29 149.98,29.02 150.02,29.03 150.05,29 150.48,28.99 150.24,29.34 150.17,29.36 150.13,29.41 149.98,29.58 149.76,29.61 149.68,29.63 149.64,29.69 149.62,29.77 149.57,29.84 149.56,29.95 149.65,30
GND on TOP (solid shape): 238.83,15.16 238.88,15.1 238.96,14.99 239.07,14.93 239.08,14.92 239.94,14.07 239.94,9.45 242.72,6.66 247.33,6.66 247.69,6.3 247.64,6.24 247.55,6.19 247.25,6.36 246.95,6.19 246.86,6.24 246.58,6.35 246.4,6.1 246.4,5.16 246.4,5.13 246.41,5.06 245.61,4.27 245.32,4.27 245.22,4.33 245.25,4.44 245.59,4.79 245.59,4.95 245.67,5.04 245.7,5.16 245.7,6.1 245.52,6.35 245.24,6.24 245.15,6.19 245.06,6.24 244.78,6.35 244.6,6.1 244.6,5.16 244.61,5.08 244.65,5 244.67,4.93 244.64,4.87 244.41,4.63 242.73,4.63 242.09,5.28 242.09,6.93 239.67,9.34 239.67,13.96 238.66,14.97 238.64,15.07 238.71,15.14 238.75,15.16
GND on TOP (solid shape): 156.65,24.21 156.75,24.14 156.73,24.03 156.52,23.83 156.52,22.63 156.94,22.21 156.94,20.52 157.09,20.52 157.09,20.19 156.36,20.19 156.36,19.63 156.51,19.63 156.51,19.12 156.46,19.08 156.42,19.02 156.65,18.45 156.88,19.02 156.84,19.08 156.79,19.12 156.79,19.63 157.1,19.63 157.1,15.64 156.94,15.48 156.9,15.48 156.57,15.15 156.23,15.15 156.23,15.77 155.65,15.77 155.65,16.38 155.06,16.38 155.06,15.15 153.51,15.15 153.42,15.21 153.44,15.32 153.72,15.6 153.72,16.03 153.75,16.04 153.93,16.2 153.96,16.44 153.95,16.47 153.99,16.5 153.99,17.19 153.92,17.26 153.94,17.32 153.98,17.32 154.04,17.38 154.16,17.38 154.17,17.35 154.36,17.2 154.59,17.27 154.66,17.29 154.91,17.19 155.16,17.29 155.23,17.27 155.51,17.21 155.66,17.45 155.66,17.6 155.55,17.81 155.21,17.84 155.16,17.92 155.16,18.03 155.66,18.53 155.66,19.13 155.74,19.2 155.74,19.35 155.77,19.35 155.77,19.91 155.76,19.91 155.76,19.98 155.43,20.31 155.42,20.36 155.47,20.39 155.57,20.39 155.73,20.55 155.73,22.26 156.27,22.8 156.27,24.21
GND on TOP (solid shape): outline of 1145 points within 224.22,3.63 261.07,23.59
GND on TOP (solid shape): outline of 11330 points within 0.2,0.2 293,85.65
GND on BOTTOM (solid shape): 32.47,1 20.29,1 20.29,5.05 32.47,5.05
GND on BOTTOM (solid shape): 79.34,21.04 71.34,21.04 71.34,29.04 79.34,29.04
GND on BOTTOM (solid shape): 192.2,71.25 179.2,71.25 179.2,73.25 192.2,73.25
GND on BOTTOM (solid shape): 220.99,73.9 206.49,73.9 206.49,75.9 220.99,75.9
GND on BOTTOM (solid shape): 10.42,76.48 10.42,75.37 10.39,75.34 9.82,75.34 9.8,75.36 9.8,76.16 9.49,76.46 9.49,76.9 9.58,76.99 9.9,76.99
GND on BOTTOM (solid shape): 106.84,16.51 106.84,14.83 106.23,14.83 106.23,15.01 106.25,15.02 106.25,15.68 106.3,15.78 106.32,15.9 106.32,16.46 106.41,16.55 106.8,16.55
GND on BOTTOM (solid shape): 128.07,82.06 128.07,80.2 128.03,80.11 128.03,80 127.92,79.89 127.14,79.89 127.02,80.01 127.02,81.48 126.85,81.65 126.85,82.23 126.91,82.28 127.85,82.28
GND on BOTTOM (solid shape): 14.56,48.77 14.56,47.79 15.04,47.31 15.04,46.7 14.92,46.58 12.81,46.58 12.81,48.22 12.68,48.35 10.58,48.35 10.41,48.52 10.36,48.52 10.34,48.55 10.34,48.81 10.44,48.92 14.41,48.92
GND on BOTTOM (solid shape): 102.4,54 100.4,54 100.4,70.85 94.24,70.85 94.48,71.85 94.24,72.85 100.4,72.85 100.4,75.5 102.4,75.5
GND on BOTTOM (solid shape): 203.13,33.32 203.13,31.52 203.3,31.35 203.32,31.24 203.23,31.18 203.03,31.18 202.64,31.57 202.64,33.42 202.63,33.42 202.62,33.48 202.66,33.51 202.94,33.51
GND on BOTTOM (solid shape): 10.32,42.81 10.97,42.81 10.97,42.33 10.14,42.33 10.14,42.19 9.95,42.19 9.7,42.42 9.36,42.39 9.32,42.4 9.27,42.4 9.07,42.61 9.38,42.66 9.6,42.89 9.7,42.9 9.8,42.95 10.32,42.95
GND on BOTTOM (solid shape): 244.34,9.43 244.34,8.33 243.88,7.86 240.69,7.86 240.52,8.03 240.52,9.16 240.57,9.25 240.68,9.25 240.78,9.21 240.89,9.19 241.32,9.19 241.37,9.2 241.43,9.21 242.3,9.21 242.53,9.27 242.69,9.45 242.7,9.48 242.86,9.48 243.25,9.09 243.25,8.91 243.66,8.91 243.78,8.91 243.88,9.02 243.88,9.49 243.96,9.56 244.22,9.56
GND on BOTTOM (solid shape): 178.03,37.86 178.26,37.86 178.26,36.84 178.63,36.48 178.64,36.47 178.66,36.44 178.66,36.41 178.66,36.38 178.65,36.35 178.63,36.33 178.6,36.31 178.57,36.3 178.56,36.3 176.5,36.3 176.1,36.7 175.95,36.7 175.9,36.75 175.9,37.11 175.91,37.12 176.31,37.12 176.42,37.01 176.42,36.92 176.47,36.87 178.13,36.87 178.13,37.63 177.41,37.63 177.41,36.87 177.21,36.87 177.21,37.63 177.17,37.63 177.17,38.23 177.01,38.23 177,38.24 176.76,38.24 176.75,38.23 176.64,38.23 176.64,38.68 176.71,38.75 177.14,38.75
GND on BOTTOM (solid shape): 114.05,76 107.45,76 107.45,77.59 107.57,77.56 107.7,77.55 108,77.55 108.57,77.78 108.8,78.35 108.8,79.65 108.57,80.22 108,80.45 107.7,80.45 107.57,80.44 107.45,80.41 107.45,80.82 114.05,80.82
GND on BOTTOM (solid shape): 179.9,76 173.3,76 173.3,77.59 173.42,77.56 173.55,77.55 173.85,77.55 174.42,77.78 174.65,78.35 174.65,79.65 174.42,80.22 173.85,80.45 173.55,80.45 173.42,80.44 173.3,80.41 173.3,80.82 179.9,80.82
GND on BOTTOM (solid shape): 206.18,64.58 206.29,64.61 206.35,64.51 206.35,64.29 204.42,62.36 204.42,60.46 204.8,60.08 205.43,60.08 206.7,58.81 207.54,58.81 207.86,58.49 208.84,58.49 209.24,58.89 210.85,58.89 210.95,58.78 210.95,56.87 210.33,56.26 209.6,56.26 209.6,56.26 209.47,56.26 207.36,58.38 207.33,58.38 207.26,58.44 206.66,58.44 205.46,59.64 204.15,59.64 200.8,62.98 200.8,64.07 200.83,64.14 200.9,64.17 200.94,64.13 201.09,64.13 204.35,64.13 204.75,64.54 206.13,64.54
GND on BOTTOM (solid shape): 10.34,32.94 10.43,32.9 10.49,32.52 10.76,32.38 11.24,32.38 11.35,32.4 11.45,32.46 11.63,32.46 11.66,32.42 11.88,32.42 11.88,32.32 12.02,32.32 12.02,32.22 11.69,31.89 9.64,31.89 9.14,31.38 8.14,31.38 8.04,31.49 8.04,32.76 8.07,32.83 8.15,32.86 8.26,32.87 8.34,32.94
GND on BOTTOM (solid shape): 187.36,14.52 187.47,14.54 187.53,14.45 187.53,10.43 187.54,9.97 188,9.97 188.06,9.97 188.09,9.93 188.09,9.82 188.07,9.82 188.07,6.43 189.45,6.43 189.56,6.32 189.58,6.2 189.49,6.14 185.06,6.14 184.6,6.6 184.6,9.03 186.89,11.32 186.89,14.05
GND on BOTTOM (solid shape): 182.92,28.88 183.18,28.64 183.51,28.79 183.6,28.83 183.69,28.77 183.99,28.58 184.29,28.76 184.61,28.76 186.05,27.32 186.05,22.92 184.54,21.41 181.33,21.41 179.08,23.66 179.08,25.2 177.46,26.82 177.44,26.93 177.53,26.99 179.34,26.99 181,28.66 182.15,28.66 182.36,28.88
GND on BOTTOM (solid shape): 0.82,56.7 1.28,55.57 2.42,55.1 3.42,55.1 4.55,55.57 5.01,56.7 7.9,56.7 7.9,49.8 3,49.8 2.5,49.85 2.21,50.56 1.5,50.85 0.95,50.85 0.95,51.65 0.83,52.13 0.5,52.49 0.5,56.7
GND on BOTTOM (solid shape): outline of 81 points within 179.45,27.65 185.75,35.21
GND on BOTTOM (solid shape): 187.83,60.76 187.83,59.82 187.52,59.5 187.52,58.99 187.83,58.68 187.83,56.86 187.92,56.78 188.02,56.78 188.02,56.63 187.97,56.54 187.87,56.54 187.41,56.23 187.87,55.93 187.97,55.93 188.02,55.84 188.02,54.97 187.95,54.88 187.84,54.9 187.11,55.63 180.68,55.63 178.38,53.32 178.37,53.32 178.11,53.06 177.82,53.06 177.82,53.06 177.72,53.06 177.63,53.12 177.65,53.23 181.5,57.08 182.32,57.08 182.48,57.25 182.48,60.15 182,60.63 179.42,60.63 178.07,61.97 178.07,64.68 178.4,65.01 178.4,66.69 178.61,66.89 181.71,66.89
GND on BOTTOM (solid shape): outline of 104 points within 169.59,6.2 192.81,23.54
GND on BOTTOM (solid shape): 185.16,42.12 185.11,41.83 185.37,41.69 185.39,41.69 185.48,41.6 185.55,41.6 185.56,41.57 185.69,41.45 185.87,41.46 185.91,41.46 185.94,41.43 185.96,41.39 185.96,41.33 185.89,41.33 185.76,41.2 185.76,40.28 185.85,40.19 186.85,40.19 186.89,40.15 186.89,39.84 187.04,39.69 188.26,39.69 188.51,39.94 189.62,39.94 191.11,38.45 191.11,37.96 191.07,37.92 189.23,37.92 189.18,37.99 189.12,38.04 189.1,38.06 189.1,38.1 188.78,38.56 188.51,38.07 188.5,37.97 188.42,37.92 188.08,37.92 187.41,38.59 185.62,38.59 184.82,39.39 184.82,40.44 184.69,40.57 184.6,40.64 184.49,40.67 184.48,40.67 184.13,41.02 183.93,41.02 183.93,41.15 183.94,41.15 183.94,41.65 183.36,41.65 183.36,42.25 184.81,42.25 185.02,42.46 185.02,42.49 185.16,42.49
GND on BOTTOM (solid shape): 225,19.06 225,10.55 215.06,10.55 214.49,9.98 214.26,9.98 214.17,10.04 214.19,10.15 215.19,11.15 215.19,13.38 215.39,13.58 216.29,13.58 216.37,13.54 216.39,13.46 216.39,13.43 216.39,12.18 216.54,11.95 216.82,12 216.89,12.03 216.96,12 217.24,11.95 217.4,12.18 217.4,13.43 217.39,13.46 217.42,13.54 217.49,13.58 218.29,13.58 218.37,13.54 218.39,13.46 218.39,13.43 218.39,12.18 218.64,11.93 218.9,12.18 218.9,13.43 218.89,13.46 218.92,13.54 218.99,13.58 222.32,13.58 223.96,15.22 224.39,15.65 224.47,15.73 224.47,19.13 224.56,19.23 224.83,19.23
GND on BOTTOM (solid shape): outline of 123 points within 176.13,27.28 178.87,35.33
GND on BOTTOM (solid shape): 122.8,81.85 121.69,81.85 120.49,80.65 120.49,74 139.87,74 139.92,73.99 139.96,73.95 139.91,73.55 140.17,73.25 140.33,73.17 140.5,73.14 142.3,73.14 142.75,73.37 142.85,73.96 142.93,74 149.87,74 149.95,73.96 150.05,73.37 150.5,73.14 152.3,73.14 152.75,73.37 152.85,73.96 152.93,74 170,74 170,85.65 171.13,85.65 171.27,85.62 171.42,85.58 171.76,85.4 172.04,85.12 172.23,84.76 172.3,84.35 172.3,82.74 172.3,81.82 172.35,81.55 172.5,81.32 172.5,74 173.1,74 173.1,55.41 171.1,55.41 171.1,72 113.25,72 113.25,74 117.99,74 117.99,81.49 119.8,81.49 120.3,81.69 120.5,82.19 120.5,84.44 120.9,85.28 121.74,85.65 122.8,85.65
GND on BOTTOM (solid shape): outline of 259 points within 189.68,57.03 193.19,61.96
GND on BOTTOM (solid shape): outline of 102 points within 179.62,30.32 191.64,38.43
GND on BOTTOM (solid shape): outline of 84 points within 226.29,1 272.54,7.01
GND on BOTTOM (solid shape): outline of 165 points within 8.04,32.06 17.77,37.62
GND on BOTTOM (solid shape): outline of 358 points within 225.94,7.19 244.34,21.64
GND on BOTTOM (solid shape): outline of 105 points within 119.12,13.58 150.28,23.84
GND on BOTTOM (solid shape): outline of 493 points within 178.68,37.6 193.11,53.64
GND on BOTTOM (solid shape): outline of 537 points within 7.68,37.44 17.01,46.06
GND on BOTTOM (solid shape): outline of 777 points within 205.7,50.25 218.99,62.28
GND on BOTTOM (solid shape): outline of 789 points within 94.36,17.1 128.42,50.42
GND on BOTTOM (solid shape): outline of 1193 points within 138.51,22.5 166.7,30.9
GND on BOTTOM (solid shape): outline of 1667 points within 193.57,30.13 220.69,55.5
GND on BOTTOM (solid shape): outline of 2282 points within 264.1,43.09 293,85.1
GND on BOTTOM (solid shape): outline of 12559 points within 0.2,0.2 293,85.65
GND on IN1 (solid shape): 284.51,15.28 284.51,12.29 283.05,10.83 281.4,10.83 281.21,11.02 281.21,16.04 281.46,16.29 283.5,16.29
GND on IN1 (solid shape): 249.52,8.99 249.52,6.51 248.32,5.31 240.23,5.31 239.75,5.8 239.75,7.15 240,7.4 245.02,7.4 247.05,9.43 249.08,9.43
GND on IN1 (solid shape): 292.6,67.9 292.36,67.34 291.8,67.1 291.7,67.1 291.2,66.9 291,66.4 291,63.4 291.2,62.9 291.7,62.7 292.2,62.7 292.76,62.46 293,61.9 293,60.75 292.54,60.75 292.54,61.21 292.54,61.21 292.54,61.9 292.44,62.14 292.2,62.24 291.7,62.24 290.88,62.58 290.54,63.4 290.54,66.4 290.88,67.22 291.7,67.56 291.8,67.56 292.04,67.66 292.14,67.9 292.14,68.47 292.14,68.93 292.6,68.93
GND on IN1 (solid shape): outline of 113 points within 222.09,19.33 292.6,85.1
GND on IN1 (solid shape): outline of 2336 points within 211.19,18.64 292.6,85.1
GND on IN1 (solid shape): outline of 2661 points within 0.2,0.2 293,78.07
GND on IN2 (solid shape): 282.93,15.72 282.93,11.91 282.48,11.47 281.4,11.47 281.21,11.66 281.21,15.72 281.46,15.98 282.67,15.98
GND on IN2 (solid shape): outline of 117 points within 222.09,19.33 292.6,85.1
GND on IN2 (solid shape): outline of 2818 points within 0.2,0.2 293,78.07
GND on IN3 (solid shape): 292.6,67.9 292.36,67.34 291.8,67.1 291.7,67.1 291.2,66.9 291,66.4 291,63.4 291.2,62.9 291.7,62.7 292.2,62.7 292.76,62.46 293,61.9 293,60.75 292.54,60.75 292.54,61.21 292.54,61.21 292.54,61.9 292.44,62.14 292.2,62.24 291.7,62.24 290.88,62.58 290.54,63.4 290.54,66.4 290.88,67.22 291.7,67.56 291.8,67.56 292.04,67.66 292.14,67.9 292.14,68.47 292.14,68.93 292.6,68.93
GND on IN3 (solid shape): outline of 2486 points within 0.2,0.2 293,78.07
GND on TOP: 161.81,22.24 162.42,22.24 162.45,22.2 162.45,18.91 162.42,18.88 161.83,18.88 161.75,18.96 161.75,22.18
GND on TOP: 81.15,62.97 81.15,59.31 81.29,59.17 81.29,56.86 81.17,56.74 81.1,56.74 80.51,56.16 79.6,56.16 79.5,56.06 79.5,54.63 79.42,54.56 78.3,54.56 77.99,54.88 77.99,59.52 79.47,61.01 79.47,62.74 79.75,63.02 81.1,63.02
GND on TOP: 219.36,52.88 219.36,51.76 219.25,51.64 219.25,50.34 219.3,50.29 220.26,50.29 220.33,50.36 220.33,52.88 220.26,52.95 219.44,52.95
GND on TOP: 122.29,32.09 122.21,32.17 122.21,32.83 122,33.04 115.51,33.04 115.47,33 115.47,32.7 115.25,32.48 113.25,32.48 113.17,32.56 113.17,33.58 113.24,33.64 115.2,33.64 115.5,33.94 115.5,34.17 115.63,34.3 125.09,34.3 125.32,34.07 125.32,33.23 125.13,33.04 124.35,33.04 124.21,32.9 124.21,32.22 124.07,32.09
GND on TOP: 101.49,51.79 101.49,55.29 101.39,55.4 99.88,55.4 99.76,55.27 99.76,53.42 100.53,52.66 100.53,51.76 100.58,51.71 101.42,51.71
GND on TOP: 171.17,15.52 169.92,15.52 169.79,15.39 169.79,10.23 169.95,10.08 171.09,10.08 171.24,10.23 171.24,15.44
GND on TOP: 22.42,7.88 22.7,7.59 27.91,7.59 28.29,7.97 28.29,8.86 28.1,9.05 26.19,9.05 26.07,9.18 26.07,9.94 24.99,11.02 23.69,11.02 22.42,9.75
GND on TOP: 96.42,53.95 96.18,54.18 96.18,58.34 95.98,58.54 95.98,60.01 96.05,60.07 97.45,60.07 98.58,58.94 98.58,54.31 98.23,53.95
GND on TOP: 99.89,37.59 99.71,37.77 97.58,37.77 97.02,38.33 94.48,38.33 94.41,38.4 94.41,40.94 94.56,41.1 95.78,41.1 95.8,41.07 101.47,41.07 101.7,41.3 101.7,41.83 102.08,42.21 104.69,42.21 105.15,41.76 105.15,39.29 104.82,38.96 102.61,38.96 102.38,38.73 102.38,37.26 102.24,37.12 100.38,37.12 99.91,37.59
GND on TOP: 85.16,66.9 85.21,66.85 85.21,66.35 85.15,66.29 83.51,66.29 83.46,66.34 83.46,66.86 83.5,66.9
GND on TOP: 124.02,40.23 115.54,40.23 115.46,40.16 115.46,38.19 115.55,38.1 122.02,38.1 122.09,38.17 122.09,38.42 122.21,38.53 122.56,38.53 122.68,38.64 122.68,39.03 122.77,39.11 124.02,39.11 124.12,39.22 124.12,40.13
